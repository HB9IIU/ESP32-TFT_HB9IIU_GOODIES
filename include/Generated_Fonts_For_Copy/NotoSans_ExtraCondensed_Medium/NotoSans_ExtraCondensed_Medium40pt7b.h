#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x7B, 0xFF, 0xF7, 0x80, 0xF9, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xE0, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE1, 0xC3, 0x80, 0xE1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0E, 0x1C, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x03, 0x8E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xFC, 0x3F, 0xFD,
  0xFF, 0xEF, 0xB3, 0xBC, 0xC0, 0xE3, 0x03, 0x8C, 0x0E, 0x30, 0x3C, 0xC0,
  0xFB, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x37,
  0x80, 0xCF, 0x03, 0x3C, 0x0C, 0x70, 0x33, 0xE0, 0xCF, 0xF3, 0xFB, 0xFF,
  0xCF, 0xFE, 0x0F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0E,
  0x00, 0xF0, 0x1F, 0x80, 0x70, 0x0F, 0xE0, 0x38, 0x0E, 0x78, 0x38, 0x07,
  0x1C, 0x1C, 0x03, 0x8E, 0x0E, 0x01, 0xC7, 0x0E, 0x01, 0xE3, 0x87, 0x00,
  0xF1, 0xC3, 0x80, 0x78, 0xE3, 0x80, 0x1C, 0x71, 0xC0, 0x0E, 0x38, 0xE1,
  0x07, 0x1C, 0xE3, 0xE3, 0x8E, 0x73, 0xF9, 0xCF, 0x73, 0xDC, 0x7F, 0x39,
  0xC7, 0x3F, 0x1C, 0xE3, 0x87, 0x1C, 0x71, 0xC0, 0x0E, 0x78, 0xE0, 0x07,
  0x3C, 0x70, 0x07, 0x1E, 0x38, 0x03, 0x8F, 0x1C, 0x01, 0xC3, 0x8E, 0x01,
  0xC1, 0xC7, 0x00, 0xE0, 0xE3, 0x80, 0xF0, 0x71, 0xC0, 0x70, 0x3D, 0xC0,
  0x38, 0x0F, 0xE0, 0x38, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0x7C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x1E, 0x7D, 0xE3, 0xCF, 0x3C,
  0x7B, 0xE3, 0xCE, 0x78, 0x3F, 0xCF, 0x07, 0xF9, 0xE0, 0x7E, 0x3C, 0x0F,
  0xC7, 0x80, 0xF0, 0xF8, 0x3F, 0x0F, 0x8F, 0xF1, 0xFF, 0xFE, 0x1F, 0xF9,
  0xE1, 0xFC, 0x3E, 0xFF, 0xBD, 0xEF, 0x39, 0xCE, 0x73, 0x9C, 0x07, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F,
  0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x3C, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x10,
  0xE1, 0x7B, 0xBD, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x7B, 0x81,
  0xCF, 0x0F, 0x1E, 0x18, 0x70, 0x21, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0xF3, 0xCF, 0x39, 0xE7,
  0x9C, 0x73, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x80,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFE, 0x1F, 0xFC, 0x78, 0xF9,
  0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0x78, 0x79, 0xF3,
  0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x1F,
  0xCF, 0x77, 0xDF, 0xE7, 0x71, 0xC8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xE7, 0xFF, 0xC3, 0x07, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xEF, 0xC2, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3D, 0xC1, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0x78, 0x07, 0x78, 0x07, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x1C,
  0x78, 0x38, 0x78, 0x38, 0x78, 0x70, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xE0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x80, 0xFB, 0x07, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x03, 0xF8,
  0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xBF, 0xEF, 0xCF,
  0xBE, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x79, 0xF3, 0xE3, 0xFF, 0x07, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xF3, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0xBC, 0x0F, 0x78,
  0x1C, 0xF0, 0x78, 0xF0, 0xF1, 0xF3, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF8, 0x3E, 0xF8, 0xF8, 0xF9, 0xE0, 0xFB, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x1E, 0xF8, 0x78, 0xFF, 0xF1, 0xFF,
  0xC0, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0xC7, 0x87,
  0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xF7, 0x83, 0xEF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xDE, 0x3F,
  0xBC, 0x1C, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x33, 0xFF,
  0xF7, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xBC,
  0x18, 0xF7, 0xDF, 0x3C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0xCF, 0x3C, 0xE7, 0x9E, 0x71, 0xCF, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00,
  0xE0, 0x01, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0x3F, 0xF8, 0xFF, 0xE2, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0F, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x70, 0x3F, 0x1C, 0xE1, 0xFF, 0x1D, 0xC3, 0xDE, 0x3F,
  0x0E, 0x3C, 0x7E, 0x1C, 0x70, 0xFC, 0x78, 0xE1, 0xF8, 0xE1, 0xC3, 0xF1,
  0xC3, 0x87, 0xE3, 0x87, 0x0F, 0xC7, 0x0E, 0x1F, 0x8E, 0x1C, 0x3F, 0x1C,
  0x38, 0x7E, 0x3C, 0xF1, 0xDC, 0x39, 0xF3, 0xB8, 0x7F, 0x7E, 0x78, 0x7C,
  0xF8, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x08, 0x01, 0xF8, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xE7, 0x80,
  0x3C, 0x70, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80,
  0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x1E, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xEF, 0xFF, 0x9F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0xF0, 0x7D, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE1, 0xFB, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3,
  0xE0, 0x47, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x1C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0,
  0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x01,
  0x8F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0xC1, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1F, 0x0F, 0x7F, 0xBF, 0xDF, 0xCF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0,
  0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xEE, 0x00, 0xFF, 0xEE,
  0x00, 0xEF, 0xFF, 0x00, 0xEF, 0xF7, 0x01, 0xEF, 0xF7, 0x01, 0xCF, 0xF7,
  0x01, 0xCF, 0xF7, 0x81, 0xCF, 0xF3, 0x83, 0xCF, 0xF3, 0x83, 0x8F, 0xF3,
  0xC3, 0x8F, 0xF3, 0xC7, 0x8F, 0xF1, 0xC7, 0x8F, 0xF1, 0xC7, 0x0F, 0xF1,
  0xE7, 0x0F, 0xF0, 0xEF, 0x0F, 0xF0, 0xEE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x38, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xBC, 0x0F, 0xEF,
  0x03, 0xFD, 0xC0, 0xFF, 0x78, 0x3F, 0xCE, 0x0F, 0xF3, 0xC3, 0xFC, 0xF0,
  0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0xE3, 0xFC, 0x3C, 0xFF, 0x0F, 0x3F,
  0xC1, 0xEF, 0xF0, 0x7B, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0xE3,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xEF, 0x1F, 0xBF, 0xFC,
  0xFF, 0xE3, 0xFE, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8,
  0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0xE3,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0xF8, 0xF0,
  0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF3,
  0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0x07,
  0xE0, 0x7F, 0xF3, 0xFF, 0xCF, 0xFE, 0x7C, 0x19, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x7F, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x7C,
  0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x78, 0xF0,
  0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x70, 0x3C, 0x1E, 0x0E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x38, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00,
  0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x3C, 0x03, 0xFC, 0x03, 0xE0, 0x1E,
  0xF0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0x79, 0xE0,
  0x3F, 0x03, 0xCF, 0x03, 0xB8, 0x1E, 0x38, 0x1D, 0xC0, 0xF1, 0xE0, 0xEE,
  0x0F, 0x0F, 0x07, 0x70, 0x78, 0x78, 0x3B, 0xC3, 0xC3, 0xC3, 0xDE, 0x1E,
  0x0E, 0x1C, 0x70, 0xF0, 0x78, 0xE3, 0x8F, 0x03, 0xC7, 0x1C, 0x78, 0x1E,
  0x38, 0xF3, 0xC0, 0xF3, 0xC7, 0x9E, 0x03, 0x9C, 0x1C, 0xE0, 0x1E, 0xE0,
  0xEF, 0x00, 0xF7, 0x07, 0x78, 0x07, 0xB8, 0x3B, 0xC0, 0x3F, 0xC1, 0xDE,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x1C, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0x78, 0xF0,
  0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xEF, 0x80,
  0xF8, 0xF0, 0x0F, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE1,
  0xE0, 0xF0, 0xF0, 0x70, 0x38, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x03, 0x9E,
  0x01, 0xEF, 0x00, 0xF7, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3D, 0xC0,
  0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC3, 0x80,
  0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x0F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x86, 0x1E, 0x10, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xF7, 0x87, 0xDF, 0xFF, 0x7F, 0x9C, 0xFC, 0x70,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF1, 0xE1, 0xE7, 0xF3, 0xDF, 0xE7, 0xF3, 0xEF, 0xC3,
  0xDF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xF0, 0xF7, 0xFF, 0xEF, 0x7F, 0x9E, 0x7E, 0x00, 0x0F, 0xC1, 0xFF,
  0x3F, 0xE7, 0xEE, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x0F, 0x1C, 0xFE, 0x77,
  0xFD, 0xDF, 0x7F, 0x78, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xFF, 0x3F, 0xDC, 0x7E, 0x70, 0x0F,
  0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x78, 0x7B, 0xC0, 0xEF, 0x03, 0xBC,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC1, 0x8F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xC0, 0x01, 0xC0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xC1, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0x1C, 0xFE, 0x73, 0xFD, 0xDF, 0x3F, 0x78, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xF7,
  0x3F, 0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xD0, 0x1E, 0x7F, 0xF9, 0xFF, 0xC7, 0xFE, 0x01, 0x80, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF1,
  0xE3, 0xDF, 0xEF, 0x7F, 0xBF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x70, 0x77, 0xBF, 0xF7, 0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x0E, 0x1E, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0xFE, 0xFC, 0xFC,
  0x60, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x7F, 0x81, 0xEE, 0x0F, 0x38, 0x3C, 0xE1, 0xE3,
  0x8F, 0x0E, 0x3C, 0x39, 0xE0, 0xEF, 0x03, 0xBC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFB, 0xC3, 0xCF, 0x0E, 0x1E, 0x38, 0x78, 0xE1, 0xE3, 0x83, 0xCE, 0x0F,
  0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0xF8,
  0xF7, 0xF1, 0xFC, 0xF7, 0xFB, 0xFE, 0xFE, 0xFF, 0xBE, 0xF8, 0x7E, 0x1E,
  0xF8, 0x3E, 0x1F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF1, 0xE3, 0xDF, 0xEF, 0x7F, 0xBF, 0xFF, 0xFC, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3,
  0xF7, 0xC7, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x0E, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x78, 0x1E,
  0xF0, 0x3C, 0xF0, 0x79, 0xE1, 0xE1, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00,
  0xF1, 0xE1, 0xE7, 0xF3, 0xDF, 0xE7, 0xF3, 0xEF, 0xC3, 0xDF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xF7,
  0xFF, 0xEF, 0x7F, 0x9E, 0x7E, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0F, 0x1C, 0xFE, 0x77, 0xFD, 0xDF, 0x7F, 0x78, 0x7F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xF7, 0x3F,
  0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE1, 0xFC, 0xFF, 0x7F,
  0xFF, 0xFE, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x0F, 0xC3, 0xFF, 0x7F, 0xE7, 0x8E, 0xF0, 0x2F, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0xC1, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xBF, 0xEF, 0xFB, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x03, 0xC0, 0xFF, 0x3F, 0xC7, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D,
  0xE1, 0xF7, 0x8F, 0xDF, 0xF7, 0x3F, 0xDC, 0x7E, 0x70, 0xF0, 0x0F, 0xF0,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x03, 0xDE,
  0x0F, 0x81, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF3, 0xC3, 0xB8, 0x78,
  0xE1, 0xDC, 0x38, 0x78, 0xEE, 0x1C, 0x3C, 0x77, 0x1E, 0x1E, 0x3B, 0x8F,
  0x0F, 0x38, 0xE7, 0x83, 0x9C, 0x73, 0x81, 0xEE, 0x39, 0xC0, 0xF7, 0x1D,
  0xE0, 0x7B, 0x8E, 0xF0, 0x1D, 0xC7, 0x70, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x0F, 0x80, 0x78, 0x1E, 0xF0, 0x78, 0xF0, 0xF1, 0xE1, 0xE1, 0xC7, 0x83,
  0xCF, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0x78, 0x1E, 0x78, 0x78, 0xF0,
  0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xDF, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x1F, 0x07, 0xF0,
  0x7E, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xF0, 0x3F, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xF0, 0x7E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0xFC,
  0x1F, 0x83, 0xC0, 0x00, 0x3C, 0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xE7, 0xFF,
  0x80, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 29, 10, 2, -29 },
  { 20, 12, 11, 16, 2, -29 },
  { 37, 17, 29, 19, 1, -29 },
  { 99, 14, 32, 18, 2, -30 },
  { 155, 25, 29, 28, 1, -29 },
  { 246, 19, 29, 20, 1, -29 },
  { 315, 5, 11, 9, 2, -29 },
  { 322, 9, 35, 12, 2, -29 },
  { 362, 9, 35, 12, 1, -29 },
  { 402, 14, 14, 16, 1, -30 },
  { 427, 15, 19, 18, 1, -24 },
  { 463, 6, 10, 9, 1, -5 },
  { 471, 9, 4, 11, 1, -13 },
  { 476, 5, 5, 9, 2, -5 },
  { 480, 14, 29, 15, 1, -29 },
  { 531, 14, 29, 18, 2, -29 },
  { 582, 10, 29, 18, 2, -29 },
  { 619, 15, 29, 18, 1, -29 },
  { 674, 15, 29, 18, 1, -29 },
  { 729, 16, 29, 18, 1, -29 },
  { 787, 14, 29, 18, 2, -29 },
  { 838, 14, 29, 18, 2, -29 },
  { 889, 15, 29, 18, 1, -29 },
  { 944, 15, 29, 18, 1, -29 },
  { 999, 15, 29, 18, 1, -29 },
  { 1054, 5, 22, 9, 2, -22 },
  { 1068, 6, 27, 9, 1, -22 },
  { 1089, 15, 18, 18, 1, -23 },
  { 1123, 15, 12, 18, 1, -20 },
  { 1146, 15, 18, 18, 1, -23 },
  { 1180, 13, 29, 13, 0, -29 },
  { 1228, 23, 32, 27, 2, -29 },
  { 1320, 19, 29, 19, 0, -29 },
  { 1389, 15, 29, 20, 3, -29 },
  { 1444, 15, 29, 18, 2, -29 },
  { 1499, 16, 29, 21, 3, -29 },
  { 1557, 12, 29, 16, 3, -29 },
  { 1601, 12, 29, 16, 3, -29 },
  { 1645, 18, 29, 22, 2, -29 },
  { 1711, 16, 29, 22, 3, -29 },
  { 1769, 9, 29, 12, 1, -29 },
  { 1802, 9, 37, 10, -2, -29 },
  { 1844, 16, 29, 19, 3, -29 },
  { 1902, 12, 29, 15, 3, -29 },
  { 1946, 24, 29, 29, 3, -29 },
  { 2033, 18, 29, 23, 3, -29 },
  { 2099, 19, 29, 23, 2, -29 },
  { 2168, 14, 29, 18, 3, -29 },
  { 2219, 19, 36, 23, 2, -29 },
  { 2305, 16, 29, 19, 3, -29 },
  { 2363, 14, 29, 17, 1, -29 },
  { 2414, 15, 29, 16, 0, -29 },
  { 2469, 16, 29, 21, 3, -29 },
  { 2527, 18, 29, 18, 0, -29 },
  { 2593, 29, 29, 29, 0, -29 },
  { 2699, 17, 29, 17, 0, -29 },
  { 2761, 17, 29, 17, 0, -29 },
  { 2823, 13, 29, 15, 1, -29 },
  { 2871, 8, 35, 12, 3, -29 },
  { 2906, 14, 29, 15, 1, -29 },
  { 2957, 9, 35, 12, 1, -29 },
  { 2997, 17, 16, 19, 1, -29 },
  { 3031, 17, 3, 17, 0, 3 },
  { 3038, 8, 7, 11, 2, -31 },
  { 3045, 14, 22, 17, 1, -22 },
  { 3084, 15, 30, 19, 2, -30 },
  { 3141, 12, 22, 14, 2, -22 },
  { 3174, 14, 30, 19, 2, -30 },
  { 3227, 14, 22, 17, 2, -22 },
  { 3266, 12, 31, 11, 0, -31 },
  { 3313, 14, 32, 19, 2, -22 },
  { 3369, 14, 30, 19, 2, -30 },
  { 3422, 5, 30, 9, 2, -30 },
  { 3441, 8, 40, 9, -1, -30 },
  { 3481, 14, 30, 17, 3, -30 },
  { 3534, 4, 30, 9, 2, -30 },
  { 3549, 24, 22, 28, 2, -22 },
  { 3615, 14, 22, 19, 2, -22 },
  { 3654, 15, 22, 18, 2, -22 },
  { 3696, 15, 32, 19, 2, -22 },
  { 3756, 14, 32, 19, 2, -22 },
  { 3812, 10, 22, 13, 2, -22 },
  { 3840, 12, 22, 14, 1, -22 },
  { 3873, 10, 26, 11, 1, -26 },
  { 3906, 14, 22, 19, 2, -22 },
  { 3945, 16, 22, 16, 0, -22 },
  { 3989, 25, 22, 25, 0, -22 },
  { 4058, 15, 22, 16, 0, -22 },
  { 4100, 16, 32, 16, 0, -22 },
  { 4164, 11, 22, 13, 1, -22 },
  { 4195, 12, 35, 14, 1, -29 },
  { 4248, 3, 40, 17, 7, -31 },
  { 4263, 11, 35, 14, 2, -29 },
  { 4312, 16, 6, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Medium40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM40PT7B_H_
