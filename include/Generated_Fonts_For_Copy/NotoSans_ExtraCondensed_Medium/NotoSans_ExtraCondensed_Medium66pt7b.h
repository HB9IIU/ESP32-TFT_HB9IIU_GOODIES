#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xF9, 0xC1, 0xCF, 0xE3, 0x80, 0x9F, 0x87,
  0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xF8, 0x70,
  0x03, 0xF0, 0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0xE3, 0x80, 0x0F, 0xF7, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x0E, 0x7F, 0x00, 0x1C, 0x7F, 0x00, 0x38, 0x7E, 0x00, 0x70, 0xFC, 0x00,
  0xE0, 0xF8, 0x01, 0xC1, 0xF0, 0x03, 0x83, 0xE0, 0x07, 0x0F, 0xE0, 0x0E,
  0x1F, 0xE0, 0x1C, 0x7F, 0xF0, 0x39, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x01, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0xC1, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x87,
  0xC0, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7E, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x0F, 0x87, 0xF8, 0x1F,
  0x07, 0xC7, 0xC3, 0xFF, 0x07, 0xC1, 0xF1, 0xF1, 0xFF, 0xE0, 0xF8, 0x7C,
  0x7C, 0x7F, 0xFC, 0x3E, 0x3E, 0x3E, 0x3F, 0x1F, 0x0F, 0xFF, 0x8F, 0x8F,
  0x87, 0xC1, 0xFF, 0xC3, 0xE3, 0xE0, 0xF8, 0x3F, 0xF1, 0xF0, 0xF8, 0x3E,
  0x07, 0xF0, 0x7C, 0x7E, 0x0F, 0x80, 0x78, 0x1F, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xF0, 0x7F, 0xFE, 0x07, 0xE1,
  0xFC, 0xFC, 0x0F, 0xC7, 0xF1, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F,
  0x81, 0xF8, 0xFC, 0x7F, 0x03, 0xF9, 0xF8, 0xFE, 0x03, 0xFF, 0xF1, 0xF8,
  0x07, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0x0F, 0xC0,
  0x0F, 0xFC, 0x1F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFC,
  0x7F, 0x03, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1F, 0x03, 0x3E, 0x3E,
  0x3E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x01, 0xF8,
  0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFF,
  0x1F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0x3F, 0xFF, 0xBF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xF7, 0xC3, 0xF9, 0xC1,
  0xFC, 0x40, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xFC, 0x3C, 0x01, 0xFC, 0x18,
  0x00, 0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3E, 0x03, 0xFC, 0x38, 0x01, 0xFE, 0x10,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x80,
  0x00, 0xFE, 0xE0, 0x01, 0xFE, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xDF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1E,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x40, 0x01, 0xFE,
  0xC0, 0x07, 0xF9, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFE, 0x02, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x07, 0xE3, 0xFF, 0x0F, 0xCF, 0xFF, 0x1F,
  0xBF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0x81, 0xFD, 0xFE,
  0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFC, 0x7F, 0x03, 0xF8,
  0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xE0,
  0x3F, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F,
  0x07, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x20, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x18, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7C, 0x1F, 0xE2, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x1F, 0x0F,
  0xC0, 0x3F, 0xFC, 0x3E, 0x1F, 0x01, 0xFF, 0xF8, 0x7C, 0x3E, 0x07, 0xFF,
  0xF0, 0x7C, 0xF8, 0x0F, 0xC7, 0xE0, 0xF9, 0xF0, 0x3F, 0x0F, 0xC1, 0xF3,
  0xE0, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x07, 0xDF, 0x83, 0xE0,
  0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0xF8, 0x0F, 0x7C, 0x0F, 0x81, 0xF0, 0x1F,
  0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0xF0, 0x7E, 0x07, 0xC0, 0x7B, 0xE0, 0xFC,
  0x0F, 0x81, 0xF7, 0xC1, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xE0, 0x3E, 0x07,
  0xDF, 0x07, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0xC0, 0xF8, 0x1F, 0x7C, 0x1F,
  0x83, 0xF0, 0x3E, 0xF8, 0x1F, 0x07, 0xE0, 0x7D, 0xF0, 0x3E, 0x0F, 0xC1,
  0xF3, 0xE0, 0x7C, 0x1F, 0x83, 0xE7, 0xE0, 0xFC, 0x77, 0x8F, 0xC7, 0xC0,
  0xFF, 0xEF, 0xFF, 0x0F, 0x81, 0xFF, 0xCF, 0xFC, 0x1F, 0x01, 0xFF, 0x1F,
  0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3E, 0x00, 0x40, 0x04, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xE0, 0xFF, 0xF3, 0xF0, 0x07, 0xF9, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7F,
  0x1F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0x3F, 0x00,
  0x7F, 0x9F, 0x80, 0x1F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFB,
  0xF0, 0x01, 0xFD, 0xF8, 0x01, 0xFE, 0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0xF0, 0x3F, 0xC0, 0x0C, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x40, 0x7F, 0xE0, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0xFF, 0x87, 0xE0, 0x0F, 0xF8, 0xFC,
  0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x07,
  0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xE0, 0x0F, 0xF0, 0xFC,
  0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0x03, 0xFE, 0x00,
  0x1C, 0x0F, 0xF0, 0x00, 0x20, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x81,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x8F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x07,
  0xF0, 0x0F, 0xC3, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFB, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xF3,
  0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0xFF, 0xFF, 0xC0, 0x00, 0x7D, 0xFF, 0xFF,
  0x80, 0x01, 0xFB, 0xFF, 0xDF, 0x00, 0x03, 0xF7, 0xFF, 0xBF, 0x00, 0x07,
  0xCF, 0xFF, 0x7E, 0x00, 0x1F, 0x9F, 0xFE, 0x7C, 0x00, 0x3F, 0x3F, 0xFC,
  0xFC, 0x00, 0x7C, 0xFF, 0xF9, 0xF8, 0x00, 0xF9, 0xFF, 0xF3, 0xF0, 0x03,
  0xF3, 0xFF, 0xE3, 0xE0, 0x07, 0xE7, 0xFF, 0xC7, 0xE0, 0x0F, 0x8F, 0xFF,
  0x8F, 0xC0, 0x3F, 0x1F, 0xFF, 0x0F, 0x80, 0x7E, 0x3F, 0xFE, 0x1F, 0x00,
  0xF8, 0x7F, 0xFC, 0x3F, 0x01, 0xF0, 0xFF, 0xF8, 0x7E, 0x07, 0xE1, 0xFF,
  0xF0, 0x7C, 0x0F, 0xC3, 0xFF, 0xE0, 0xFC, 0x1F, 0x07, 0xFF, 0xC1, 0xF8,
  0x3E, 0x0F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0xFF, 0x03, 0xE1, 0xF0, 0x3F,
  0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0xF8, 0x0F,
  0x9F, 0x81, 0xFF, 0xF0, 0x1F, 0x3E, 0x03, 0xFF, 0xE0, 0x3F, 0x7C, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xDF, 0x80, 0x1F, 0xFE, 0xFC, 0x00, 0xFF, 0xF3, 0xF0,
  0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xFC, 0xFE, 0x01, 0xFF, 0xE3, 0xF0, 0x0F,
  0xFF, 0x1F, 0xC0, 0x7F, 0xF8, 0x7E, 0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0xFE,
  0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x83, 0xF8, 0x3F, 0xFC, 0x0F,
  0xC1, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF, 0x01, 0xF8, 0x7F, 0xF8, 0x0F, 0xC3,
  0xFF, 0xC0, 0x7F, 0x1F, 0xFE, 0x01, 0xF8, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF,
  0x80, 0x3F, 0x3F, 0xFC, 0x01, 0xFD, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0x00,
  0x3F, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0x01, 0xFF, 0x7E, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x7F, 0xBF,
  0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x3F, 0x01, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0x1F, 0xE0, 0x1C, 0x7F, 0x80, 0x08,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFD, 0xF0, 0x07, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xFE,
  0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x7C, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x7C, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x7C, 0x03,
  0xF8, 0x0F, 0xC0, 0x3E, 0x7C, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x3E, 0x07,
  0xF0, 0x0F, 0xE0, 0x7C, 0x3E, 0x07, 0xF0, 0x07, 0xE0, 0x7C, 0x3E, 0x07,
  0xF0, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xF8, 0x1F, 0x0F, 0xE0, 0x07, 0xF0, 0xF8, 0x1F, 0x0F,
  0xE0, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0x9F,
  0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0x9F, 0xC0, 0x01, 0xF9, 0xF0, 0x0F, 0x9F,
  0x80, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x07, 0xDF,
  0x80, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE3,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3C, 0x0F, 0xE0, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x7F,
  0xDF, 0xF7, 0xDF, 0x3F, 0xFF, 0x7C, 0xFF, 0xF9, 0xF1, 0xFF, 0xC7, 0xC3,
  0xFE, 0x0F, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x7F, 0x01, 0xF8, 0xFF, 0xC0, 0xFC, 0xFF, 0xF8, 0x7E, 0xFF,
  0xFC, 0x3F, 0x7F, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xF8, 0x0F, 0xE7, 0xF8,
  0x07, 0xF3, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0x9F, 0xF0, 0x1F, 0xCF, 0xFC,
  0x1F, 0xE7, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF1, 0xF9, 0xFF, 0xF0, 0xFC,
  0x7F, 0xF0, 0x7C, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFE, 0x3C,
  0x3F, 0x80, 0x47, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x02,
  0x3F, 0xC0, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x3F, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFC, 0x1F,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x01, 0x0F, 0xF0, 0x0E, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xFC, 0x20, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x07, 0xFE,
  0x1F, 0x0F, 0xFF, 0x1F, 0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC7,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF,
  0x3F, 0x0F, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x60, 0x00, 0xFE, 0x78, 0x03,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xF0, 0x7E, 0x3F, 0xF8, 0xFC, 0xFF, 0xF1, 0xFB, 0xFF, 0xF3, 0xF7,
  0xFF, 0xF7, 0xFF, 0xBF, 0xEF, 0xF8, 0x1F, 0xDF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFC, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF,
  0x8F, 0xF0, 0x7C, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFE, 0x00, 0xFD, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x9F,
  0x80, 0xFF, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00,
  0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xE1, 0xFF, 0x83, 0xFF, 0x8F, 0x8F, 0xFF,
  0x1F, 0xFF, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFB,
  0xFF, 0x9F, 0xFF, 0x1F, 0xEF, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0xE3, 0xE3, 0xFF, 0xC7,
  0xEF, 0xFF, 0xCF, 0xDF, 0xFF, 0xDF, 0xFC, 0x7F, 0xBF, 0xE0, 0x7F, 0x7F,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x1F, 0xC0, 0x7C, 0x3F,
  0xF8, 0x3F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFF, 0x0F, 0xDF, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF3, 0xFE, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7,
  0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0,
  0x07, 0xE7, 0xFC, 0x07, 0xF3, 0xFF, 0x07, 0xF9, 0xFB, 0xFF, 0xF8, 0xFD,
  0xFF, 0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0x1F, 0xFC, 0x1F, 0x87, 0xFC, 0x0F,
  0xC0, 0x70, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x1F, 0x07, 0xFE, 0x1F, 0x0F, 0xFF, 0x1F, 0x1F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0x7F, 0x81, 0xFF, 0x7F,
  0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFE, 0x3F, 0x03,
  0xFC, 0x3F, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xFD, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFE, 0x0F, 0xBF, 0x80, 0x27, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE1,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x70,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xE0, 0x7F, 0xDF, 0xE1, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E, 0x7F,
  0xFC, 0xFC, 0x7F, 0xF0, 0xF8, 0x7F, 0xC1, 0xF0, 0x0E, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0xFC,
  0x00, 0xFF, 0x00, 0x7E, 0xFE, 0x01, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xFF,
  0x00, 0x7E, 0x7E, 0x01, 0xFF, 0x00, 0xFE, 0x7E, 0x01, 0xFF, 0x80, 0xFC,
  0x7E, 0x01, 0xEF, 0x80, 0xFC, 0x7F, 0x03, 0xEF, 0x80, 0xFC, 0x3F, 0x03,
  0xEF, 0x80, 0xFC, 0x3F, 0x03, 0xE7, 0x81, 0xF8, 0x3F, 0x03, 0xE7, 0xC1,
  0xF8, 0x3F, 0x03, 0xE7, 0xC1, 0xF8, 0x1F, 0x87, 0xC7, 0xC1, 0xF8, 0x1F,
  0x87, 0xC7, 0xC1, 0xF8, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x1F, 0x87, 0xC3,
  0xE3, 0xF0, 0x1F, 0x87, 0xC3, 0xE3, 0xF0, 0x0F, 0xCF, 0x83, 0xE3, 0xF0,
  0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0x0F, 0xCF,
  0x83, 0xE7, 0xE0, 0x0F, 0xCF, 0x81, 0xF7, 0xE0, 0x07, 0xCF, 0x81, 0xF7,
  0xE0, 0x07, 0xEF, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F,
  0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x1F, 0xFE, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 48, 16, 4, -47 },
  { 49, 19, 17, 26, 4, -47 },
  { 90, 29, 47, 31, 1, -47 },
  { 261, 23, 54, 29, 3, -50 },
  { 417, 42, 49, 46, 2, -48 },
  { 675, 31, 49, 33, 2, -48 },
  { 865, 7, 17, 14, 4, -47 },
  { 880, 15, 57, 20, 3, -47 },
  { 987, 15, 57, 20, 2, -47 },
  { 1094, 23, 23, 27, 2, -50 },
  { 1161, 25, 31, 29, 2, -39 },
  { 1258, 10, 17, 15, 2, -8 },
  { 1280, 15, 6, 19, 2, -21 },
  { 1292, 8, 10, 15, 4, -9 },
  { 1302, 23, 47, 25, 1, -47 },
  { 1438, 23, 49, 29, 3, -48 },
  { 1579, 17, 47, 29, 4, -47 },
  { 1679, 24, 48, 29, 2, -48 },
  { 1823, 24, 49, 29, 2, -48 },
  { 1970, 27, 47, 29, 1, -47 },
  { 2129, 23, 48, 29, 3, -47 },
  { 2267, 23, 49, 29, 3, -48 },
  { 2408, 25, 47, 29, 2, -47 },
  { 2555, 25, 49, 29, 2, -48 },
  { 2709, 24, 49, 29, 2, -48 },
  { 2856, 8, 37, 16, 4, -36 },
  { 2893, 10, 45, 16, 2, -36 },
  { 2950, 25, 29, 29, 2, -38 },
  { 3041, 25, 19, 29, 2, -33 },
  { 3101, 25, 29, 29, 2, -38 },
  { 3192, 20, 49, 22, 1, -48 },
  { 3315, 39, 53, 44, 3, -48 },
  { 3574, 31, 47, 31, 0, -47 },
  { 3757, 25, 47, 32, 5, -47 },
  { 3904, 26, 49, 30, 3, -48 },
  { 4064, 27, 47, 35, 5, -47 },
  { 4223, 19, 47, 27, 5, -47 },
  { 4335, 19, 47, 26, 5, -47 },
  { 4447, 30, 49, 36, 3, -48 },
  { 4631, 27, 47, 36, 5, -47 },
  { 4790, 15, 47, 19, 2, -47 },
  { 4879, 14, 60, 16, -3, -47 },
  { 4984, 26, 47, 31, 5, -47 },
  { 5137, 19, 47, 25, 5, -47 },
  { 5249, 39, 47, 48, 5, -47 },
  { 5479, 29, 47, 39, 5, -47 },
  { 5650, 31, 49, 37, 3, -48 },
  { 5840, 23, 47, 30, 5, -47 },
  { 5976, 31, 59, 37, 3, -48 },
  { 6205, 26, 47, 31, 5, -47 },
  { 6358, 23, 49, 27, 2, -48 },
  { 6499, 24, 47, 26, 1, -47 },
  { 6640, 27, 48, 35, 4, -47 },
  { 6802, 30, 47, 30, 0, -47 },
  { 6979, 48, 47, 48, 0, -47 },
  { 7261, 28, 47, 28, 0, -47 },
  { 7426, 27, 47, 27, 0, -47 },
  { 7585, 23, 47, 25, 1, -47 },
  { 7721, 15, 58, 21, 4, -47 },
  { 7830, 23, 47, 25, 1, -47 },
  { 7966, 14, 58, 21, 2, -47 },
  { 8068, 29, 26, 31, 1, -47 },
  { 8163, 28, 4, 28, 0, 6 },
  { 8177, 13, 11, 18, 3, -51 },
  { 8195, 22, 37, 28, 2, -36 },
  { 8297, 25, 51, 31, 4, -50 },
  { 8457, 20, 37, 24, 3, -36 },
  { 8550, 24, 51, 31, 3, -50 },
  { 8703, 23, 37, 28, 3, -36 },
  { 8810, 18, 50, 18, 1, -50 },
  { 8923, 24, 52, 31, 3, -36 },
  { 9079, 23, 50, 31, 4, -50 },
  { 9223, 7, 49, 15, 4, -49 },
  { 9266, 12, 65, 15, -1, -49 },
  { 9364, 24, 50, 28, 4, -50 },
  { 9514, 6, 50, 15, 4, -50 },
  { 9552, 38, 36, 46, 4, -36 },
  { 9723, 23, 36, 31, 4, -36 },
  { 9827, 25, 37, 30, 3, -36 },
  { 9943, 25, 52, 31, 4, -36 },
  { 10106, 24, 52, 31, 3, -36 },
  { 10262, 16, 36, 21, 4, -36 },
  { 10334, 19, 37, 23, 2, -36 },
  { 10422, 16, 45, 18, 1, -44 },
  { 10512, 23, 37, 31, 4, -36 },
  { 10619, 26, 36, 26, 0, -36 },
  { 10736, 40, 36, 41, 1, -36 },
  { 10916, 24, 36, 26, 1, -36 },
  { 11024, 26, 52, 26, 0, -36 },
  { 11193, 18, 36, 21, 2, -36 },
  { 11274, 19, 58, 24, 2, -47 },
  { 11412, 6, 66, 27, 11, -50 },
  { 11462, 18, 58, 24, 3, -47 },
  { 11593, 25, 9, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Medium66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM66PT7B_H_
