#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x50, 0xF0, 0xDF, 0x2C, 0xB2, 0xC8, 0x1B, 0x09, 0x04,
  0x82, 0x47, 0xFB, 0xFC, 0xD8, 0x6C, 0x36, 0x7F, 0x89, 0x04, 0x82, 0x43,
  0x60, 0x10, 0xFB, 0xF6, 0x89, 0x1A, 0x1C, 0x1E, 0x1C, 0x2C, 0x5E, 0xEF,
  0x82, 0x04, 0x00, 0x61, 0x8F, 0x10, 0x91, 0x09, 0x30, 0x92, 0x09, 0x60,
  0x96, 0xEF, 0x5A, 0x6D, 0x20, 0x93, 0x09, 0x31, 0x92, 0x11, 0xA3, 0x0E,
  0x30, 0x3C, 0x13, 0x09, 0x84, 0x83, 0xC0, 0xC0, 0xE6, 0xDB, 0x45, 0xA3,
  0x98, 0xCF, 0xF3, 0xDC, 0xFF, 0xC0, 0x13, 0x66, 0x4C, 0xCC, 0xCC, 0xCC,
  0xC4, 0x62, 0x30, 0xC3, 0x08, 0x63, 0x08, 0x63, 0x18, 0xC6, 0x23, 0x18,
  0xCC, 0xC0, 0x32, 0xDF, 0xCC, 0x7B, 0x30, 0x30, 0x60, 0xC1, 0x8F, 0xE6,
  0x0C, 0x18, 0x30, 0xFE, 0xFF, 0xF0, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06,
  0x08, 0x30, 0x60, 0x83, 0x06, 0x18, 0x00, 0x30, 0xF3, 0x36, 0x6C, 0x58,
  0xF1, 0xE3, 0xC7, 0x8B, 0x36, 0x67, 0xCF, 0x00, 0x19, 0xDF, 0xB5, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x73, 0xF8, 0xC3, 0x0C, 0x30, 0xC6, 0x38,
  0xC6, 0x30, 0xFF, 0xF0, 0x73, 0xF8, 0xC3, 0x0C, 0x37, 0x9E, 0x0C, 0x30,
  0x43, 0xDF, 0xE0, 0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x36, 0x26, 0x66, 0x46,
  0xC6, 0xFF, 0x06, 0x06, 0x06, 0xFD, 0xFB, 0x06, 0x0C, 0x18, 0x3E, 0x06,
  0x0C, 0x0C, 0x10, 0x6D, 0xDF, 0x00, 0x1C, 0xF9, 0x86, 0x0C, 0x1B, 0x3F,
  0x66, 0xC7, 0x8F, 0x1E, 0x27, 0xCF, 0x00, 0xFF, 0xFC, 0x10, 0x60, 0xC1,
  0x06, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x00, 0x38, 0xFB, 0x36, 0x2C,
  0xDD, 0x9E, 0x3C, 0xCD, 0x8E, 0x1E, 0x3C, 0xCF, 0x00, 0x30, 0xF3, 0x36,
  0x6C, 0x58, 0xB3, 0xFE, 0x74, 0x08, 0x30, 0x6B, 0x9E, 0x00, 0xF0, 0x00,
  0xF0, 0xD8, 0x00, 0x00, 0xFB, 0x40, 0x02, 0x1C, 0xE7, 0x0C, 0x0E, 0x07,
  0x03, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0xC1, 0xE0, 0xE0, 0xE7,
  0x38, 0x60, 0x80, 0x73, 0xE8, 0xC3, 0x0C, 0x31, 0x8C, 0x30, 0x80, 0x00,
  0x70, 0xC0, 0x0E, 0x07, 0xF1, 0x83, 0x20, 0x2C, 0xF7, 0xB6, 0xE6, 0xCC,
  0x99, 0x93, 0x72, 0x6E, 0x7D, 0x66, 0xE4, 0x00, 0xC0, 0x0F, 0xC0, 0x60,
  0x1C, 0x0E, 0x05, 0x02, 0x83, 0x61, 0xB0, 0xD8, 0x44, 0x7F, 0x3F, 0x98,
  0xCC, 0x6C, 0x1E, 0x0C, 0xF0, 0xFE, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE,
  0xC6, 0xC3, 0xC3, 0xC6, 0xFE, 0xFC, 0x1C, 0x7D, 0x8F, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x03, 0x07, 0xE7, 0xC0, 0xF0, 0xFC, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0xF8, 0xFF, 0xFC, 0x30,
  0xC3, 0x0F, 0xFF, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x3F, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x0E, 0x3F, 0x61, 0x60, 0xC0,
  0xC0, 0xC0, 0xC7, 0xC1, 0xC1, 0xC1, 0x61, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFE, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xF0, 0xF8, 0xF8,
  0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xD0, 0xBD,
  0x0B, 0xD9, 0xBD, 0x9B, 0xC9, 0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0xC6, 0x3C,
  0x63, 0xE1, 0xF0, 0xF8, 0x7E, 0x3D, 0x1E, 0xCF, 0x67, 0x9B, 0xCD, 0xE3,
  0xF1, 0xF8, 0xFC, 0x3E, 0x1C, 0x1C, 0x3F, 0x18, 0xD8, 0x6C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xCC, 0x67, 0xF1, 0xF0, 0xF1, 0xFB, 0x3E,
  0x3C, 0x78, 0xF1, 0xFE, 0xF9, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x1C, 0x3F,
  0x18, 0xD8, 0x6C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xCC, 0x67,
  0xF1, 0xF0, 0x18, 0x0C, 0x03, 0x00, 0xF0, 0xFC, 0xCE, 0xC6, 0xC6, 0xC6,
  0xCE, 0xFC, 0xD8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x39, 0xFC, 0x70, 0xC3,
  0x07, 0x0E, 0x1C, 0x30, 0xC3, 0xFF, 0xE0, 0xFF, 0xFC, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3E, 0xC1, 0xE0,
  0xB0, 0xCC, 0x66, 0x33, 0x11, 0x98, 0x4C, 0x36, 0x1B, 0x0D, 0x03, 0x81,
  0xC0, 0xE0, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0x91, 0xC6, 0x67, 0x99, 0x9E,
  0x66, 0x59, 0x99, 0x24, 0x2C, 0xB0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38,
  0x60, 0x61, 0x80, 0xC3, 0x66, 0x66, 0x26, 0x3C, 0x3C, 0x18, 0x18, 0x3C,
  0x3C, 0x26, 0x66, 0x66, 0xC3, 0xC3, 0xC3, 0x66, 0x66, 0x64, 0x3C, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0xFC, 0x10, 0x60, 0xC3,
  0x06, 0x18, 0x30, 0x61, 0x83, 0x0F, 0xFF, 0xC0, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x04, 0x0C,
  0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xF0, 0x08, 0x0C, 0x07, 0x06, 0x83, 0x61, 0x11, 0x8D, 0x83,
  0xFF, 0xCC, 0x70, 0xF9, 0x30, 0xC3, 0x7F, 0x3C, 0xE3, 0xDF, 0xD0, 0xC1,
  0x83, 0x06, 0x0F, 0xDC, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0xFB, 0x80,
  0x7F, 0x71, 0x8C, 0x63, 0x18, 0xEB, 0xC0, 0x06, 0x0C, 0x18, 0x37, 0xF9,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0xEE, 0xC0, 0x7B, 0x3C, 0x71, 0xFF,
  0x0C, 0x30, 0x65, 0xF0, 0x14, 0xE2, 0x18, 0x63, 0xE6, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x00, 0x7F, 0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEE,
  0xEC, 0x18, 0x38, 0xDF, 0x8C, 0x00, 0xC1, 0x83, 0x06, 0x0F, 0xDC, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0xF0, 0xFF, 0xFF, 0xF0, 0x6C,
  0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x7E, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0xF9,
  0xB6, 0x68, 0xF9, 0xF3, 0x26, 0x6C, 0xD8, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFD, 0xFD, 0xCF, 0x19, 0xE3, 0x3C, 0x67, 0x8C, 0xF1, 0x9E, 0x33, 0xC6,
  0x78, 0xCC, 0xFD, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x7D,
  0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x6C, 0xF0, 0xFD, 0xCF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xEF, 0xBB, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x7F, 0x9F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEE, 0xEC, 0x18, 0x30, 0x60, 0xC1, 0x80,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0xFE, 0x61, 0x8F, 0x1C, 0x63,
  0xBF, 0x80, 0x21, 0x19, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xF3, 0x80, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEE, 0xEC, 0xC6, 0x8D, 0x9B, 0x26,
  0xC5, 0x8B, 0x1C, 0x38, 0x30, 0xC6, 0x34, 0x62, 0x6F, 0x66, 0xF6, 0x6B,
  0x66, 0x94, 0x29, 0x42, 0x94, 0x39, 0xC3, 0x9C, 0xE6, 0xD8, 0xB1, 0xC1,
  0x87, 0x0F, 0x36, 0x65, 0x8C, 0xC6, 0x8D, 0x9B, 0x26, 0xC5, 0x8F, 0x1C,
  0x38, 0x30, 0x61, 0x83, 0x1C, 0x10, 0x00, 0x7C, 0x61, 0x86, 0x30, 0xC6,
  0x18, 0x7F, 0xF0, 0x09, 0xCC, 0x42, 0x10, 0x8C, 0xC7, 0x18, 0x42, 0x10,
  0x86, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0x18, 0xC6, 0x31, 0x86,
  0x19, 0x88, 0xC6, 0x31, 0x9C, 0xC0, 0xE3, 0xFE, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 14, 5, 1, -14 },
  { 5, 6, 5, 8, 1, -14 },
  { 9, 9, 14, 9, 0, -14 },
  { 25, 7, 15, 8, 1, -14 },
  { 39, 12, 14, 13, 1, -14 },
  { 60, 9, 14, 10, 1, -14 },
  { 76, 2, 5, 4, 1, -14 },
  { 78, 4, 17, 6, 1, -14 },
  { 87, 5, 17, 6, 0, -14 },
  { 98, 6, 6, 8, 1, -14 },
  { 103, 7, 9, 8, 1, -11 },
  { 111, 2, 4, 4, 1, -2 },
  { 112, 4, 2, 5, 1, -6 },
  { 113, 2, 2, 4, 1, -2 },
  { 114, 7, 14, 7, 0, -14 },
  { 127, 7, 14, 8, 1, -14 },
  { 140, 5, 14, 8, 1, -14 },
  { 149, 6, 14, 8, 1, -14 },
  { 160, 6, 14, 8, 1, -14 },
  { 171, 8, 14, 8, 0, -14 },
  { 185, 7, 14, 8, 1, -14 },
  { 198, 7, 14, 8, 1, -14 },
  { 211, 7, 14, 8, 1, -14 },
  { 224, 7, 14, 8, 1, -14 },
  { 237, 7, 14, 8, 1, -14 },
  { 250, 2, 10, 5, 1, -10 },
  { 253, 3, 12, 5, 1, -10 },
  { 258, 7, 9, 8, 1, -11 },
  { 266, 7, 5, 8, 1, -9 },
  { 271, 7, 9, 8, 1, -11 },
  { 279, 6, 14, 6, 0, -14 },
  { 290, 11, 16, 13, 1, -14 },
  { 312, 9, 14, 9, 0, -14 },
  { 328, 8, 14, 9, 1, -14 },
  { 342, 7, 14, 9, 1, -14 },
  { 355, 8, 14, 10, 1, -14 },
  { 369, 6, 14, 8, 1, -14 },
  { 380, 6, 14, 8, 1, -14 },
  { 391, 8, 14, 10, 1, -14 },
  { 405, 8, 14, 10, 1, -14 },
  { 419, 4, 14, 6, 1, -14 },
  { 426, 4, 18, 5, -1, -14 },
  { 435, 8, 14, 9, 1, -14 },
  { 449, 6, 14, 7, 1, -14 },
  { 460, 12, 14, 14, 1, -14 },
  { 481, 9, 14, 11, 1, -14 },
  { 497, 9, 14, 11, 1, -14 },
  { 513, 7, 14, 9, 1, -14 },
  { 526, 9, 17, 11, 1, -14 },
  { 546, 8, 14, 9, 1, -14 },
  { 560, 6, 14, 8, 1, -14 },
  { 571, 7, 14, 8, 0, -14 },
  { 584, 8, 14, 10, 1, -14 },
  { 598, 9, 14, 9, 0, -14 },
  { 614, 14, 14, 14, 0, -14 },
  { 639, 8, 14, 8, 0, -14 },
  { 653, 8, 14, 8, 0, -14 },
  { 667, 7, 14, 7, 0, -14 },
  { 680, 4, 17, 6, 1, -14 },
  { 689, 7, 14, 7, 0, -14 },
  { 702, 4, 17, 6, 1, -14 },
  { 711, 9, 8, 9, 0, -14 },
  { 720, 8, 1, 8, 0, 2 },
  { 721, 4, 3, 5, 1, -15 },
  { 723, 6, 10, 8, 1, -10 },
  { 731, 7, 14, 9, 1, -14 },
  { 744, 5, 10, 7, 1, -10 },
  { 751, 7, 14, 9, 1, -14 },
  { 764, 6, 10, 8, 1, -10 },
  { 772, 6, 15, 5, 0, -15 },
  { 784, 7, 15, 9, 1, -10 },
  { 798, 7, 14, 9, 1, -14 },
  { 811, 2, 14, 4, 1, -14 },
  { 815, 3, 19, 4, 0, -14 },
  { 823, 7, 14, 8, 1, -14 },
  { 836, 2, 14, 4, 1, -14 },
  { 840, 11, 10, 13, 1, -10 },
  { 854, 7, 10, 9, 1, -10 },
  { 863, 7, 10, 9, 1, -10 },
  { 872, 7, 15, 9, 1, -10 },
  { 886, 7, 15, 9, 1, -10 },
  { 900, 5, 10, 6, 1, -10 },
  { 907, 5, 10, 7, 1, -10 },
  { 914, 5, 13, 5, 0, -13 },
  { 923, 7, 10, 9, 1, -10 },
  { 932, 7, 10, 7, 0, -10 },
  { 941, 12, 10, 12, 0, -10 },
  { 956, 7, 10, 7, 0, -10 },
  { 965, 7, 15, 7, 0, -10 },
  { 979, 6, 10, 6, 0, -10 },
  { 987, 5, 17, 7, 1, -14 },
  { 998, 2, 19, 8, 3, -15 },
  { 1003, 5, 17, 7, 1, -14 },
  { 1014, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Medium19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM19PT7B_H_
