#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE1,
  0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83,
  0xC0, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xE6, 0x1C, 0x7C, 0x60, 0x0F, 0x86, 0x00, 0xF8, 0x60, 0x0F, 0x86, 0x00,
  0xF8, 0x60, 0x0F, 0x86, 0x00, 0x7C, 0x60, 0x07, 0xE6, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x06, 0x7E, 0x00, 0x63, 0xE0, 0x06, 0x1E, 0x00,
  0x61, 0xF0, 0x06, 0x1F, 0x00, 0x61, 0xE8, 0x06, 0x3E, 0xC0, 0x63, 0xEF,
  0x86, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03,
  0xFE, 0x00, 0x78, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0xF0, 0x0F, 0x00,
  0x1E, 0x3E, 0x03, 0xC0, 0x0F, 0x87, 0x81, 0xF0, 0x03, 0xC1, 0xE0, 0x78,
  0x00, 0xF0, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x78, 0x00, 0x3C, 0x1E,
  0x1E, 0x00, 0x0F, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE3, 0xC1, 0xC0, 0xF0,
  0x78, 0xF1, 0xFC, 0x1E, 0x1E, 0x7C, 0xFF, 0x87, 0x8F, 0x9E, 0x3F, 0xF1,
  0xE3, 0xC7, 0x9F, 0x3C, 0x3F, 0xF3, 0xE7, 0x8F, 0x8F, 0xF8, 0xF1, 0xE1,
  0xE1, 0xFE, 0x3C, 0x78, 0x78, 0x3E, 0x1E, 0x3E, 0x1E, 0x00, 0x07, 0x8F,
  0x07, 0x80, 0x01, 0xE3, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x7C, 0x00, 0x3C,
  0x3C, 0x1F, 0x00, 0x0F, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC1, 0xF0, 0x01,
  0xE0, 0xF0, 0x78, 0x00, 0xF8, 0x3E, 0x1E, 0x00, 0x3C, 0x07, 0x87, 0x80,
  0x0F, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x78, 0xF8, 0x01, 0xE0, 0x0F, 0x3C,
  0x00, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0x87, 0xFF, 0x07,
  0xE3, 0xF3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x1F, 0x1F, 0x1F, 0x07,
  0xEF, 0xC7, 0xC0, 0xFF, 0xE1, 0xF0, 0x1F, 0xF8, 0xFC, 0x07, 0xFE, 0x3F,
  0x00, 0xFF, 0x0F, 0xC0, 0x1F, 0xC1, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xFC,
  0x1F, 0x81, 0xFF, 0x07, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xBF, 0x07, 0xFF, 0xC7, 0xE0, 0x7F, 0xC0, 0xFC, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE0, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x10, 0x78, 0x3F, 0x9E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xEF, 0x01,
  0xF3, 0xE0, 0xFC, 0x7C, 0x3E, 0x1F, 0x87, 0x83, 0x80, 0x40, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x79, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0xC7,
  0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x9F, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF,
  0x7E, 0x7F, 0xF1, 0xF7, 0x87, 0xCC, 0x1F, 0x10, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xF0, 0x3F, 0x8C, 0x03, 0xF1,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xF0, 0x1F, 0x88, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01,
  0xFB, 0xC0, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x77, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x79, 0xF0,
  0x01, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xE1, 0xF0, 0x07,
  0x87, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xA0, 0x07, 0xEF, 0x07, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x30, 0x07, 0x8F,
  0xE0, 0xF9, 0xFF, 0x8F, 0xBF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0, 0xFC, 0xFE,
  0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x8F,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0x9F, 0xC7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE3,
  0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFB, 0xF8, 0x3F, 0x1F,
  0xC7, 0xE0, 0xFC, 0x7C, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xF7,
  0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0xFD, 0xF0, 0x1F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFE, 0xF8, 0xFF, 0x9F, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE1, 0x03, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x3E, 0xFF, 0xFF, 0xFF, 0xE7, 0xC2, 0x00, 0x3E, 0x7E, 0x7F,
  0x7F, 0x7F, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x60,
  0x7E, 0x40, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x40, 0x3E, 0x3E, 0x07, 0xFE, 0x1E, 0x3C, 0x0F, 0xFE,
  0x1E, 0x3C, 0x1F, 0xFE, 0x1E, 0x7C, 0x1E, 0x1E, 0x1F, 0x78, 0x3E, 0x1E,
  0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x0F, 0x78, 0x7C, 0x1E,
  0x0F, 0x78, 0x78, 0x3E, 0x0F, 0xF8, 0x78, 0x3E, 0x0F, 0xF8, 0x78, 0x3E,
  0x0F, 0xF0, 0x78, 0x3E, 0x0F, 0xF0, 0x78, 0x3E, 0x0F, 0xF8, 0x78, 0x3E,
  0x0F, 0xF8, 0x78, 0x3E, 0x1E, 0x78, 0x78, 0x3E, 0x1E, 0x78, 0x7C, 0x7E,
  0x1E, 0x78, 0x3C, 0x7E, 0x3C, 0x78, 0x3F, 0xEF, 0xFC, 0x78, 0x1F, 0xE7,
  0xF8, 0x7C, 0x1F, 0xC7, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x03, 0xF8, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3E, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0x81, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x3F, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x81, 0xFE, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x06, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x02, 0x1F, 0xF1, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xE0,
  0xFF, 0x8F, 0x80, 0xFE, 0x3E, 0x01, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x00,
  0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE0, 0x1C, 0x1F, 0x80, 0x04, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x3F, 0x1F, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x87, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x83, 0xC0, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E,
  0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xC1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x03,
  0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFB, 0xF0, 0x1F,
  0x8F, 0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x3F,
  0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xDF, 0xFB, 0xC0, 0x07, 0xDF, 0xFB, 0xC0, 0x07, 0xDF,
  0xFB, 0xE0, 0x07, 0x9F, 0xFB, 0xE0, 0x07, 0x9F, 0xF9, 0xE0, 0x0F, 0x9F,
  0xF9, 0xF0, 0x0F, 0x9F, 0xF9, 0xF0, 0x0F, 0x1F, 0xF9, 0xF0, 0x1F, 0x1F,
  0xF8, 0xF0, 0x1F, 0x1F, 0xF8, 0xF8, 0x1E, 0x1F, 0xF8, 0xF8, 0x1E, 0x1F,
  0xF8, 0x78, 0x3E, 0x1F, 0xF8, 0x78, 0x3E, 0x1F, 0xF8, 0x7C, 0x3C, 0x1F,
  0xF8, 0x7C, 0x3C, 0x1F, 0xF8, 0x3C, 0x7C, 0x1F, 0xF8, 0x3E, 0x78, 0x1F,
  0xF8, 0x3E, 0x78, 0x1F, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x1F,
  0xFB, 0xE0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F,
  0xF8, 0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F,
  0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8, 0x1F, 0x1F,
  0xF8, 0x1F, 0x9F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F, 0x9F, 0xF8, 0x07, 0xDF,
  0xF8, 0x07, 0xDF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7E, 0x07, 0xF9, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF9, 0xF0, 0x7F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x7F, 0x7C,
  0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7E, 0x07, 0xF9, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x2F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C, 0x1F, 0xE3, 0xE0, 0x3F, 0x1F,
  0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3E, 0x01,
  0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFE, 0x07, 0x1F, 0x80, 0x27, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x80, 0x0F, 0xDC, 0x03, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0xE3, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x80, 0x1F, 0x3F, 0x00,
  0x7F, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0xFC, 0x7C, 0x03, 0xDE, 0x01,
  0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xE1, 0xF0, 0x0F, 0x78, 0x07, 0xC3, 0xF0,
  0x1E, 0xF0, 0x0F, 0x83, 0xE0, 0x3D, 0xF0, 0x3F, 0x07, 0xC0, 0xFB, 0xE0,
  0x7C, 0x0F, 0x81, 0xF3, 0xC0, 0xF8, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0x3F,
  0x07, 0x8F, 0x03, 0xE0, 0x3E, 0x0F, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x3C, 0x3E, 0x01, 0xF0, 0xF0, 0x78, 0x7C, 0x03,
  0xF1, 0xE0, 0xF0, 0xF8, 0x03, 0xE3, 0xC1, 0xF3, 0xF0, 0x07, 0xCF, 0x83,
  0xE7, 0xC0, 0x0F, 0x9F, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x07, 0x9F, 0x00,
  0x3E, 0x78, 0x0F, 0x3E, 0x00, 0x3E, 0xF0, 0x1E, 0x7C, 0x00, 0x7D, 0xE0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8,
  0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0xFC, 0x07, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F,
  0xBF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0xDF, 0x80, 0x3E, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x86, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFF, 0x07, 0xF7, 0xFF, 0xFD, 0xFF, 0xCF, 0x3F, 0xE3, 0xC7, 0xF0,
  0xF0, 0x20, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0x80, 0xFC, 0xFF, 0x0F,
  0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0x07, 0xEF, 0xE0, 0x7E,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xEF, 0xE0, 0x7E, 0xFF, 0x07, 0xEF,
  0xBF, 0xFC, 0xFB, 0xFF, 0xCF, 0x9F, 0xF8, 0xF8, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0x82,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0x01, 0x3F, 0x83, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1C, 0x1F, 0x07, 0xF1, 0xF0, 0xFF,
  0xDF, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x3F, 0x0F, 0xF7, 0xE0, 0x7F, 0x7E,
  0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0x0F, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0xCF, 0x07, 0xF0, 0xF0, 0x08, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x7C,
  0x1F, 0x8F, 0x81, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x47, 0xF0,
  0x38, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x18,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xE2, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7F, 0x8F, 0x0F, 0xFC, 0xF1, 0xFF, 0xDF, 0x3F, 0xFF, 0xF3,
  0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x07, 0xF3, 0xF0, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0,
  0x7F, 0x1F, 0x01, 0xC1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x40, 0x03, 0xE3, 0x00, 0x7E, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x1C, 0x0F, 0x8F, 0xF1, 0xF3, 0xFF, 0x3E, 0xFF, 0xF7, 0xDF,
  0xFE, 0xFF, 0x0F, 0xDF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xE0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0,
  0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0x80, 0xFD, 0xF0, 0x0F,
  0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x80, 0xFF, 0xF8, 0x0F, 0xF7, 0xC0,
  0xFE, 0x7C, 0x0F, 0xE7, 0xE0, 0xFC, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xC0, 0xF8, 0xFF, 0x07, 0xF8,
  0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x0F, 0xF8, 0x7E, 0xFE, 0x07, 0xF0, 0x3E, 0xFC, 0x07, 0xE0, 0x3E,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x3C, 0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0x7D,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x1F, 0xBF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x7F,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1C, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC,
  0xFB, 0xFF, 0xCF, 0xF0, 0x7E, 0xFE, 0x03, 0xEF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3E, 0xFE, 0x07, 0xEF, 0xF0, 0xFE, 0xFB, 0xFF, 0xCF, 0xBF, 0xFC,
  0xF9, 0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x10, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x8F, 0x0F, 0xFC, 0xF1, 0xFF, 0xDF,
  0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x03,
  0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xF3, 0xF0, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF,
  0x0F, 0xF9, 0xF0, 0x7F, 0x1F, 0x01, 0x81, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3B, 0xC3, 0xFF, 0x9F, 0xBE, 0xFE, 0xFB, 0xFB, 0xFF,
  0xEF, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xF8, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x81, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0x8F, 0xFC, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF1, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x08, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFB, 0xE0, 0x7F, 0x7E, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xEF, 0x8F,
  0xF8, 0xF0, 0xFE, 0x1E, 0x06, 0x00, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x03,
  0xEF, 0x80, 0xFF, 0x01, 0xF7, 0xC0, 0x7F, 0x81, 0xF1, 0xF0, 0x3F, 0xC0,
  0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x7C, 0x0E, 0xF0, 0x3E, 0x3E, 0x0F, 0x3C,
  0x1F, 0x0F, 0x87, 0x9E, 0x1F, 0x07, 0xC3, 0xCF, 0x0F, 0x83, 0xE1, 0xE7,
  0x87, 0xC1, 0xF0, 0xF3, 0xC3, 0xE0, 0xF8, 0xF1, 0xE1, 0xE0, 0x3E, 0x78,
  0x79, 0xF0, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0x9E, 0x1E, 0x7C, 0x07, 0xCF,
  0x0F, 0x3E, 0x03, 0xEF, 0x87, 0x9E, 0x00, 0xF7, 0x83, 0xDF, 0x00, 0x7B,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xDF, 0x01,
  0xFB, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F,
  0x81, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x07,
  0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Medium54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 40, 13, 3, -39 },
  { 36, 16, 14, 21, 3, -39 },
  { 64, 24, 39, 25, 1, -39 },
  { 181, 20, 44, 24, 2, -41 },
  { 291, 34, 39, 38, 2, -39 },
  { 457, 26, 40, 27, 1, -39 },
  { 587, 6, 14, 12, 3, -39 },
  { 598, 12, 48, 16, 3, -39 },
  { 670, 13, 48, 16, 1, -39 },
  { 748, 18, 19, 22, 2, -41 },
  { 791, 20, 26, 24, 2, -32 },
  { 856, 8, 13, 13, 2, -6 },
  { 869, 13, 5, 15, 1, -17 },
  { 878, 7, 8, 13, 3, -7 },
  { 885, 19, 39, 21, 1, -39 },
  { 978, 20, 40, 24, 2, -39 },
  { 1078, 14, 39, 24, 3, -39 },
  { 1147, 19, 39, 24, 2, -39 },
  { 1240, 19, 40, 24, 2, -39 },
  { 1335, 22, 39, 24, 1, -39 },
  { 1443, 18, 40, 24, 3, -39 },
  { 1533, 20, 40, 24, 2, -39 },
  { 1633, 20, 39, 24, 2, -39 },
  { 1731, 20, 40, 24, 2, -39 },
  { 1831, 19, 40, 24, 2, -39 },
  { 1926, 7, 30, 13, 3, -29 },
  { 1953, 8, 36, 13, 2, -29 },
  { 1989, 20, 24, 24, 2, -31 },
  { 2049, 20, 16, 24, 2, -27 },
  { 2089, 20, 24, 24, 2, -31 },
  { 2149, 16, 40, 18, 1, -39 },
  { 2229, 32, 43, 36, 2, -39 },
  { 2401, 25, 39, 25, 0, -39 },
  { 2523, 20, 39, 27, 4, -39 },
  { 2621, 20, 40, 25, 3, -39 },
  { 2721, 22, 39, 29, 4, -39 },
  { 2829, 16, 39, 22, 4, -39 },
  { 2907, 16, 39, 21, 4, -39 },
  { 2985, 24, 40, 30, 3, -39 },
  { 3105, 22, 39, 30, 4, -39 },
  { 3213, 12, 39, 16, 2, -39 },
  { 3272, 12, 50, 13, -3, -39 },
  { 3347, 21, 39, 25, 4, -39 },
  { 3450, 16, 39, 21, 4, -39 },
  { 3528, 32, 39, 40, 4, -39 },
  { 3684, 24, 39, 32, 4, -39 },
  { 3801, 25, 40, 30, 3, -39 },
  { 3926, 19, 39, 25, 4, -39 },
  { 4019, 25, 48, 30, 3, -39 },
  { 4169, 21, 39, 26, 4, -39 },
  { 4272, 19, 40, 22, 2, -39 },
  { 4367, 20, 39, 21, 1, -39 },
  { 4465, 21, 40, 29, 4, -39 },
  { 4570, 25, 39, 25, 0, -39 },
  { 4692, 39, 39, 39, 0, -39 },
  { 4883, 23, 39, 23, 0, -39 },
  { 4996, 22, 39, 22, 0, -39 },
  { 5104, 18, 39, 20, 1, -39 },
  { 5192, 11, 48, 17, 4, -39 },
  { 5258, 19, 39, 21, 1, -39 },
  { 5351, 11, 48, 17, 2, -39 },
  { 5417, 23, 22, 25, 1, -39 },
  { 5481, 23, 3, 23, 0, 5 },
  { 5490, 11, 8, 15, 2, -41 },
  { 5501, 18, 31, 23, 2, -30 },
  { 5571, 20, 42, 26, 3, -41 },
  { 5676, 16, 31, 20, 2, -30 },
  { 5738, 20, 42, 26, 2, -41 },
  { 5843, 19, 31, 23, 2, -30 },
  { 5917, 16, 41, 14, 0, -41 },
  { 5999, 20, 43, 26, 2, -30 },
  { 6107, 19, 41, 25, 3, -41 },
  { 6205, 6, 40, 12, 3, -40 },
  { 6235, 10, 53, 12, -1, -40 },
  { 6302, 20, 41, 23, 3, -41 },
  { 6405, 6, 41, 12, 3, -41 },
  { 6436, 32, 30, 38, 3, -30 },
  { 6556, 19, 30, 25, 3, -30 },
  { 6628, 21, 31, 25, 2, -30 },
  { 6710, 20, 43, 26, 3, -30 },
  { 6818, 20, 43, 26, 2, -30 },
  { 6926, 14, 30, 17, 3, -30 },
  { 6979, 15, 31, 19, 2, -30 },
  { 7038, 13, 37, 15, 1, -36 },
  { 7099, 19, 30, 25, 3, -29 },
  { 7171, 21, 29, 21, 0, -29 },
  { 7248, 33, 29, 34, 0, -29 },
  { 7368, 19, 29, 21, 1, -29 },
  { 7437, 21, 42, 21, 0, -29 },
  { 7548, 15, 29, 17, 1, -29 },
  { 7603, 15, 48, 19, 2, -39 },
  { 7693, 5, 54, 22, 9, -41 },
  { 7727, 16, 48, 19, 2, -39 },
  { 7823, 20, 8, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Medium54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM54PT7B_H_
