#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xF7, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0x70, 0x78, 0x01, 0xE1, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x83, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7C, 0xC3, 0x3E, 0x30, 0x0F, 0x0C, 0x03,
  0xC3, 0x00, 0xF0, 0xC0, 0x3E, 0x30, 0x0F, 0x8C, 0x01, 0xF3, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0D, 0xF8, 0x03, 0x3E, 0x00, 0xC7, 0x80, 0x31, 0xF0, 0x0C, 0x7C,
  0x03, 0x1E, 0x80, 0xC7, 0xB0, 0x33, 0xEF, 0xCF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x07, 0xFC, 0x01, 0xC0, 0x1E, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x3C, 0x03,
  0xC3, 0x81, 0xE0, 0x0F, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x1C, 0x00, 0xF0,
  0xF0, 0xF0, 0x03, 0xC3, 0xC3, 0xC0, 0x0F, 0x0F, 0x0E, 0x00, 0x3C, 0x3C,
  0x78, 0x00, 0xF0, 0xF1, 0xE0, 0x03, 0xC3, 0xC7, 0x02, 0x0F, 0x0F, 0x3C,
  0x7E, 0x3C, 0x38, 0xF3, 0xFC, 0x71, 0xE7, 0x8F, 0xF9, 0xE7, 0x9E, 0x79,
  0xE7, 0xFC, 0x79, 0xE3, 0xCF, 0xF3, 0xC7, 0x0F, 0x1F, 0x8F, 0x3C, 0x3C,
  0x00, 0x38, 0xF0, 0xF0, 0x01, 0xE3, 0xC3, 0xC0, 0x07, 0x8F, 0x0F, 0x00,
  0x1C, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3, 0xC3, 0xC0, 0x0E,
  0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x3C, 0x01, 0xE0, 0x70, 0xF0, 0x0F, 0x01,
  0xE3, 0xC0, 0x3C, 0x07, 0x9E, 0x00, 0xE0, 0x0F, 0xF8, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x3E, 0x78, 0x78, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xF0, 0x7E,
  0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFE, 0x7C, 0x1F, 0xFC, 0x7E, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xE7, 0x00, 0x01,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x08, 0x3C, 0x17, 0x9E, 0x7B,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xE7, 0x81, 0xF3, 0xE1, 0xF0, 0xF8, 0x38, 0x78, 0x08, 0x10, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF,
  0x9F, 0x3C, 0x79, 0xF3, 0xC7, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7B,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x3E, 0x7C,
  0x1F, 0x1F, 0x07, 0xC3, 0xE3, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF,
  0x3E, 0xF7, 0xCF, 0xF8, 0xF7, 0x0F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0x83, 0xF3, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0x03, 0xF3, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF,
  0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x70,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xDF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1C, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFB, 0x80, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x7F, 0x0F, 0xBF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0x87, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7C, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3E, 0x1F, 0x0F, 0xCF, 0x81,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFD,
  0xF8, 0x7E, 0x3F, 0x1F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF,
  0xC0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xF3, 0xE0, 0xFB,
  0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xBE,
  0x1F, 0xDF, 0xFF, 0xE7, 0xFE, 0xF3, 0xFE, 0x78, 0x7E, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0x33, 0xEF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x18,
  0xF9, 0xFB, 0xF7, 0xEF, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9F, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x3E, 0x78, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF3,
  0x07, 0xE4, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x3F, 0x07, 0x8F, 0x07,
  0xFE, 0x3C, 0xF0, 0x7F, 0xF1, 0xE7, 0x83, 0xC7, 0x87, 0x3C, 0x3C, 0x3C,
  0x3D, 0xC1, 0xE1, 0xE1, 0xEE, 0x1E, 0x0F, 0x0F, 0xF0, 0xF0, 0x78, 0x7F,
  0x87, 0x83, 0xC3, 0xFC, 0x3C, 0x3C, 0x1F, 0xE1, 0xE1, 0xE0, 0xFF, 0x0F,
  0x0F, 0x07, 0xF8, 0x78, 0x78, 0x3F, 0xC3, 0xC3, 0xC1, 0xDE, 0x1E, 0x1E,
  0x0E, 0xF0, 0xF0, 0xF0, 0xF7, 0x83, 0xCF, 0xC7, 0x1C, 0x1F, 0xEF, 0xF8,
  0xF0, 0x7F, 0x3F, 0x87, 0x81, 0xF0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81,
  0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x0F,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7C, 0x07,
  0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xBE, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0x81, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0x87, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE1, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xE0, 0x38, 0x7E, 0x00, 0x21, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0x7C, 0x07,
  0xFD, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x7C, 0x7E,
  0x01, 0xF1, 0xFC, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8,
  0x78, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xC0, 0x3E, 0x78, 0x07, 0xCF,
  0x01, 0xF1, 0xE0, 0x7E, 0x3C, 0x0F, 0x87, 0x83, 0xF0, 0xF0, 0x7C, 0x1E,
  0x1F, 0x83, 0xC3, 0xE0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x3D,
  0xF8, 0x07, 0xBE, 0x00, 0xF7, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xDF, 0x01, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x83, 0xE0, 0xF0,
  0x7C, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x8F, 0x01, 0xF1, 0xE0,
  0x3F, 0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1E, 0xFF, 0x78, 0x01, 0xEF, 0xF7, 0x80, 0x1E, 0xFF, 0x7C,
  0x03, 0xEF, 0xF3, 0xC0, 0x3C, 0xFF, 0x3C, 0x03, 0xCF, 0xF3, 0xC0, 0x3C,
  0xFF, 0x3E, 0x07, 0x8F, 0xF1, 0xE0, 0x78, 0xFF, 0x1E, 0x07, 0x8F, 0xF1,
  0xE0, 0xF8, 0xFF, 0x0F, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0x0F, 0xF0, 0xF9, 0xE0, 0xFF, 0x07, 0x9E, 0x0F, 0xF0, 0x79, 0xE0, 0xFF,
  0x07, 0xBE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xBC,
  0x03, 0xFD, 0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0x3E, 0x07, 0xF9, 0xF0, 0x3F,
  0xC7, 0xC1, 0xFE, 0x3E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0xC3, 0xFC, 0x1E,
  0x1F, 0xE0, 0xF8, 0xFF, 0x07, 0xC7, 0xF8, 0x1F, 0x3F, 0xC0, 0xF9, 0xFE,
  0x03, 0xCF, 0xF0, 0x1F, 0x7F, 0x80, 0xFB, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xF0, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x7F, 0xBE,
  0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x3F,
  0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xF0, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x7F, 0x8F,
  0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F,
  0x8F, 0x81, 0xF8, 0xF8, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF0, 0x73, 0xF0, 0x09, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFA, 0x00, 0xFD, 0xE0, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80,
  0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7F, 0x07, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xF9, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F,
  0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xF1,
  0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x01, 0xF8,
  0x03, 0xE7, 0x80, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x80, 0x3E, 0x7C, 0x03, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0xC0, 0x7C,
  0x3C, 0x03, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03, 0xBC,
  0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0x78, 0x3E, 0x07, 0x9E, 0x0F, 0x81, 0xE0,
  0x79, 0xE0, 0xF8, 0x1F, 0x07, 0x9E, 0x0F, 0x81, 0xF0, 0x79, 0xE0, 0xF8,
  0x1F, 0x0F, 0x1E, 0x0F, 0x00, 0xF0, 0xF1, 0xE1, 0xF0, 0x0F, 0x0F, 0x0F,
  0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x9F, 0x0F, 0x1F, 0x00, 0xF9,
  0xE0, 0xF1, 0xE0, 0x07, 0x9E, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x7B, 0xE0,
  0x07, 0x9E, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xFC, 0x07,
  0xBC, 0x00, 0x3F, 0xC0, 0x7B, 0xC0, 0x03, 0xFC, 0x03, 0xBC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0x78, 0xF0, 0x07, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xDE, 0x00,
  0x7D, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x78,
  0x1F, 0x07, 0xC1, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x03, 0xF7, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0,
  0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xE0, 0x1E, 0x0F, 0x01,
  0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x7C, 0x01,
  0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x18,
  0x3E, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0xFF, 0x7F, 0xEF, 0x7F, 0xCF, 0x3F, 0x8F, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0x83, 0xE7, 0xF8,
  0xFB, 0xFF, 0x3F, 0xFF, 0xCF, 0xF1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xFE, 0x0F, 0xBF,
  0xFF, 0xCF, 0x7F, 0xF3, 0xCF, 0xF8, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xF0, 0xCF, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x81, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x7C, 0x3F, 0xCF, 0x1F, 0xFB, 0xCF, 0xFE, 0xF7, 0xF3, 0xFD, 0xF0, 0x3F,
  0x7C, 0x0F, 0xDE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3F,
  0x7E, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x0F, 0xE3, 0xC0,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0,
  0x79, 0xE0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x04, 0x7F, 0xBE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0xF1, 0xFF, 0xBC, 0xFF, 0xEF,
  0x3F, 0x3F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0x7C, 0x07, 0xDF, 0x03, 0xF7, 0xE1, 0xFC, 0xFF, 0xEF, 0x3F, 0xFB, 0xC7,
  0xFC, 0xF0, 0xFE, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x98, 0x03, 0xE7, 0xE7, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x1F, 0x7F, 0xCF, 0xFF, 0xE7, 0xBF,
  0xFB, 0xFC, 0xFD, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xF8, 0x27, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x02, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xFB, 0xF7, 0xFB, 0xF9, 0xFC, 0x78, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x78,
  0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xBE, 0x0F, 0xCF, 0x83, 0xE1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8,
  0x0F, 0x0F, 0x3F, 0xC3, 0xFC, 0xF7, 0xFE, 0x7F, 0xEF, 0x7F, 0xFF, 0xFE,
  0xFE, 0x3F, 0xE3, 0xFF, 0xC1, 0xFC, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0x80,
  0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80,
  0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8,
  0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8,
  0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF,
  0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F,
  0x80, 0xFF, 0x80, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x79,
  0xFF, 0x3D, 0xFF, 0x9E, 0xFF, 0xEF, 0xF3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x79, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xE3, 0xE0, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xF8, 0x3C, 0x7F,
  0x8F, 0x3F, 0xF3, 0xDF, 0xFC, 0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xE1, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0xFF, 0x8F, 0x9F, 0xC3, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x03, 0xFC, 0xF1, 0xFF, 0xBC, 0xFF, 0xEF, 0x3F, 0x3F, 0xDF,
  0x03, 0xF7, 0xC0, 0xFD, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF,
  0x03, 0xF7, 0xE1, 0xFC, 0xFF, 0xEF, 0x3F, 0xFB, 0xC7, 0xFC, 0xF0, 0xFE,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xF7, 0xFF,
  0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFE, 0xF8, 0x33, 0xC0, 0x4F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xEC,
  0x0F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xC7, 0xFC, 0x00, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF,
  0x3F, 0xE7, 0x8F, 0xE3, 0xC0, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xF1, 0xF0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3D, 0xE0,
  0x3F, 0x01, 0xF7, 0xC0, 0xFE, 0x07, 0xDF, 0x03, 0xF8, 0x1E, 0x7C, 0x0F,
  0xE0, 0x78, 0xF0, 0x3B, 0x81, 0xE3, 0xC1, 0xEE, 0x0F, 0x8F, 0x87, 0xBC,
  0x3E, 0x3E, 0x1E, 0xF0, 0xF0, 0x78, 0x73, 0xC3, 0xC1, 0xE1, 0xCF, 0x1F,
  0x07, 0x8F, 0x1C, 0x7C, 0x1F, 0x3C, 0x79, 0xE0, 0x7C, 0xF1, 0xE7, 0x80,
  0xF3, 0xC7, 0x9E, 0x03, 0xCE, 0x1E, 0x78, 0x0F, 0x38, 0x7B, 0xE0, 0x3D,
  0xE0, 0xEF, 0x00, 0xFF, 0x83, 0xBC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x9F,
  0x07, 0xC7, 0xC1, 0xF0, 0xF0, 0x78, 0x3E, 0x3E, 0x07, 0x8F, 0x81, 0xF7,
  0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0xC1,
  0xF1, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0xF8, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x81,
  0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x7C, 0x3C, 0x0F, 0x8F,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBE,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x0B, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x3F, 0xC1, 0xFC,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x0C, 0x00,
  0x27, 0xF8, 0x05, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0xFF,
  0xA0, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 35, 12, 3, -35 },
  { 28, 14, 13, 20, 3, -35 },
  { 51, 21, 35, 23, 1, -35 },
  { 143, 18, 40, 22, 2, -37 },
  { 233, 30, 35, 34, 2, -35 },
  { 365, 24, 35, 25, 1, -35 },
  { 470, 5, 13, 11, 3, -35 },
  { 479, 11, 43, 15, 2, -35 },
  { 539, 11, 43, 15, 1, -35 },
  { 599, 17, 17, 20, 2, -37 },
  { 636, 19, 23, 22, 1, -29 },
  { 691, 7, 12, 11, 2, -6 },
  { 702, 12, 4, 14, 1, -15 },
  { 708, 6, 6, 11, 3, -6 },
  { 713, 17, 35, 19, 1, -35 },
  { 788, 18, 35, 21, 2, -35 },
  { 867, 12, 35, 21, 3, -35 },
  { 920, 17, 35, 21, 2, -35 },
  { 995, 17, 35, 21, 2, -35 },
  { 1070, 20, 35, 21, 1, -35 },
  { 1158, 17, 35, 21, 2, -35 },
  { 1233, 18, 35, 21, 2, -35 },
  { 1312, 19, 35, 21, 1, -35 },
  { 1396, 18, 35, 21, 2, -35 },
  { 1475, 17, 35, 21, 2, -35 },
  { 1550, 6, 27, 12, 3, -27 },
  { 1571, 7, 33, 12, 2, -27 },
  { 1600, 19, 23, 22, 1, -29 },
  { 1655, 19, 14, 22, 1, -24 },
  { 1689, 19, 23, 22, 1, -29 },
  { 1744, 15, 35, 16, 0, -35 },
  { 1810, 29, 39, 33, 2, -35 },
  { 1952, 23, 35, 23, 0, -35 },
  { 2053, 19, 35, 24, 3, -35 },
  { 2137, 19, 36, 22, 2, -36 },
  { 2223, 21, 35, 26, 3, -35 },
  { 2315, 14, 35, 20, 4, -35 },
  { 2377, 14, 35, 19, 4, -35 },
  { 2439, 22, 35, 27, 2, -35 },
  { 2536, 19, 35, 27, 4, -35 },
  { 2620, 11, 35, 14, 2, -35 },
  { 2669, 10, 45, 12, -2, -35 },
  { 2726, 19, 35, 23, 4, -35 },
  { 2810, 15, 35, 19, 3, -35 },
  { 2876, 28, 35, 36, 4, -35 },
  { 2999, 21, 35, 29, 4, -35 },
  { 3091, 23, 35, 28, 2, -35 },
  { 3192, 18, 35, 22, 3, -35 },
  { 3271, 23, 43, 28, 2, -35 },
  { 3395, 20, 35, 23, 3, -35 },
  { 3483, 17, 36, 20, 2, -36 },
  { 3560, 18, 35, 19, 1, -35 },
  { 3639, 20, 35, 26, 3, -35 },
  { 3727, 23, 35, 23, 0, -35 },
  { 3828, 36, 35, 36, 0, -35 },
  { 3986, 20, 35, 21, 0, -35 },
  { 4074, 20, 35, 20, 0, -35 },
  { 4162, 17, 35, 18, 1, -35 },
  { 4237, 11, 43, 15, 3, -35 },
  { 4297, 17, 35, 19, 1, -35 },
  { 4372, 11, 43, 15, 1, -35 },
  { 4432, 21, 20, 23, 1, -35 },
  { 4485, 21, 3, 21, 0, 4 },
  { 4493, 10, 8, 14, 2, -38 },
  { 4503, 16, 27, 21, 2, -27 },
  { 4557, 18, 37, 23, 3, -37 },
  { 4641, 15, 27, 18, 2, -27 },
  { 4692, 18, 37, 23, 2, -37 },
  { 4776, 17, 27, 21, 2, -27 },
  { 4834, 14, 37, 13, 0, -37 },
  { 4899, 18, 39, 23, 2, -27 },
  { 4987, 17, 37, 23, 3, -37 },
  { 5066, 5, 37, 11, 3, -37 },
  { 5090, 9, 49, 11, -1, -37 },
  { 5146, 18, 37, 21, 3, -37 },
  { 5230, 5, 37, 11, 3, -37 },
  { 5254, 28, 27, 34, 3, -27 },
  { 5349, 17, 27, 23, 3, -27 },
  { 5407, 18, 27, 22, 2, -27 },
  { 5468, 18, 39, 23, 3, -27 },
  { 5556, 18, 39, 23, 2, -27 },
  { 5644, 12, 27, 16, 3, -27 },
  { 5685, 14, 27, 17, 2, -27 },
  { 5733, 12, 32, 14, 1, -32 },
  { 5781, 17, 26, 23, 3, -26 },
  { 5837, 19, 26, 19, 0, -26 },
  { 5899, 30, 26, 31, 0, -26 },
  { 5997, 18, 26, 19, 1, -26 },
  { 6056, 19, 38, 19, 0, -26 },
  { 6147, 14, 26, 16, 1, -26 },
  { 6193, 14, 43, 18, 2, -35 },
  { 6269, 4, 49, 20, 8, -37 },
  { 6294, 14, 43, 18, 2, -35 },
  { 6370, 19, 7, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Medium49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM49PT7B_H_
