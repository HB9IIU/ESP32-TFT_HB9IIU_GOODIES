#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA8, 0xB0, 0xBB, 0xB9, 0x24, 0xA2, 0x9F, 0x28, 0xAF, 0xD2,
  0x59, 0x40, 0x21, 0x3D, 0x4A, 0x70, 0xC7, 0x3F, 0x88, 0x40, 0xC4, 0xA4,
  0xA8, 0xA8, 0xAF, 0xD5, 0x15, 0x25, 0x25, 0x27, 0x30, 0x91, 0x23, 0xC3,
  0x0E, 0xF7, 0x66, 0x4C, 0xEC, 0xF0, 0x6B, 0x49, 0x24, 0x99, 0x30, 0xC4,
  0x22, 0x22, 0x32, 0x22, 0x6C, 0x31, 0x3E, 0x65, 0x80, 0x30, 0xC3, 0x3F,
  0x30, 0xC0, 0x69, 0x60, 0xF0, 0xC0, 0x08, 0xC4, 0x23, 0x10, 0x88, 0x46,
  0x00, 0x74, 0xA5, 0x39, 0xCE, 0x72, 0x93, 0x80, 0x2E, 0x92, 0x49, 0x24,
  0xF9, 0x20, 0x82, 0x18, 0x43, 0x18, 0x43, 0xF0, 0xF9, 0x20, 0x82, 0x30,
  0x60, 0x83, 0x8B, 0xE0, 0x18, 0x62, 0x8A, 0x49, 0x28, 0xBF, 0x08, 0x20,
  0xF4, 0x21, 0x0F, 0x08, 0x62, 0x97, 0x80, 0x76, 0x21, 0x0F, 0x4A, 0x73,
  0x93, 0x80, 0xFC, 0x20, 0x86, 0x18, 0x43, 0x0C, 0x21, 0x80, 0x79, 0x24,
  0x92, 0x31, 0xE4, 0xF3, 0x4D, 0xE0, 0x71, 0x24, 0xB3, 0x4D, 0xE0, 0x82,
  0x19, 0xC0, 0xB0, 0x0B, 0x4C, 0x00, 0x1A, 0x58, 0x0C, 0x66, 0x38, 0x18,
  0x30, 0xFC, 0x00, 0x3F, 0xC1, 0xC1, 0xC7, 0x73, 0x00, 0xF9, 0x11, 0x32,
  0x40, 0x66, 0x3C, 0x42, 0x82, 0xBD, 0xA9, 0xA9, 0xA9, 0xBE, 0x80, 0xC0,
  0x7C, 0x30, 0x70, 0xE1, 0x46, 0x89, 0x1F, 0x22, 0xC5, 0x8C, 0xF4, 0xE3,
  0x1F, 0x4E, 0x31, 0x9F, 0x80, 0x7E, 0x71, 0x08, 0x42, 0x18, 0xCB, 0xC0,
  0xF2, 0x68, 0xA3, 0x8E, 0x38, 0xE2, 0x9B, 0xC0, 0xF8, 0x88, 0xF8, 0x88,
  0x8F, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x7D, 0x1C, 0x20, 0x82, 0x78, 0x71,
  0xC5, 0xF0, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8E, 0x30, 0xF6, 0x66,
  0x66, 0x66, 0x6F, 0x24, 0x92, 0x49, 0x24, 0xFC, 0x8E, 0x69, 0x2C, 0xA3,
  0xC9, 0x24, 0x9A, 0x30, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC3, 0xC3, 0xE3,
  0xA7, 0xA5, 0xA5, 0x95, 0x99, 0x99, 0x99, 0xC7, 0x1E, 0x69, 0xB6, 0x59,
  0x63, 0x8E, 0x30, 0x7B, 0x38, 0xE1, 0x86, 0x18, 0x63, 0xCD, 0xE0, 0xF4,
  0xE3, 0x19, 0xFA, 0x10, 0x84, 0x00, 0x7B, 0x38, 0xE1, 0x86, 0x18, 0x63,
  0xCD, 0xE1, 0x83, 0xF2, 0x68, 0xA2, 0x9B, 0xC9, 0x24, 0x9A, 0x30, 0x7A,
  0x50, 0x87, 0x0C, 0x21, 0x9F, 0x80, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x00, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xC9, 0xE0, 0xC7, 0x14, 0xD3,
  0x49, 0xA2, 0x8E, 0x30, 0xC0, 0x8C, 0x73, 0x1C, 0xCD, 0x32, 0x4E, 0x96,
  0xA7, 0x28, 0xCE, 0x33, 0x0C, 0xC0, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x16,
  0x4B, 0x30, 0xCD, 0x24, 0x9E, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0xF8, 0xC4,
  0x23, 0x11, 0x88, 0x47, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0xC2, 0x10,
  0x42, 0x10, 0x42, 0x18, 0x40, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10, 0xC2,
  0x92, 0x47, 0x10, 0xFC, 0xB4, 0x32, 0xC2, 0x76, 0xE5, 0x2F, 0x84, 0x21,
  0x6D, 0xC6, 0x31, 0x8E, 0xEC, 0x6D, 0x88, 0x88, 0x8F, 0x18, 0xC6, 0xFF,
  0xCE, 0x73, 0x9C, 0xFA, 0x6D, 0x9F, 0xF8, 0x97, 0x37, 0x47, 0xF4, 0x44,
  0x44, 0x40, 0x6F, 0xE7, 0x39, 0xCE, 0x7F, 0x18, 0xFC, 0x84, 0x21, 0x6F,
  0xCE, 0x73, 0x9C, 0xE6, 0xBF, 0xC0, 0x45, 0x55, 0x55, 0xC0, 0x84, 0x21,
  0x39, 0x53, 0x9C, 0xB4, 0xA6, 0xFF, 0xE0, 0xB6, 0xFF, 0x99, 0x99, 0x99,
  0x99, 0x99, 0x99, 0xB6, 0xE7, 0x39, 0xCE, 0x73, 0x67, 0xA7, 0x39, 0xCE,
  0x4E, 0xB6, 0xE3, 0x18, 0xC7, 0x76, 0x84, 0x20, 0x6F, 0xE7, 0x39, 0xCE,
  0x7F, 0x18, 0xC6, 0xBF, 0x49, 0x24, 0x35, 0xC6, 0x31, 0x9F, 0x47, 0xF4,
  0x44, 0x44, 0x70, 0x9C, 0xE7, 0x39, 0xCE, 0x7D, 0x8E, 0x52, 0xB5, 0x38,
  0xC6, 0x89, 0xEC, 0x95, 0x4A, 0xA5, 0x52, 0xB9, 0xD8, 0x4C, 0xCA, 0xDC,
  0x63, 0x39, 0x79, 0x8E, 0x52, 0xB5, 0x38, 0xC6, 0x21, 0x38, 0xFF, 0x32,
  0x64, 0x4F, 0x32, 0x22, 0x26, 0xE2, 0x22, 0x23, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC4, 0x44, 0x46, 0x74, 0x44, 0x4C, 0x66, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 3, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 6, 10, 7, 0, -10 },
  { 14, 5, 12, 6, 1, -11 },
  { 22, 8, 10, 10, 1, -10 },
  { 32, 7, 10, 7, 0, -10 },
  { 41, 1, 4, 3, 1, -10 },
  { 42, 3, 12, 4, 1, -10 },
  { 47, 4, 12, 4, 0, -10 },
  { 53, 5, 5, 6, 0, -11 },
  { 57, 6, 6, 6, 0, -8 },
  { 62, 3, 4, 3, 0, -2 },
  { 64, 4, 1, 4, 0, -4 },
  { 65, 1, 2, 3, 1, -2 },
  { 66, 5, 10, 5, 0, -10 },
  { 73, 5, 10, 6, 1, -10 },
  { 80, 3, 10, 6, 1, -10 },
  { 84, 6, 10, 6, 0, -10 },
  { 92, 6, 10, 6, 0, -10 },
  { 100, 6, 10, 6, 0, -10 },
  { 108, 5, 10, 6, 1, -10 },
  { 115, 5, 10, 6, 1, -10 },
  { 122, 6, 10, 6, 0, -10 },
  { 130, 6, 10, 6, 0, -10 },
  { 138, 6, 10, 6, 0, -10 },
  { 146, 2, 8, 3, 1, -8 },
  { 148, 3, 10, 3, 0, -8 },
  { 152, 6, 6, 6, 0, -8 },
  { 157, 6, 4, 6, 0, -7 },
  { 160, 6, 6, 6, 0, -8 },
  { 165, 4, 10, 5, 0, -10 },
  { 170, 8, 11, 9, 1, -10 },
  { 181, 7, 10, 7, 0, -10 },
  { 190, 5, 10, 7, 1, -10 },
  { 197, 5, 10, 6, 1, -10 },
  { 204, 6, 10, 7, 1, -10 },
  { 212, 4, 10, 6, 1, -10 },
  { 217, 4, 10, 6, 1, -10 },
  { 222, 6, 10, 8, 1, -10 },
  { 230, 6, 10, 8, 1, -10 },
  { 238, 4, 10, 4, 0, -10 },
  { 243, 3, 13, 3, -1, -10 },
  { 248, 6, 10, 7, 1, -10 },
  { 256, 4, 10, 5, 1, -10 },
  { 261, 8, 10, 10, 1, -10 },
  { 271, 6, 10, 8, 1, -10 },
  { 279, 6, 10, 8, 1, -10 },
  { 287, 5, 10, 6, 1, -10 },
  { 294, 6, 12, 8, 1, -10 },
  { 303, 6, 10, 7, 1, -10 },
  { 311, 5, 10, 6, 0, -10 },
  { 318, 5, 10, 6, 0, -10 },
  { 325, 6, 10, 8, 1, -10 },
  { 333, 6, 10, 6, 0, -10 },
  { 341, 10, 10, 10, 0, -10 },
  { 354, 6, 10, 6, 0, -10 },
  { 362, 6, 10, 6, 0, -10 },
  { 370, 5, 10, 5, 0, -10 },
  { 377, 3, 12, 4, 1, -10 },
  { 382, 5, 10, 5, 0, -10 },
  { 389, 3, 12, 4, 0, -10 },
  { 394, 6, 6, 7, 0, -10 },
  { 399, 6, 1, 6, 0, 1 },
  { 400, 2, 3, 4, 1, -11 },
  { 401, 5, 8, 6, 0, -8 },
  { 406, 5, 11, 7, 1, -11 },
  { 413, 4, 8, 5, 1, -8 },
  { 417, 5, 11, 7, 1, -11 },
  { 424, 4, 8, 6, 1, -8 },
  { 428, 4, 11, 4, 0, -11 },
  { 434, 5, 11, 7, 1, -8 },
  { 441, 5, 11, 7, 1, -11 },
  { 448, 1, 10, 3, 1, -10 },
  { 450, 2, 13, 3, 0, -10 },
  { 454, 5, 11, 6, 1, -11 },
  { 461, 1, 11, 3, 1, -11 },
  { 463, 8, 8, 10, 1, -8 },
  { 471, 5, 8, 7, 1, -8 },
  { 476, 5, 8, 6, 1, -8 },
  { 481, 5, 11, 7, 1, -8 },
  { 488, 5, 11, 7, 1, -8 },
  { 495, 3, 8, 4, 1, -8 },
  { 498, 4, 8, 5, 0, -8 },
  { 502, 4, 9, 4, 0, -9 },
  { 507, 5, 8, 7, 1, -8 },
  { 512, 5, 8, 5, 0, -8 },
  { 517, 9, 8, 9, 0, -8 },
  { 526, 5, 8, 5, 0, -8 },
  { 531, 5, 11, 5, 0, -8 },
  { 538, 4, 8, 4, 0, -8 },
  { 542, 4, 12, 5, 0, -10 },
  { 548, 2, 14, 6, 2, -11 },
  { 552, 4, 12, 5, 1, -10 },
  { 558, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Medium14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM14PT7B_H_
