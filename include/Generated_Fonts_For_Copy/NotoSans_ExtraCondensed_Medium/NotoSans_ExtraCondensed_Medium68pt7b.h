#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x18, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F,
  0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFD, 0xFC, 0x7F, 0x3C, 0x1C, 0xFE, 0x3C, 0x04, 0xFC, 0x3C, 0x00, 0xFC,
  0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC,
  0x3C, 0x00, 0xFE, 0x3C, 0x00, 0x7F, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3C, 0xFE, 0x00, 0x3C, 0x7F, 0x00, 0x3C, 0x3F, 0x00,
  0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00,
  0x3C, 0x3F, 0x80, 0x3C, 0x7F, 0xE0, 0x3C, 0x7E, 0xFC, 0x3D, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x81, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x0F, 0x87, 0xF8, 0x3E, 0x07, 0xC7, 0xC3, 0xFF, 0x0F, 0x83, 0xF1,
  0xF1, 0xFF, 0xE1, 0xF0, 0xF8, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x3E, 0x3F,
  0x1F, 0x1F, 0xFF, 0x8F, 0x8F, 0x87, 0xE3, 0xFF, 0xC7, 0xE3, 0xE0, 0xF8,
  0x7F, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0xF0, 0x7C, 0x7E, 0x0F, 0x81, 0xF8,
  0x3E, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0xFC, 0x00, 0x03, 0xE1,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x3F, 0x00,
  0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFC, 0x1F, 0xFF, 0x80,
  0xFC, 0x3F, 0xDF, 0xC1, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0xFE, 0x03, 0xFB,
  0xF8, 0xFE, 0x01, 0xFB, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0xFF,
  0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x7F, 0xE7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x70, 0x3C, 0x0E, 0x7E, 0x3C, 0x7E, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8,
  0x07, 0x81, 0xE0, 0x03, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xE7,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x9F, 0xEF, 0xDF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFB, 0xE0,
  0xFC, 0xE0, 0x7E, 0x20, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFC,
  0x07, 0xF8, 0x78, 0x01, 0xFC, 0x18, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF8,
  0x70, 0x01, 0xFC, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x40, 0x00,
  0x7F, 0xB8, 0x00, 0x7F, 0x9F, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3E, 0xFE,
  0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7C, 0xFE, 0x00, 0x07, 0xCF, 0xE0, 0x00,
  0xF8, 0xFE, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F,
  0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7C, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x10, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x80, 0x01,
  0xFC, 0xE0, 0x07, 0xFC, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x7F,
  0xE0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xE3,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x9F, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01,
  0xFE, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07,
  0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFE,
  0xFF, 0x01, 0xFF, 0x3F, 0x80, 0xFF, 0x9F, 0xF3, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xF7, 0xF0, 0xFF, 0xFB, 0xF0, 0x3F, 0xF9, 0xF8, 0x0F, 0xF8,
  0xFC, 0x00, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x02, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x0F, 0x03, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x78, 0x0F, 0xF2, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x80,
  0x7C, 0x3F, 0x00, 0xFF, 0xF8, 0x7C, 0x3E, 0x01, 0xFF, 0xF8, 0x3E, 0x3E,
  0x03, 0xFF, 0xF8, 0x3E, 0x7E, 0x07, 0xF1, 0xF8, 0x3E, 0x7C, 0x07, 0xE1,
  0xF0, 0x3E, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0xFC, 0x1F,
  0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0x03,
  0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0xFC, 0x0F,
  0x87, 0x78, 0x7C, 0x7C, 0x0F, 0xCF, 0x7C, 0xFC, 0x7C, 0x0F, 0xFF, 0x7F,
  0xF8, 0x7C, 0x07, 0xFE, 0x3F, 0xF0, 0x7E, 0x03, 0xFC, 0x3F, 0xE0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x04, 0x00, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x8F, 0xE0, 0x7F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE,
  0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xE3, 0xF8, 0x03,
  0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0,
  0x1F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x78, 0x3F, 0xC0, 0x04,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x18, 0x1F, 0xFC, 0x7E, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFE, 0x1F, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF,
  0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x1F, 0xF0, 0xFE, 0x07, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x3E, 0x07, 0xFC, 0x00, 0x18, 0x0F, 0xF0,
  0x00, 0x10, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0,
  0x03, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0x0F,
  0xBF, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0xFD,
  0xF8, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x3E, 0x3F,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0xFC, 0x7E,
  0x00, 0x7C, 0x3F, 0xFC, 0x3E, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x1F, 0x81,
  0xF0, 0x3F, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0xFC, 0x07,
  0xC7, 0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xC0,
  0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xCF,
  0xC0, 0x0F, 0xFF, 0x3F, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0xFF, 0xF1, 0xF8,
  0x03, 0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x3F, 0x80,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0x07, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0, 0x7E, 0x0F, 0xFF,
  0x01, 0xFC, 0x3F, 0xFC, 0x07, 0xF0, 0xFF, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0,
  0x3F, 0x8F, 0xFF, 0x00, 0x7E, 0x3F, 0xFC, 0x01, 0xFC, 0xFF, 0xF0, 0x03,
  0xF3, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x7E,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x05, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFE, 0x1F, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0x8F, 0xFF,
  0x07, 0xF0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE0, 0x7C, 0x3F, 0xC0, 0x1C, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x80,
  0x00, 0xFE, 0xE0, 0x01, 0xFE, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x7C, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xDF, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7D, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x3E, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF3, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3E, 0x3F, 0x01,
  0xF8, 0x03, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xE1, 0xF0,
  0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x1F,
  0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x3E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC,
  0x0F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x0F,
  0x80, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0x03, 0xF9,
  0xF8, 0x07, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x01, 0xF3, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x7C, 0xFE, 0x00, 0x07, 0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x01,
  0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0xFB, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xF0, 0x7F, 0x81, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0x83, 0xF7, 0xF8, 0x07, 0xEF, 0xE0,
  0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xDF, 0xC0, 0x7F, 0xBF, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0x7C,
  0xFF, 0xF8, 0xF8, 0xFF, 0xF1, 0xF0, 0xFF, 0x83, 0xE0, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xF0, 0x3F, 0x9F, 0xFE, 0x0F, 0xEF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xF3, 0xFE, 0x3F, 0xF0, 0x3F, 0xCF,
  0xF8, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFC, 0xFF,
  0x80, 0x7F, 0x3F, 0xE0, 0x3F, 0xCF, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFC, 0x3F, 0x3F, 0xFE, 0x0F, 0xC7, 0xFF, 0x83, 0xF0, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0x3E, 0x3F, 0xC0, 0x23, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x13, 0xFE,
  0x0F, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xFF, 0x1F, 0x87, 0xFF, 0xCF,
  0xC7, 0xFF, 0xF7, 0xE7, 0xFF, 0xFB, 0xF3, 0xFE, 0x3F, 0xF9, 0xFC, 0x07,
  0xFD, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07,
  0xFB, 0xFC, 0x07, 0xFC, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xDF, 0x87, 0xFF, 0xCF, 0xC1, 0xFF, 0xC7, 0xE0, 0x7F, 0xC1, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x81, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x3F,
  0xE0, 0x3C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x1F, 0x83, 0xFF, 0x8F, 0xC3, 0xFF, 0xE7, 0xE3, 0xFF, 0xF3,
  0xF1, 0xFF, 0xFD, 0xF9, 0xFF, 0x3F, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01,
  0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x03,
  0xFE, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF, 0xEF, 0xC3, 0xFF,
  0xE7, 0xE0, 0xFF, 0xE3, 0xF0, 0x3F, 0xE3, 0xF8, 0x03, 0x81, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF2, 0x00, 0x07, 0xF9,
  0xE0, 0x07, 0xF8, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0xFE, 0x7F,
  0xF0, 0xFE, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC0, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x38, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFB, 0xF0, 0x0F, 0xF9, 0xFC, 0x07, 0xF8, 0x7E, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFD, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xF7, 0xFF, 0xF3, 0xFE, 0xFF,
  0x81, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x1F,
  0xE0, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF,
  0xFC, 0xFF, 0xF3, 0xFE, 0xFF, 0xC0, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0xFC, 0x1F, 0xE0, 0x3F, 0x1F, 0xFC, 0x0F, 0xC7, 0xFF, 0x83, 0xF3, 0xFF,
  0xF0, 0xFD, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0x8F, 0xF8, 0x0F, 0xF3, 0xFE,
  0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01,
  0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x3F, 0xE0,
  0x1F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFF, 0x87, 0xF8, 0xFD, 0xFF, 0xFE, 0x3F,
  0xBF, 0xFF, 0x0F, 0xEF, 0xFF, 0x83, 0xF9, 0xFF, 0xE0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x81, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x83, 0xFF, 0x8F, 0xC3,
  0xFF, 0xE7, 0xE3, 0xFF, 0xF3, 0xF1, 0xFF, 0xFD, 0xF9, 0xFF, 0x1F, 0xFC,
  0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xFB,
  0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xDF,
  0x8F, 0xFF, 0xEF, 0xC3, 0xFF, 0xE7, 0xE0, 0xFF, 0xE3, 0xF0, 0x3F, 0xE3,
  0xF8, 0x03, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF,
  0xDF, 0xF7, 0xEF, 0xFB, 0xFF, 0xED, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8,
  0x3C, 0x7E, 0x00, 0xCF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7E, 0xE0, 0x0F, 0xEF, 0x81, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x1F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC1, 0x0F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xE0, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x7F, 0x01, 0xFF, 0x7F, 0x87, 0xFF, 0x7F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x1F, 0xFE, 0x3F, 0x07,
  0xFC, 0x3F, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x7F,
  0x01, 0xF7, 0xC0, 0x7E, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x0F, 0xC0, 0x7D,
  0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0xF8, 0x1F, 0xC3, 0xF0, 0x3E, 0x7C, 0x0F,
  0xC1, 0xFC, 0x1F, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x8F, 0x83, 0xF0, 0x3F,
  0x07, 0xC7, 0xC1, 0xF8, 0x1F, 0x87, 0xE3, 0xE1, 0xFC, 0x0F, 0xC3, 0xE1,
  0xF0, 0xFC, 0x07, 0xF1, 0xF0, 0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x7E, 0x3F,
  0x00, 0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x0F, 0x9F, 0x80, 0x3F,
  0x3F, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x03, 0xE7, 0xE0, 0x07, 0xEF, 0x81,
  0xF3, 0xF0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x01, 0xFB, 0xE0, 0x3E, 0xF8,
  0x00, 0xFD, 0xF0, 0x1F, 0xFC, 0x00, 0x3E, 0xF0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xF1, 0xF8, 0x01,
  0xF9, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0xFE,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x47, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x80, 0x03, 0xFF, 0x20, 0x00, 0x1C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 50, 16, 4, -49 },
  { 51, 19, 18, 27, 4, -49 },
  { 94, 30, 49, 32, 1, -49 },
  { 278, 24, 56, 30, 3, -52 },
  { 446, 42, 50, 47, 3, -49 },
  { 709, 32, 50, 34, 2, -49 },
  { 909, 7, 18, 15, 4, -49 },
  { 925, 16, 60, 20, 3, -49 },
  { 1045, 15, 60, 20, 2, -49 },
  { 1158, 24, 24, 28, 2, -52 },
  { 1230, 26, 32, 30, 2, -40 },
  { 1334, 10, 17, 16, 2, -8 },
  { 1356, 15, 6, 19, 2, -21 },
  { 1368, 8, 10, 16, 4, -9 },
  { 1378, 24, 49, 26, 1, -49 },
  { 1525, 24, 50, 30, 3, -49 },
  { 1675, 17, 49, 30, 4, -49 },
  { 1780, 25, 49, 30, 2, -49 },
  { 1934, 25, 50, 30, 2, -49 },
  { 2091, 28, 49, 30, 1, -49 },
  { 2263, 24, 50, 30, 3, -49 },
  { 2413, 24, 50, 30, 3, -49 },
  { 2563, 25, 49, 30, 2, -49 },
  { 2717, 26, 50, 30, 2, -49 },
  { 2880, 25, 50, 30, 2, -49 },
  { 3037, 8, 38, 16, 4, -37 },
  { 3075, 11, 46, 16, 2, -37 },
  { 3139, 26, 31, 30, 2, -40 },
  { 3240, 26, 20, 30, 2, -34 },
  { 3305, 26, 31, 30, 2, -40 },
  { 3406, 20, 50, 23, 1, -49 },
  { 3531, 40, 55, 46, 3, -49 },
  { 3806, 32, 49, 32, 0, -49 },
  { 4002, 26, 49, 33, 5, -49 },
  { 4162, 26, 50, 31, 3, -49 },
  { 4325, 28, 49, 36, 5, -49 },
  { 4497, 20, 49, 28, 5, -49 },
  { 4620, 20, 49, 27, 5, -49 },
  { 4743, 31, 50, 37, 3, -49 },
  { 4937, 28, 49, 37, 5, -49 },
  { 5109, 16, 49, 20, 2, -49 },
  { 5207, 14, 62, 16, -3, -49 },
  { 5316, 27, 49, 32, 5, -49 },
  { 5482, 20, 49, 26, 5, -49 },
  { 5605, 40, 49, 50, 5, -49 },
  { 5850, 30, 49, 40, 5, -49 },
  { 6034, 32, 50, 38, 3, -49 },
  { 6234, 24, 49, 31, 5, -49 },
  { 6381, 32, 61, 38, 3, -49 },
  { 6625, 27, 49, 32, 5, -49 },
  { 6791, 24, 50, 28, 2, -49 },
  { 6941, 25, 49, 27, 1, -49 },
  { 7095, 27, 50, 37, 5, -49 },
  { 7264, 31, 49, 31, 0, -49 },
  { 7454, 50, 49, 49, 0, -49 },
  { 7761, 28, 49, 29, 0, -49 },
  { 7933, 28, 49, 28, 0, -49 },
  { 8105, 23, 49, 26, 1, -49 },
  { 8246, 14, 60, 21, 5, -49 },
  { 8351, 24, 49, 26, 1, -49 },
  { 8498, 15, 60, 21, 2, -49 },
  { 8611, 30, 27, 32, 1, -48 },
  { 8713, 29, 4, 29, 0, 6 },
  { 8728, 13, 11, 19, 3, -52 },
  { 8746, 23, 38, 29, 2, -37 },
  { 8856, 26, 53, 32, 4, -52 },
  { 9029, 20, 38, 25, 3, -37 },
  { 9124, 25, 53, 32, 3, -52 },
  { 9290, 24, 38, 29, 3, -37 },
  { 9404, 19, 52, 18, 1, -52 },
  { 9528, 25, 53, 32, 3, -37 },
  { 9694, 24, 52, 32, 4, -52 },
  { 9850, 7, 51, 15, 4, -51 },
  { 9895, 12, 67, 15, -1, -51 },
  { 9996, 25, 52, 29, 4, -52 },
  { 10159, 7, 52, 15, 4, -52 },
  { 10205, 40, 37, 48, 4, -37 },
  { 10390, 24, 37, 32, 4, -37 },
  { 10501, 25, 38, 31, 3, -37 },
  { 10620, 26, 53, 32, 4, -37 },
  { 10793, 25, 53, 32, 3, -37 },
  { 10959, 17, 37, 22, 4, -37 },
  { 11038, 20, 38, 24, 2, -37 },
  { 11133, 17, 46, 19, 1, -45 },
  { 11231, 24, 38, 32, 4, -37 },
  { 11345, 26, 37, 27, 0, -37 },
  { 11466, 41, 37, 43, 1, -37 },
  { 11656, 25, 37, 26, 1, -37 },
  { 11772, 26, 53, 27, 0, -37 },
  { 11945, 18, 37, 22, 2, -37 },
  { 12029, 20, 60, 24, 2, -49 },
  { 12179, 6, 68, 28, 11, -52 },
  { 12230, 19, 60, 24, 3, -49 },
  { 12373, 26, 10, 30, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_Medium68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM68PT7B_H_
