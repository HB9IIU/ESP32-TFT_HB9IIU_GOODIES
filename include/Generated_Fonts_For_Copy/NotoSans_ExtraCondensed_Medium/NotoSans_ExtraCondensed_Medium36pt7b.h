#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x33, 0xDF, 0xFB, 0x80, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0x61, 0xD8, 0x70, 0x07, 0x18, 0x0C, 0x30, 0x18,
  0x60, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFC, 0x31, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x63, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x38, 0x1C, 0x60, 0x30, 0xC0, 0x63, 0x80, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x3F, 0xE3, 0xFF, 0xBF, 0xF9, 0xCC, 0x4E, 0x60, 0x73, 0x03, 0x98,
  0x1C, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0x78,
  0x19, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0xE1, 0xBF, 0xFF, 0xDF, 0xFC, 0x3F,
  0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x1E, 0x01, 0x80, 0x7E,
  0x07, 0x01, 0xFC, 0x0E, 0x03, 0x9C, 0x18, 0x06, 0x38, 0x70, 0x1C, 0x70,
  0xE0, 0x38, 0xE1, 0x80, 0x71, 0xC7, 0x00, 0xE3, 0x8E, 0x01, 0xC7, 0x38,
  0x03, 0x8E, 0x71, 0xC3, 0x1C, 0xCF, 0xC7, 0x3B, 0x9F, 0xCF, 0xE7, 0x73,
  0x8F, 0xCC, 0xE3, 0x0F, 0x39, 0xC7, 0x00, 0x73, 0x8E, 0x00, 0xC7, 0x1C,
  0x03, 0x8E, 0x38, 0x07, 0x1C, 0x70, 0x1C, 0x38, 0xE0, 0x38, 0x71, 0x80,
  0x60, 0xE7, 0x01, 0xC0, 0xEE, 0x03, 0x81, 0xF8, 0x0E, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x80,
  0xE3, 0x80, 0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xFC, 0x39, 0xEE, 0x3C, 0xF7, 0x9E, 0xF1, 0xEF, 0x78,
  0x77, 0x3C, 0x3F, 0x9E, 0x0F, 0xCF, 0x07, 0xC7, 0x83, 0xE3, 0xE3, 0xF8,
  0xFF, 0xFC, 0x7F, 0xEF, 0x0F, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xEE, 0x66,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x67, 0xFF,
  0x7F, 0xFC, 0x7E, 0x01, 0xF0, 0x1D, 0xC1, 0xEF, 0x1E, 0x38, 0x31, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0xE7, 0x9E, 0x71, 0xC7, 0x18,
  0xE0, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80,
  0xFF, 0x0F, 0xF8, 0x79, 0xE7, 0x87, 0x3C, 0x3D, 0xC1, 0xEE, 0x0F, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xF7, 0x87, 0xBC, 0x38, 0xE3, 0xC7,
  0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFB, 0xDF,
  0xCE, 0xC7, 0x23, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1F,
  0x81, 0xFF, 0x3F, 0xFC, 0xE1, 0xE2, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xE1,
  0xE4, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x3F, 0x81, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x03, 0xDF, 0xFE, 0xFF, 0xE3, 0xFE,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xBC, 0x0E, 0xF0, 0x33, 0xC1, 0xCF, 0x06, 0x3C, 0x38, 0xF0,
  0xC3, 0xC7, 0x0F, 0x1C, 0x3C, 0xE0, 0xF3, 0x83, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE4, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF0, 0x03, 0xF0, 0x7F, 0x87, 0xFC, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xF8, 0xFF, 0xEF, 0xFF, 0x7C,
  0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03,
  0xBC, 0x3C, 0xF1, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x1E, 0x1E, 0x70, 0x79, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x78, 0x78, 0xE3,
  0xC3, 0xDF, 0x07, 0xF8, 0x0F, 0x80, 0x7F, 0x03, 0xDF, 0x1E, 0x3C, 0x70,
  0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE7, 0x87, 0x9F,
  0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7,
  0x07, 0x38, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0xF7, 0x87, 0xBE, 0x7C, 0xFE, 0xE7, 0xF7, 0x0E, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x8F, 0xF8, 0x7F, 0x83, 0xF8, 0x00,
  0x2F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF7, 0x11, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE7,
  0x9E, 0x79, 0xC7, 0x18, 0xE0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x1F, 0x1F, 0xF9,
  0xFF, 0x30, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x03, 0xF3, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00,
  0x71, 0xC0, 0x01, 0xCE, 0x0F, 0x8E, 0x61, 0xFE, 0x77, 0x0E, 0x71, 0xB8,
  0xE3, 0x8D, 0xC7, 0x1C, 0x7C, 0x70, 0xE3, 0xE3, 0x87, 0x1F, 0x1C, 0x30,
  0xF8, 0xE3, 0x86, 0xC7, 0x1C, 0x36, 0x38, 0xE3, 0xB8, 0xE7, 0x9D, 0xC7,
  0xEF, 0xCE, 0x1F, 0x7E, 0x70, 0x71, 0xE1, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x08, 0x07, 0xE7, 0x80, 0x1F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0x70, 0x3F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x01, 0xC7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFE, 0x07,
  0xFE, 0x3F, 0xFD, 0xC3, 0xEE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xB8, 0x3D, 0xFF, 0xCF, 0xF8, 0x7F, 0xF3, 0x83, 0xDC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDF,
  0xFE, 0xFF, 0xE7, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0x86,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x8F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x39, 0xFC, 0xE0, 0xFB,
  0x81, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0E, 0xE0, 0x7B, 0x83, 0xEE, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFE, 0x3F, 0x0E, 0x3C, 0x02, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78,
  0x0F, 0x7C, 0x0F, 0x3E, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xFF, 0xFF, 0x7F,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFE, 0xF8, 0xE0, 0x3F, 0x81, 0xEE,
  0x07, 0xB8, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x3C, 0x38, 0xF0, 0xE7, 0x83,
  0x9E, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xE0,
  0xE3, 0xC3, 0x8F, 0x0E, 0x1E, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x0F,
  0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xDF, 0xF0, 0x0E, 0xFD, 0xC0, 0x77,
  0xEE, 0x03, 0xFF, 0x70, 0x3B, 0xFB, 0x81, 0xDF, 0xCE, 0x0E, 0xFE, 0x70,
  0xE7, 0xF3, 0x87, 0x3F, 0x9E, 0x39, 0xFC, 0x71, 0xCF, 0xE3, 0x9C, 0x7F,
  0x1C, 0xE3, 0xF8, 0x77, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC,
  0x3F, 0x83, 0xE1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xC0,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xEE, 0x0F, 0xEE, 0x0F, 0xEF, 0x0F, 0xE7, 0x0F, 0xE7, 0x8F,
  0xE3, 0x8F, 0xE3, 0xCF, 0xE3, 0xCF, 0xE1, 0xCF, 0xE1, 0xEF, 0xE0, 0xEF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xC7,
  0x87, 0x81, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xF0, 0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x00,
  0xFC, 0x0F, 0xFC, 0xFF, 0xEE, 0x7E, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xC7, 0xC7,
  0x81, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03,
  0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0E, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0xF0, 0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0xFE,
  0x03, 0xFF, 0x0F, 0xFE, 0x39, 0xFC, 0xE0, 0xF3, 0x83, 0xCE, 0x0F, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x3C, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF8, 0x39, 0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE1, 0xE3,
  0x83, 0xCE, 0x0F, 0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xF0, 0x0F, 0xE0, 0xFF,
  0xCF, 0xFC, 0xF8, 0xE7, 0x81, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x7B, 0x83, 0xDF, 0xFC,
  0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xF7, 0x01, 0xEF, 0x03, 0xDE, 0x0F, 0x1F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xE0, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x1E, 0x1E, 0x0E,
  0x0F, 0x07, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xF1, 0xC0, 0x78, 0xE0, 0x1C,
  0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x01, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3D, 0xC0, 0x78, 0x0F,
  0x70, 0x1F, 0x03, 0x9E, 0x0F, 0xC0, 0xE7, 0x83, 0xF0, 0x79, 0xE0, 0xFC,
  0x1E, 0x38, 0x3F, 0x07, 0x8E, 0x0E, 0xE1, 0xC3, 0x87, 0x38, 0x70, 0xF1,
  0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x07, 0x1C, 0xE3, 0xC1, 0xC7, 0x1C, 0xE0,
  0x73, 0x87, 0x38, 0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x80, 0xEE, 0x1D,
  0xE0, 0x3B, 0x83, 0x70, 0x0E, 0xC0, 0xDC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x1E, 0xF0, 0x78, 0xE0, 0xF1, 0xE1, 0xC3, 0xC7, 0x83, 0x8F, 0x07,
  0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xE0, 0x79, 0xC0,
  0xE3, 0x83, 0xC7, 0x87, 0x87, 0x0E, 0x0F, 0x3C, 0x1E, 0x78, 0x1D, 0xE0,
  0x3C, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0x87, 0x07,
  0x0F, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x3D, 0xE0, 0x3B, 0x80, 0x77, 0x00,
  0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x07,
  0xB8, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0x70, 0xE0, 0xE3, 0x80, 0xE7, 0x01,
  0xDC, 0x03, 0xF8, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x3C,
  0x1C, 0x0E, 0x07, 0x0F, 0x83, 0xFE, 0x3F, 0xE3, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x07, 0xF3, 0xFF, 0x7F, 0xF7, 0x87, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xF7, 0xBF, 0x7F, 0x73, 0xE3, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xE0, 0xF7,
  0xE3, 0xFF, 0xCF, 0xCF, 0x3E, 0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF,
  0x07, 0xBE, 0x1E, 0xFF, 0xF3, 0xBF, 0xCE, 0x7E, 0x00, 0x07, 0xC3, 0xFC,
  0xFF, 0x9E, 0x27, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x27, 0xFC, 0x7F, 0x87,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC3, 0xCF, 0x1F, 0xBC, 0xFF, 0xF3, 0xCF, 0xDE, 0x1F, 0x78, 0x3D,
  0xC0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F,
  0x70, 0x3D, 0xC0, 0xF7, 0x83, 0xDE, 0x1F, 0x3F, 0xFC, 0xFF, 0x71, 0xF9,
  0xC0, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0x79, 0xE7, 0x87, 0x38, 0x1D, 0xC0,
  0xEE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x11, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x01, 0x01,
  0xFC, 0x7F, 0x0F, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0F, 0xF3,
  0xFE, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x7E, 0x73, 0xFD, 0xCF, 0x3F, 0x78, 0x7D, 0xE0, 0xF7,
  0x03, 0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D,
  0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x78, 0x7C, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x40, 0x79, 0xE7, 0xE7, 0xFF,
  0x1F, 0xF8, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x78, 0xF7, 0xE7, 0xFF, 0xBF, 0x3D, 0xF0, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E,
  0x6F, 0xFF, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xBD, 0xFB, 0xE3, 0x80, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x77, 0x87, 0xBC, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xC3, 0xDC, 0x1F, 0xE0,
  0xFF, 0x07, 0xFC, 0x3E, 0xE1, 0xE7, 0x8F, 0x1C, 0x78, 0xF3, 0xC3, 0x9E,
  0x1E, 0xF0, 0xF7, 0x83, 0xFC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xC7, 0x3F,
  0x3F, 0xBB, 0xFF, 0xFD, 0xFB, 0xFD, 0xFF, 0x8F, 0x87, 0xF8, 0x3C, 0x3F,
  0xC1, 0xE0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C,
  0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFE,
  0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0,
  0x70, 0x03, 0x87, 0x3F, 0x3B, 0xFD, 0xF9, 0xEF, 0x87, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x0F, 0x3E, 0x78, 0x79, 0xE0, 0xE7, 0x03, 0xDC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x03,
  0xDE, 0x0E, 0x38, 0x78, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0x03, 0xC3, 0x9F,
  0x8E, 0xFF, 0x3F, 0x3E, 0xF8, 0x7B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC,
  0x1E, 0xF8, 0x7B, 0xFF, 0xCF, 0xFF, 0x3D, 0xF8, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x7E, 0x73, 0xFD, 0xCF, 0x3F, 0x78, 0x7D, 0xE0, 0xF7, 0x03,
  0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xC0,
  0xF7, 0x03, 0xDE, 0x0F, 0x78, 0x7C, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x03, 0xF3, 0xFB, 0xFD, 0xFF, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x00, 0x0F, 0x0F, 0xF7, 0xFF, 0xC3, 0xF0, 0x38, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x83, 0xFF,
  0xFF, 0xF9, 0xFC, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x87, 0xFB, 0xFC, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xFC, 0xFE, 0x3F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEE, 0x1F, 0x7F, 0xBB, 0xFD, 0xCF,
  0xCE, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E, 0x0E, 0x78, 0x78, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x78, 0x1D, 0xC1, 0xF0, 0x77, 0x07, 0xC3, 0xDE, 0x1F, 0x0E, 0x78, 0xEC,
  0x38, 0xE3, 0xB0, 0xE3, 0x8E, 0xE7, 0x8E, 0x3B, 0x9E, 0x3C, 0xCE, 0x70,
  0xF7, 0x39, 0xC1, 0xDC, 0x67, 0x07, 0x71, 0xBC, 0x1D, 0xC7, 0xE0, 0x76,
  0x1F, 0x81, 0xD8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0xE1, 0xE3, 0xC7, 0x0F, 0x3C, 0x1C,
  0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x3C, 0x38, 0x71, 0xE1, 0xEF,
  0x03, 0xC0, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E, 0x0E, 0x78, 0x78, 0xE1,
  0xC3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0xB8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC1, 0xF0, 0x7C, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x87, 0xC3, 0xE0, 0xF8,
  0x1F, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x1F, 0x03,
  0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x1F, 0x03, 0xE1, 0xF8, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE1, 0xF8, 0x3E, 0x07, 0x00, 0x7C, 0x07, 0xFE, 0x3F, 0xFF, 0xE0, 0xFE,
  0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 10, 10, 14, 2, -26 },
  { 31, 15, 26, 17, 1, -26 },
  { 80, 13, 29, 16, 1, -27 },
  { 128, 23, 26, 25, 1, -26 },
  { 203, 17, 26, 18, 1, -26 },
  { 259, 4, 10, 8, 2, -26 },
  { 264, 8, 32, 11, 2, -26 },
  { 296, 8, 32, 11, 1, -26 },
  { 328, 13, 12, 15, 1, -27 },
  { 348, 14, 17, 16, 1, -21 },
  { 378, 6, 9, 8, 1, -4 },
  { 385, 8, 3, 10, 1, -11 },
  { 388, 4, 5, 8, 2, -5 },
  { 391, 12, 26, 14, 1, -26 },
  { 430, 13, 26, 16, 1, -26 },
  { 473, 9, 26, 16, 2, -26 },
  { 503, 13, 26, 16, 1, -26 },
  { 546, 13, 26, 16, 1, -26 },
  { 589, 14, 26, 16, 1, -26 },
  { 635, 12, 26, 16, 2, -26 },
  { 674, 13, 26, 16, 1, -26 },
  { 717, 14, 26, 16, 1, -26 },
  { 763, 14, 26, 16, 1, -26 },
  { 809, 13, 26, 16, 1, -26 },
  { 852, 4, 20, 9, 2, -20 },
  { 862, 6, 25, 9, 1, -20 },
  { 881, 14, 16, 16, 1, -21 },
  { 909, 14, 11, 16, 1, -18 },
  { 929, 14, 16, 16, 1, -21 },
  { 957, 11, 26, 12, 0, -26 },
  { 993, 21, 29, 24, 2, -26 },
  { 1070, 17, 26, 17, 0, -26 },
  { 1126, 13, 26, 18, 3, -26 },
  { 1169, 14, 26, 16, 2, -26 },
  { 1215, 14, 26, 19, 3, -26 },
  { 1261, 10, 26, 15, 3, -26 },
  { 1294, 10, 26, 14, 3, -26 },
  { 1327, 16, 26, 20, 2, -26 },
  { 1379, 14, 26, 20, 3, -26 },
  { 1425, 8, 26, 11, 1, -26 },
  { 1451, 8, 33, 9, -2, -26 },
  { 1484, 14, 26, 17, 3, -26 },
  { 1530, 10, 26, 14, 3, -26 },
  { 1563, 21, 26, 26, 3, -26 },
  { 1632, 16, 26, 21, 3, -26 },
  { 1684, 17, 26, 20, 2, -26 },
  { 1740, 12, 26, 16, 3, -26 },
  { 1779, 17, 32, 20, 2, -26 },
  { 1847, 14, 26, 17, 3, -26 },
  { 1893, 13, 26, 15, 1, -26 },
  { 1936, 14, 26, 14, 0, -26 },
  { 1982, 15, 26, 19, 2, -26 },
  { 2031, 17, 26, 17, 0, -26 },
  { 2087, 26, 26, 26, 0, -26 },
  { 2172, 15, 26, 15, 0, -26 },
  { 2221, 15, 26, 15, 0, -26 },
  { 2270, 12, 26, 14, 1, -26 },
  { 2309, 8, 32, 11, 2, -26 },
  { 2341, 12, 26, 14, 1, -26 },
  { 2380, 8, 32, 11, 1, -26 },
  { 2412, 15, 15, 17, 1, -26 },
  { 2441, 16, 2, 15, 0, 3 },
  { 2445, 8, 6, 10, 1, -28 },
  { 2451, 12, 20, 15, 1, -20 },
  { 2481, 14, 27, 17, 2, -27 },
  { 2529, 11, 20, 13, 1, -20 },
  { 2557, 14, 27, 17, 1, -27 },
  { 2605, 13, 20, 15, 1, -20 },
  { 2638, 11, 28, 10, 0, -28 },
  { 2677, 14, 29, 17, 1, -20 },
  { 2728, 13, 27, 17, 2, -27 },
  { 2772, 4, 27, 8, 2, -27 },
  { 2786, 7, 36, 8, -1, -27 },
  { 2818, 13, 27, 15, 2, -27 },
  { 2862, 4, 27, 8, 2, -27 },
  { 2876, 21, 20, 25, 2, -20 },
  { 2929, 13, 20, 17, 2, -20 },
  { 2962, 14, 20, 16, 1, -20 },
  { 2997, 14, 29, 17, 2, -20 },
  { 3048, 14, 29, 17, 1, -20 },
  { 3099, 9, 20, 11, 2, -20 },
  { 3122, 10, 20, 13, 1, -20 },
  { 3147, 9, 24, 10, 1, -24 },
  { 3174, 13, 19, 17, 2, -19 },
  { 3205, 14, 19, 14, 0, -19 },
  { 3239, 22, 19, 23, 0, -19 },
  { 3292, 14, 19, 14, 0, -19 },
  { 3326, 14, 28, 14, 0, -19 },
  { 3375, 10, 19, 12, 1, -19 },
  { 3399, 10, 32, 13, 1, -26 },
  { 3439, 3, 37, 15, 6, -28 },
  { 3453, 11, 32, 13, 1, -26 },
  { 3497, 14, 5, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Medium36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM36PT7B_H_
