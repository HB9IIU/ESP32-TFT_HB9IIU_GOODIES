#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x50,
  0x47, 0xDC, 0xC6, 0x55, 0xF4, 0x40, 0x66, 0x2A, 0x25, 0x0B, 0x66, 0xB0,
  0x64, 0x52, 0x2A, 0x33, 0x00, 0x70, 0xB1, 0x41, 0x87, 0x4A, 0xB7, 0x64,
  0x76, 0xE0, 0x7A, 0x49, 0x24, 0x89, 0x80, 0xC8, 0x92, 0x49, 0x2B, 0x00,
  0x25, 0x7E, 0xA5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x5C, 0xE0, 0xC0, 0x18,
  0x84, 0x42, 0x11, 0x08, 0xC0, 0x72, 0x52, 0x9C, 0xA5, 0x2B, 0x70, 0x7E,
  0x92, 0x49, 0x20, 0xF8, 0x42, 0x31, 0x18, 0x88, 0xF8, 0xF8, 0x42, 0x27,
  0x04, 0x33, 0xF0, 0x18, 0xE3, 0x96, 0x5A, 0x6F, 0xC6, 0x18, 0xF8, 0x8E,
  0xB1, 0x1B, 0xE0, 0x78, 0x8E, 0x99, 0x99, 0xE0, 0xF8, 0x46, 0x21, 0x18,
  0x84, 0x60, 0x7A, 0x52, 0xE7, 0x27, 0x29, 0x78, 0x72, 0x73, 0x95, 0x94,
  0x22, 0x70, 0xC6, 0x50, 0x05, 0xC0, 0x08, 0xDD, 0x83, 0x04, 0xF8, 0x3E,
  0x86, 0x0C, 0x13, 0x60, 0xF1, 0x13, 0x24, 0x04, 0x60, 0x7D, 0x8E, 0x6D,
  0x5A, 0xB5, 0x6A, 0xCA, 0xC0, 0xF0, 0x30, 0xC3, 0x9A, 0x49, 0xE4, 0xF3,
  0xC4, 0xF4, 0xE7, 0x2F, 0x4E, 0x33, 0xF0, 0x7E, 0x21, 0x08, 0x42, 0x18,
  0x70, 0xF4, 0xE3, 0x18, 0xC6, 0x33, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0,
  0xF8, 0x88, 0xF8, 0x88, 0x80, 0x7E, 0x21, 0x09, 0xC6, 0x39, 0x78, 0x8C,
  0x63, 0x1F, 0xC6, 0x31, 0x88, 0xED, 0xB6, 0xDB, 0xE0, 0x24, 0x92, 0x49,
  0x27, 0xA0, 0x9C, 0xA9, 0x4E, 0x5A, 0x52, 0x98, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0xC3, 0xC7, 0xE7, 0xA7, 0xAF, 0xAB, 0x9B, 0x9B, 0x93, 0xCF, 0x3E,
  0xEB, 0xBE, 0x59, 0x63, 0x8C, 0x7A, 0x28, 0xE3, 0x8E, 0x38, 0xB2, 0x70,
  0xF4, 0xA7, 0x2F, 0x42, 0x10, 0x80, 0x7A, 0x28, 0xE3, 0x8E, 0x38, 0xB2,
  0x70, 0x40, 0x80, 0xF4, 0xA7, 0x2F, 0x52, 0x52, 0x98, 0x7A, 0x10, 0xC3,
  0x0C, 0x33, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0x87, 0x34, 0x92, 0x49, 0xE3, 0x0C, 0x30, 0x88, 0xE6,
  0x53, 0x2A, 0xB5, 0x5A, 0xA9, 0xCC, 0x66, 0x23, 0x00, 0xCA, 0xDC, 0x63,
  0x19, 0x49, 0xC8, 0xCA, 0xD4, 0xE3, 0x10, 0x84, 0x20, 0xF8, 0x84, 0x42,
  0x31, 0x18, 0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10, 0x42, 0x10,
  0x42, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x30, 0xC6, 0x92, 0xC4, 0xFC,
  0x90, 0x70, 0xC2, 0xFC, 0xED, 0xA0, 0x84, 0x21, 0xE9, 0x4E, 0x73, 0x97,
  0x80, 0xF2, 0x49, 0x38, 0x11, 0x1F, 0x99, 0x99, 0x9F, 0xE9, 0x9F, 0x88,
  0xF0, 0x74, 0x4E, 0x44, 0x44, 0x44, 0xF9, 0x99, 0x99, 0xF1, 0x1F, 0x88,
  0x8F, 0x99, 0x99, 0x99, 0xDF, 0xC0, 0x51, 0x55, 0x55, 0xC0, 0x88, 0x89,
  0xAA, 0xEA, 0x99, 0xFF, 0xC0, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0x80,
  0xF9, 0x99, 0x99, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF4, 0xA7, 0x39, 0xCB,
  0xD0, 0x84, 0x00, 0xF9, 0x99, 0x99, 0xF1, 0x11, 0xFA, 0x49, 0x20, 0x7C,
  0x46, 0x19, 0xF0, 0x4B, 0xA4, 0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x8E,
  0xD4, 0xA5, 0x28, 0x80, 0x99, 0xD9, 0x5A, 0x5A, 0x56, 0x66, 0x26, 0xDA,
  0x9C, 0x45, 0x2B, 0x60, 0x8E, 0xD4, 0xA5, 0x18, 0x84, 0x66, 0x00, 0xF3,
  0x26, 0x44, 0xF0, 0x32, 0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF, 0xF8, 0xC9,
  0x24, 0x52, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 4, 11, 6, 1, -10 },
  { 18, 9, 9, 9, 0, -9 },
  { 29, 7, 9, 7, 0, -9 },
  { 37, 1, 3, 3, 1, -9 },
  { 38, 3, 11, 4, 1, -9 },
  { 43, 3, 11, 4, 0, -9 },
  { 48, 5, 5, 5, 0, -10 },
  { 52, 5, 6, 6, 0, -8 },
  { 56, 2, 3, 3, 0, -1 },
  { 57, 3, 1, 4, 0, -4 },
  { 58, 1, 2, 3, 1, -2 },
  { 59, 5, 9, 5, 0, -9 },
  { 65, 5, 9, 6, 0, -9 },
  { 71, 3, 9, 6, 1, -9 },
  { 75, 5, 9, 6, 0, -9 },
  { 81, 5, 9, 6, 0, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 4, 9, 6, 1, -9 },
  { 99, 4, 9, 6, 1, -9 },
  { 104, 5, 9, 6, 0, -9 },
  { 110, 5, 9, 6, 0, -9 },
  { 116, 5, 9, 6, 0, -9 },
  { 122, 1, 7, 3, 1, -7 },
  { 123, 2, 9, 3, 0, -7 },
  { 126, 5, 6, 6, 0, -8 },
  { 130, 5, 3, 6, 0, -6 },
  { 132, 5, 6, 6, 0, -8 },
  { 136, 4, 9, 4, 0, -9 },
  { 141, 7, 10, 9, 1, -9 },
  { 150, 6, 9, 6, 0, -9 },
  { 157, 5, 9, 6, 1, -9 },
  { 163, 5, 9, 6, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 4, 9, 5, 1, -9 },
  { 180, 4, 9, 5, 1, -9 },
  { 185, 5, 9, 7, 1, -9 },
  { 191, 5, 9, 7, 1, -9 },
  { 197, 3, 9, 4, 0, -9 },
  { 201, 3, 12, 3, -1, -9 },
  { 206, 5, 9, 6, 1, -9 },
  { 212, 4, 9, 5, 1, -9 },
  { 217, 8, 9, 10, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 6, 9, 7, 1, -9 },
  { 240, 5, 9, 6, 1, -9 },
  { 246, 6, 11, 7, 1, -9 },
  { 255, 5, 9, 6, 1, -9 },
  { 261, 5, 9, 5, 0, -9 },
  { 267, 5, 9, 5, 0, -9 },
  { 273, 5, 9, 7, 1, -9 },
  { 279, 6, 9, 6, 0, -9 },
  { 286, 9, 9, 9, 0, -9 },
  { 297, 5, 9, 5, 0, -9 },
  { 303, 5, 9, 5, 0, -9 },
  { 309, 5, 9, 5, 0, -9 },
  { 315, 3, 11, 4, 1, -9 },
  { 320, 5, 9, 5, 0, -9 },
  { 326, 3, 11, 4, 0, -9 },
  { 331, 6, 5, 6, 0, -9 },
  { 335, 6, 1, 6, 0, 1 },
  { 336, 2, 2, 4, 1, -10 },
  { 337, 5, 7, 6, 0, -7 },
  { 342, 5, 10, 6, 1, -10 },
  { 349, 3, 7, 5, 1, -7 },
  { 352, 4, 10, 6, 1, -10 },
  { 357, 4, 7, 6, 1, -7 },
  { 361, 4, 10, 3, 0, -10 },
  { 366, 4, 10, 6, 1, -7 },
  { 371, 4, 10, 6, 1, -10 },
  { 376, 1, 10, 3, 1, -10 },
  { 378, 2, 13, 3, 0, -10 },
  { 382, 4, 10, 6, 1, -10 },
  { 387, 1, 10, 3, 1, -10 },
  { 389, 7, 7, 9, 1, -7 },
  { 396, 4, 7, 6, 1, -7 },
  { 400, 4, 7, 6, 1, -7 },
  { 404, 5, 10, 6, 1, -7 },
  { 411, 4, 10, 6, 1, -7 },
  { 416, 3, 7, 4, 1, -7 },
  { 419, 4, 7, 5, 0, -7 },
  { 423, 3, 9, 4, 0, -9 },
  { 427, 4, 7, 6, 1, -7 },
  { 431, 5, 7, 5, 0, -7 },
  { 436, 8, 7, 8, 0, -7 },
  { 443, 5, 7, 5, 0, -7 },
  { 448, 5, 10, 5, 0, -7 },
  { 455, 4, 7, 4, 0, -7 },
  { 459, 4, 11, 5, 0, -9 },
  { 465, 1, 13, 5, 2, -10 },
  { 467, 3, 11, 5, 1, -9 },
  { 472, 5, 1, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Medium13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM13PT7B_H_
