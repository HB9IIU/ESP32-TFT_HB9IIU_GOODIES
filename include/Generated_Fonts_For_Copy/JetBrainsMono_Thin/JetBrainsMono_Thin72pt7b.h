#ifndef _JETBRAINSMONO_THIN72PT7B_H_
#define _JETBRAINSMONO_THIN72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00,
  0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFE, 0x31, 0xFC, 0x03, 0xF0, 0x60, 0xF8, 0x0F, 0x80, 0xC0,
  0xF8, 0x1E, 0x01, 0x80, 0xF8, 0x78, 0x03, 0x00, 0xF0, 0xF0, 0x06, 0x00,
  0xF1, 0xE0, 0x0C, 0x01, 0xE3, 0x80, 0x18, 0x03, 0xC7, 0x00, 0x30, 0x03,
  0x8E, 0x00, 0x60, 0x07, 0x1C, 0x00, 0xC0, 0x0E, 0x38, 0x01, 0x80, 0x00,
  0x78, 0x03, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x07,
  0xE0, 0xC0, 0x00, 0x07, 0xE1, 0x80, 0x00, 0x07, 0xFB, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x6F, 0xF0, 0x00, 0x00, 0xC3, 0xF0, 0x00, 0x01,
  0x83, 0xF0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x0C,
  0x03, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60,
  0x07, 0x80, 0x00, 0xC0, 0x0F, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x03, 0x00,
  0x3F, 0xC0, 0x06, 0x00, 0x7F, 0x80, 0x0C, 0x00, 0xFF, 0x00, 0x18, 0x01,
  0xEE, 0x00, 0x30, 0x03, 0xDE, 0x00, 0x60, 0x07, 0xBC, 0x00, 0xC0, 0x1E,
  0x3C, 0x01, 0x80, 0x3C, 0x7C, 0x03, 0x00, 0xF0, 0x7C, 0x06, 0x07, 0xC0,
  0x7E, 0x0C, 0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x83,
  0xFF, 0x80, 0x00, 0x03, 0x83, 0xFF, 0xE0, 0x00, 0x03, 0x83, 0xE0, 0xF8,
  0x00, 0x03, 0xC1, 0xC0, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x00, 0x70,
  0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x3C, 0x00, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x1C, 0x00,
  0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x0E, 0x00, 0x00, 0x1F,
  0xFC, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xC1,
  0xFF, 0xF0, 0x00, 0x01, 0xC1, 0xF8, 0xFC, 0x00, 0x01, 0xC0, 0xF0, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x00, 0x78, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x0E, 0x00,
  0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xE7, 0x80, 0x78, 0x00, 0x3D, 0xE0, 0x07, 0x80,
  0x0F, 0x3C, 0x00, 0xF8, 0x01, 0xE7, 0x00, 0x0F, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0x0F, 0x1C, 0x00, 0x0F, 0x03, 0xC3, 0x80, 0x01, 0xF0, 0x70, 0x70,
  0x00, 0x1E, 0x1E, 0x0E, 0x00, 0x01, 0xE3, 0x81, 0xC0, 0x00, 0x1E, 0xF0,
  0x38, 0x00, 0x03, 0xFC, 0x07, 0x00, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x03,
  0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x70, 0x00,
  0x01, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x1E, 0x78, 0x3C,
  0x00, 0x07, 0xC7, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x7C, 0x00, 0x7C, 0x0F,
  0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0x07, 0xFF, 0xF0,
  0x01, 0xE0, 0x7F, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x27, 0x80, 0x07, 0x00, 0x0F, 0x7F,
  0x80, 0x38, 0x03, 0xFF, 0xFF, 0x81, 0xC0, 0xFF, 0xE7, 0xFF, 0x0E, 0x1F,
  0xFC, 0x07, 0xFE, 0x73, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x07, 0xF1, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xE0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xDE,
  0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xE0, 0xF0,
  0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0xF0, 0x7F, 0xF8, 0x07, 0x8F,
  0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xC1, 0xEF, 0x00, 0x7F, 0x0F, 0x70, 0x00,
  0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x01, 0xC7, 0xFF, 0x80, 0x07, 0xBF, 0xFF, 0xC0, 0x0E,
  0xFE, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x7F,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xDC, 0x00, 0x7F, 0xFE, 0x78, 0x00, 0x1F,
  0xF1, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F,
  0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC, 0x0E, 0x00, 0x0F, 0xE0, 0xFF,
  0x87, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xA0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF9, 0xF8,
  0x00, 0xFF, 0x1F, 0x7E, 0x00, 0x3E, 0x00, 0xDF, 0x80, 0x1F, 0x00, 0x1F,
  0xE0, 0x07, 0x80, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0x3F, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x01, 0xF8, 0x01, 0xC0,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x07,
  0x00, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x1F, 0x80,
  0x1C, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x03,
  0xF8, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0x00,
  0x1F, 0xE0, 0x03, 0xE0, 0x0D, 0xF8, 0x00, 0x7E, 0x0F, 0x7E, 0x00, 0x1F,
  0xFF, 0x9F, 0x80, 0x01, 0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xF8, 0x78,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0xC7,
  0x80, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFE,
  0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x7E, 0x0F, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xEE, 0x00, 0x01, 0xFF, 0xB8, 0x00, 0x0E, 0xFE, 0xE0,
  0x00, 0x3B, 0xF9, 0xC0, 0x00, 0xEF, 0xE7, 0x00, 0x07, 0x3F, 0x9C, 0x00,
  0x1C, 0xFE, 0x38, 0x00, 0x63, 0xF8, 0xE0, 0x03, 0x8F, 0xE3, 0x80, 0x0E,
  0x3F, 0x87, 0x00, 0x30, 0xFE, 0x1C, 0x01, 0xC3, 0xF8, 0x38, 0x07, 0x0F,
  0xE0, 0xE0, 0x38, 0x3F, 0x83, 0x80, 0xE0, 0xFE, 0x07, 0x03, 0x83, 0xF8,
  0x1C, 0x1C, 0x0F, 0xE0, 0x70, 0x70, 0x3F, 0x80, 0xE1, 0x80, 0xFE, 0x03,
  0x8E, 0x03, 0xF8, 0x0E, 0x38, 0x0F, 0xE0, 0x1C, 0xC0, 0x3F, 0x80, 0x77,
  0x00, 0xFE, 0x00, 0xDC, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80,
  0x3F, 0x80, 0x1E, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xDC, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x07, 0xE7, 0x00,
  0x00, 0xFC, 0xE0, 0x00, 0x1F, 0x8E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x7E,
  0x3C, 0x00, 0x0F, 0xC3, 0x80, 0x01, 0xF8, 0x70, 0x00, 0x3F, 0x07, 0x00,
  0x07, 0xE0, 0xE0, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0x81, 0xC0, 0x03, 0xF0,
  0x38, 0x00, 0x7E, 0x03, 0x80, 0x0F, 0xC0, 0x70, 0x01, 0xF8, 0x0F, 0x00,
  0x3F, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x03, 0xF0, 0x07, 0x80, 0x7E, 0x00, 0x70, 0x0F, 0xC0, 0x0E, 0x01,
  0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x1C, 0x07, 0xE0, 0x03, 0xC0, 0xFC, 0x00,
  0x38, 0x1F, 0x80, 0x07, 0x03, 0xF0, 0x00, 0xF0, 0x7E, 0x00, 0x0E, 0x0F,
  0xC0, 0x01, 0xE1, 0xF8, 0x00, 0x1C, 0x3F, 0x00, 0x03, 0x87, 0xE0, 0x00,
  0x78, 0xFC, 0x00, 0x07, 0x1F, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x0E, 0x7E,
  0x00, 0x01, 0xCF, 0xC0, 0x00, 0x3D, 0xF8, 0x00, 0x03, 0xBF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x01,
  0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0xFC, 0x1E, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xC3,
  0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0xE3, 0xC0, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x6E, 0x00, 0x3D, 0xC0, 0x03, 0x70, 0x01,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E,
  0x60, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0xE7,
  0x80, 0x18, 0xE0, 0x07, 0x3C, 0x00, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x38,
  0x03, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x86, 0x00, 0xE1, 0xC0,
  0x1C, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x78, 0x06, 0x0E, 0x01,
  0xC3, 0xC0, 0x30, 0x70, 0x0E, 0x1E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C,
  0x1C, 0x07, 0x83, 0x80, 0xE0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x3C, 0x0C, 0x07,
  0x03, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x38, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x30, 0x70, 0x0E, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0x60, 0x0E, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x1E, 0x38,
  0x03, 0x87, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07, 0x8E, 0x00, 0xE1, 0xC0,
  0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE3, 0x00, 0x18, 0xE0, 0x07, 0x18, 0x00,
  0xE7, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x0F,
  0x70, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x0E, 0x70, 0x03, 0xDC, 0x00, 0x33,
  0x80, 0x0E, 0xC0, 0x01, 0xBC, 0x00, 0x76, 0x00, 0x0F, 0xC0, 0x03, 0xB0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x07, 0x71, 0xF8, 0x00, 0xF3, 0x87, 0xFE, 0xFF, 0x1C, 0x1F,
  0xFF, 0xF0, 0xE0, 0x3F, 0xFE, 0x07, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xFE, 0x00, 0xF0,
  0xFF, 0xFC, 0x0F, 0x3F, 0xFF, 0xE0, 0xF7, 0xC0, 0x3F, 0x0F, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7C, 0xFE, 0x00,
  0x0F, 0x8F, 0x78, 0x01, 0xF0, 0xF3, 0xF1, 0xFE, 0x0F, 0x1F, 0xFF, 0xC0,
  0xF0, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x01, 0xFF, 0x81, 0xC0, 0xFF, 0xFC, 0x38, 0x7F, 0xFF,
  0xC7, 0x1F, 0x80, 0x3C, 0xE7, 0xC0, 0x01, 0xDC, 0xF0, 0x00, 0x1B, 0xBC,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0x3E, 0x00, 0x0E, 0xE3, 0xE0, 0x03, 0x9C, 0x3F, 0xC7, 0xE3, 0x83,
  0xFF, 0xF8, 0x70, 0x1F, 0xFC, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0xBF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xE0, 0x7F, 0xFE, 0x1C, 0x3F, 0xFF, 0xE3, 0x8F,
  0xC0, 0x1E, 0x73, 0xE0, 0x00, 0xEE, 0x78, 0x00, 0x0D, 0xDE, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xB9, 0xE0, 0x00,
  0x37, 0x1F, 0x00, 0x1C, 0xE3, 0xF8, 0x0F, 0x9C, 0x3F, 0xFF, 0xE3, 0x81,
  0xFF, 0xF0, 0x70, 0x0F, 0xF8, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0xC0, 0x3C,
  0x3F, 0xFF, 0x07, 0x9F, 0xFF, 0xF0, 0xF7, 0xC0, 0x3F, 0x1E, 0xE0, 0x01,
  0xF3, 0xF8, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0xE3, 0xF8, 0x0F, 0xF0, 0xE7,
  0xFE, 0x1F, 0xF8, 0xEF, 0xFF, 0x3F, 0xFC, 0xEC, 0x1F, 0x30, 0x3C, 0xF8,
  0x0F, 0xA0, 0x1E, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x0E, 0xE0,
  0x03, 0xC0, 0x0E, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1E, 0x1F, 0xFF, 0x83, 0xCF, 0xFF, 0xF8, 0x7B, 0xE0, 0x1F,
  0x8F, 0x70, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x00,
  0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x3F, 0xE0, 0x0F, 0x0F, 0xFF, 0xC0, 0xF3, 0xFF, 0xFE,
  0x0F, 0x7C, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x78, 0xFC,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x3C, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0xF8, 0xF7, 0x80, 0x1F, 0x0F,
  0x3F, 0x1F, 0xE0, 0xF1, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xE0,
  0x7F, 0xFE, 0x1C, 0x3F, 0xFF, 0xE3, 0x8F, 0xC0, 0x1E, 0x73, 0xE0, 0x00,
  0xEE, 0x78, 0x00, 0x0D, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0x71, 0xF0, 0x01,
  0xCE, 0x1F, 0xE3, 0xF1, 0xC1, 0xFF, 0xFC, 0x38, 0x0F, 0xFE, 0x07, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x3F, 0xF0, 0x0F, 0x0F,
  0xFF, 0xC0, 0xF1, 0xFF, 0xFE, 0x0F, 0x3C, 0x03, 0xF8, 0xF7, 0x00, 0x0F,
  0x8F, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF8,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x03, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x01, 0xF0, 0x00,
  0xEF, 0x00, 0x1F, 0x00, 0x0E, 0xF0, 0x01, 0xF0, 0x00, 0xEF, 0x00, 0x1B,
  0x00, 0x1E, 0x70, 0x01, 0xB8, 0x01, 0xE7, 0x00, 0x3B, 0x80, 0x1C, 0x70,
  0x03, 0x98, 0x01, 0xC7, 0x80, 0x39, 0x80, 0x1C, 0x78, 0x03, 0x18, 0x01,
  0xC7, 0x80, 0x31, 0xC0, 0x3C, 0x38, 0x07, 0x1C, 0x03, 0xC3, 0x80, 0x71,
  0xC0, 0x38, 0x38, 0x07, 0x0C, 0x03, 0x83, 0xC0, 0x70, 0xC0, 0x38, 0x3C,
  0x06, 0x0E, 0x03, 0x83, 0xC0, 0x60, 0xE0, 0x78, 0x1C, 0x0E, 0x0E, 0x07,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x1C, 0x0E, 0x06, 0x07, 0x01, 0xE0, 0xC0,
  0x70, 0x70, 0x1E, 0x0C, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0xF0, 0x0E,
  0x1C, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x30, 0xE0, 0x0E, 0x1C, 0x03, 0x8E,
  0x00, 0xF1, 0x80, 0x38, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0x73, 0x80,
  0x39, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07,
  0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xDC,
  0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x3F, 0xF0, 0x00, 0x1C,
  0xFF, 0xF0, 0x00, 0x3B, 0xE1, 0xF0, 0x00, 0x77, 0x01, 0xF0, 0x00, 0xFE,
  0x00, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xF0, 0x7B, 0x80, 0x01, 0xFF, 0xF7, 0x00,
  0x01, 0xFF, 0xCE, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph JetBrainsMono_Thin72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 8, 53, 43, 18, -53 },
  { 54, 19, 22, 43, 12, -53 },
  { 107, 38, 53, 43, 3, -53 },
  { 359, 31, 73, 43, 6, -63 },
  { 642, 41, 53, 43, 1, -53 },
  { 914, 35, 54, 43, 5, -53 },
  { 1151, 5, 22, 43, 19, -53 },
  { 1165, 20, 69, 43, 15, -60 },
  { 1338, 20, 69, 43, 8, -60 },
  { 1511, 37, 37, 43, 3, -44 },
  { 1683, 33, 34, 43, 5, -41 },
  { 1824, 12, 23, 43, 14, -11 },
  { 1859, 23, 3, 43, 10, -25 },
  { 1868, 11, 11, 43, 16, -10 },
  { 1884, 29, 68, 43, 7, -60 },
  { 2131, 30, 54, 43, 7, -53 },
  { 2334, 31, 53, 43, 7, -53 },
  { 2540, 32, 53, 43, 6, -53 },
  { 2752, 29, 54, 43, 6, -53 },
  { 2948, 28, 52, 43, 7, -52 },
  { 3130, 29, 54, 43, 7, -53 },
  { 3326, 31, 54, 43, 6, -53 },
  { 3536, 32, 53, 43, 6, -53 },
  { 3748, 31, 54, 43, 6, -53 },
  { 3958, 31, 53, 43, 6, -53 },
  { 4164, 11, 41, 43, 16, -40 },
  { 4221, 13, 52, 43, 14, -40 },
  { 4306, 31, 36, 43, 6, -42 },
  { 4446, 29, 20, 43, 7, -34 },
  { 4519, 31, 36, 43, 6, -42 },
  { 4659, 24, 53, 43, 12, -53 },
  { 4818, 34, 66, 43, 5, -53 },
  { 5099, 33, 53, 43, 5, -53 },
  { 5318, 29, 53, 43, 8, -53 },
  { 5511, 29, 54, 43, 8, -53 },
  { 5707, 28, 53, 43, 8, -53 },
  { 5893, 28, 53, 43, 9, -53 },
  { 6079, 30, 53, 43, 8, -53 },
  { 6278, 29, 54, 43, 8, -53 },
  { 6474, 27, 53, 43, 8, -53 },
  { 6653, 26, 53, 43, 9, -53 },
  { 6826, 30, 54, 43, 5, -53 },
  { 7029, 31, 53, 43, 8, -53 },
  { 7235, 29, 53, 43, 9, -53 },
  { 7428, 30, 53, 43, 7, -53 },
  { 7627, 27, 53, 43, 8, -53 },
  { 7806, 28, 54, 43, 8, -53 },
  { 7995, 31, 53, 43, 8, -53 },
  { 8201, 29, 66, 43, 8, -53 },
  { 8441, 30, 53, 43, 8, -53 },
  { 8640, 31, 54, 43, 6, -53 },
  { 8850, 35, 53, 43, 4, -53 },
  { 9082, 27, 54, 43, 8, -53 },
  { 9265, 33, 53, 43, 5, -53 },
  { 9484, 37, 53, 43, 3, -53 },
  { 9730, 35, 53, 43, 4, -53 },
  { 9962, 36, 53, 43, 4, -53 },
  { 10201, 30, 53, 43, 7, -53 },
  { 10400, 16, 68, 43, 16, -60 },
  { 10536, 29, 68, 43, 7, -60 },
  { 10783, 16, 68, 43, 11, -60 },
  { 10919, 29, 29, 43, 7, -53 },
  { 11025, 35, 3, 43, 4, 2 },
  { 11039, 13, 11, 43, 14, -57 },
  { 11057, 29, 41, 43, 6, -40 },
  { 11206, 28, 54, 43, 8, -53 },
  { 11395, 28, 41, 43, 8, -40 },
  { 11539, 27, 54, 43, 8, -53 },
  { 11722, 28, 41, 43, 8, -40 },
  { 11866, 33, 53, 43, 5, -53 },
  { 12085, 27, 53, 43, 8, -40 },
  { 12264, 27, 53, 43, 8, -53 },
  { 12443, 32, 55, 43, 7, -55 },
  { 12663, 26, 68, 43, 7, -55 },
  { 12884, 30, 53, 43, 8, -53 },
  { 13083, 35, 53, 43, 4, -53 },
  { 13315, 32, 40, 43, 6, -40 },
  { 13475, 27, 40, 43, 8, -40 },
  { 13610, 28, 41, 43, 8, -40 },
  { 13754, 28, 53, 43, 8, -40 },
  { 13940, 27, 53, 43, 8, -40 },
  { 14119, 28, 40, 43, 9, -40 },
  { 14259, 30, 41, 43, 7, -40 },
  { 14413, 31, 51, 43, 5, -51 },
  { 14611, 27, 41, 43, 8, -40 },
  { 14750, 33, 40, 43, 5, -40 },
  { 14915, 36, 40, 43, 4, -40 },
  { 15095, 33, 40, 43, 5, -40 },
  { 15260, 33, 53, 43, 5, -40 },
  { 15479, 29, 40, 43, 7, -40 },
  { 15624, 29, 68, 43, 7, -60 },
  { 15871, 3, 68, 43, 20, -60 },
  { 15897, 29, 68, 43, 7, -60 },
  { 16144, 31, 13, 43, 6, -32 },
};

const GFXfont JetBrainsMono_Thin72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_THIN72PT7B_H_
