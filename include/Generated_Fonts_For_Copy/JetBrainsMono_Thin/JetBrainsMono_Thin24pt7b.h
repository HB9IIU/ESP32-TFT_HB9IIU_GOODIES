#ifndef _JETBRAINSMONO_THIN24PT7B_H_
#define _JETBRAINSMONO_THIN24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x02, 0xF8, 0xC7, 0x1C, 0x71, 0xC6,
  0x18, 0x61, 0x04, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x84, 0x04, 0x21,
  0xFF, 0xE2, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x61, 0x0F, 0xFF, 0x10,
  0x40, 0x86, 0x04, 0x20, 0x61, 0x02, 0x08, 0x00, 0x04, 0x01, 0x00, 0x40,
  0x38, 0x37, 0x91, 0x34, 0x45, 0x11, 0x44, 0x11, 0x06, 0x40, 0x70, 0x07,
  0x01, 0x60, 0x4C, 0x11, 0x04, 0x61, 0x1C, 0x45, 0x93, 0x3F, 0x01, 0x00,
  0x40, 0x10, 0x18, 0x05, 0x90, 0x24, 0x21, 0x90, 0x84, 0x42, 0x21, 0x09,
  0x04, 0x24, 0x0F, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x27, 0x01, 0x22, 0x08,
  0x8C, 0x22, 0x11, 0x08, 0x48, 0x23, 0x20, 0x8B, 0x01, 0xE0, 0x1C, 0x06,
  0x61, 0x86, 0x20, 0x44, 0x00, 0x80, 0x08, 0x01, 0x80, 0x70, 0x11, 0x06,
  0x31, 0xC3, 0x28, 0x29, 0x03, 0x20, 0x64, 0x1E, 0xC6, 0x4F, 0x84, 0xFF,
  0xF5, 0x06, 0x30, 0xC3, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xC1, 0x81, 0x03, 0x03, 0x03, 0x81, 0x80, 0xC1, 0x81,
  0x02, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30,
  0xC6, 0x33, 0x88, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2, 0x17,
  0x2F, 0x0F, 0x80, 0x60, 0x0D, 0x00, 0x98, 0x10, 0xC3, 0x04, 0x10, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x76, 0x64, 0xC8, 0x88, 0xFF, 0x7F, 0x70,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x00, 0x1E, 0x0E, 0xE6, 0x0B, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xCC, 0x73, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x05,
  0x03, 0x61, 0x8F, 0xC0, 0x06, 0x01, 0xC0, 0xD8, 0x33, 0x08, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x1F, 0xFC, 0x1E, 0x0E, 0x71, 0x03, 0x60, 0x28, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x1F, 0xFC, 0x7F, 0xDF, 0xF0, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x38, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x0D, 0x02, 0x61, 0x8F, 0xC0, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x30, 0xC8, 0x34, 0x0F, 0x03, 0xC0, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x7F, 0xDF, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x41, 0x7E, 0x60, 0x90, 0x30, 0x04, 0x01, 0x00, 0x40, 0x1C, 0x05, 0x03,
  0x61, 0x8F, 0xC0, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00,
  0x98, 0x5F, 0x98, 0x3C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03, 0x61,
  0x8F, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0x40, 0x28, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x0E, 0x0C, 0xE4, 0x0D, 0x01, 0x40, 0x50, 0x14, 0x08,
  0xC6, 0x1E, 0x07, 0x82, 0x19, 0x03, 0xC0, 0x60, 0x18, 0x07, 0x01, 0x60,
  0x8F, 0xC0, 0x0E, 0x0C, 0xE4, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01,
  0x40, 0xD8, 0x63, 0xE8, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06,
  0x00, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x70, 0xFF, 0x60, 0x00, 0x00,
  0x07, 0x66, 0x4C, 0x88, 0x80, 0x00, 0x40, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x0C, 0x0E, 0x06, 0x06, 0x06, 0x02, 0x00, 0xE0, 0xFC, 0x02, 0x03, 0x01,
  0x01, 0x01, 0x03, 0x06, 0x3C, 0x20, 0x20, 0x20, 0x00, 0x00, 0x20, 0x70,
  0x70, 0x0E, 0x07, 0x31, 0x01, 0x60, 0x38, 0x03, 0x00, 0x60, 0xCC, 0x77,
  0x88, 0x31, 0x06, 0x20, 0xC4, 0x18, 0x83, 0x10, 0x62, 0x0C, 0x37, 0x83,
  0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x3E, 0x00, 0x0C, 0x01, 0x80, 0x30,
  0x05, 0x01, 0x20, 0x24, 0x04, 0xC0, 0x88, 0x21, 0x04, 0x20, 0x82, 0x30,
  0x47, 0xF8, 0x81, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0C, 0xF8, 0x7F, 0x20,
  0x50, 0x38, 0x0C, 0x06, 0x07, 0x02, 0xFE, 0x7F, 0xA0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x83, 0x7F, 0x00, 0x1C, 0x33, 0xB0, 0x70, 0x18, 0x0C,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x03,
  0xC1, 0x1F, 0x00, 0xF0, 0x7F, 0x20, 0xD0, 0x28, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x02, 0x86, 0x7E, 0x00,
  0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1C, 0x33, 0xB0, 0x70,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x47, 0xE3, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0xC1, 0x1F, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x7F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0A, 0x02, 0x41, 0x8F, 0x80, 0x80, 0xE0,
  0x28, 0x1A, 0x04, 0x83, 0x20, 0x88, 0x62, 0x10, 0xFC, 0x23, 0x08, 0x42,
  0x18, 0x82, 0x20, 0xC8, 0x12, 0x06, 0x80, 0xA0, 0x30, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xC0, 0xF0, 0x3A, 0x0E,
  0x85, 0xA1, 0x64, 0x59, 0x26, 0x29, 0x8C, 0x63, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x80, 0xE0, 0x70, 0x38, 0x1A,
  0x0D, 0x06, 0x43, 0x21, 0x90, 0xC4, 0x62, 0x30, 0x98, 0x4C, 0x26, 0x0B,
  0x05, 0x81, 0xC0, 0xC0, 0x1C, 0x33, 0xA0, 0x50, 0x38, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xC3, 0x3F,
  0x00, 0xF8, 0x3F, 0xC8, 0x1A, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x02, 0x81,
  0xBF, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x1C, 0x33, 0xA0, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xC3, 0x3F, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0xF8, 0x3F, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x0A, 0x02, 0x81,
  0xBF, 0x88, 0x42, 0x10, 0x82, 0x20, 0x88, 0x12, 0x04, 0x80, 0xA0, 0x30,
  0x1E, 0x0C, 0xE4, 0x0D, 0x01, 0x40, 0x50, 0x04, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x07, 0x01, 0x60, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x02, 0xC3, 0x3F, 0x00, 0x80,
  0x30, 0x0E, 0x01, 0x60, 0x24, 0x0C, 0x81, 0x18, 0x21, 0x04, 0x21, 0x84,
  0x20, 0xC4, 0x08, 0x81, 0x20, 0x24, 0x06, 0x80, 0x50, 0x0C, 0x01, 0x80,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x51, 0xC5, 0x14, 0x51, 0x45, 0x14, 0x93,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x8A, 0x68, 0xA2, 0x8A, 0x30, 0xA3, 0x0A,
  0x30, 0xC3, 0x0C, 0x40, 0x36, 0x02, 0x20, 0x63, 0x04, 0x10, 0x80, 0x88,
  0x09, 0x00, 0x70, 0x06, 0x00, 0x60, 0x05, 0x00, 0x90, 0x18, 0x81, 0x0C,
  0x30, 0x42, 0x06, 0x40, 0x2C, 0x01, 0x80, 0x14, 0x03, 0x40, 0x22, 0x06,
  0x20, 0x41, 0x0C, 0x10, 0x80, 0x98, 0x09, 0x00, 0x70, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xFF, 0xF0,
  0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x3F, 0xF0, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x0F, 0xC0, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x03,
  0x00, 0xA0, 0x68, 0x13, 0x0C, 0x42, 0x19, 0x82, 0x40, 0xB0, 0x30, 0xFF,
  0xF0, 0xC4, 0x23, 0x3F, 0x18, 0x24, 0x0C, 0x01, 0x00, 0x40, 0x17, 0xFF,
  0x01, 0x80, 0x60, 0x18, 0x0D, 0x05, 0x3E, 0x40, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x05, 0xF3, 0x05, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0xC3, 0x5F, 0x00, 0x7E, 0x60, 0xA0, 0x70, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x78, 0x63, 0xE0, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0B, 0xF7, 0x0B, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0xC2, 0xBE, 0x40, 0x7E, 0x60, 0xA0, 0x70, 0x18, 0x0C, 0x07,
  0xFF, 0x00, 0x80, 0x40, 0x20, 0x78, 0x67, 0xE0, 0x03, 0xE1, 0xFC, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x3F, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x7E, 0xE1, 0x60,
  0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xD0, 0xA7, 0x90, 0x08,
  0x04, 0x06, 0x02, 0x7E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x05, 0xF3,
  0x05, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x1F, 0xFC, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x27, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x28,
  0x12, 0x0C, 0x82, 0x21, 0x08, 0xC3, 0xE0, 0x84, 0x21, 0x88, 0x22, 0x04,
  0x81, 0xA0, 0x30, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x3F, 0xFB, 0xD1, 0x8A, 0x11, 0x42, 0x38,
  0x47, 0x08, 0xE1, 0x1C, 0x23, 0x84, 0x70, 0x8E, 0x11, 0xC2, 0x38, 0x46,
  0xBE, 0x60, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x7E, 0x60, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x78, 0x67, 0xE0, 0xBE, 0x60, 0xA0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x78, 0x6B, 0xE4, 0x02, 0x01, 0x00,
  0x80, 0x00, 0x7E, 0xE1, 0x60, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x78, 0x57, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0xBF, 0x60,
  0xF0, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x00, 0x3F, 0x90, 0x34, 0x05, 0x00, 0x40, 0x0E, 0x00, 0xF8, 0x03, 0x00,
  0x40, 0x1C, 0x05, 0x03, 0x3F, 0x80, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x07, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x58, 0x67, 0xE0, 0x80, 0x78, 0x09, 0x03, 0x20,
  0x46, 0x08, 0x43, 0x08, 0x40, 0x88, 0x13, 0x02, 0x40, 0x28, 0x06, 0x00,
  0xC0, 0x86, 0x1C, 0x61, 0x46, 0x14, 0x53, 0x45, 0x24, 0x92, 0x49, 0x22,
  0x92, 0x28, 0xA2, 0x8E, 0x28, 0xC3, 0x0C, 0x30, 0xC0, 0xC0, 0xCC, 0x10,
  0x86, 0x09, 0x81, 0xA0, 0x18, 0x03, 0x00, 0x50, 0x12, 0x06, 0x20, 0x82,
  0x20, 0x6C, 0x06, 0x80, 0x68, 0x09, 0x03, 0x30, 0x42, 0x08, 0x42, 0x0C,
  0x40, 0x98, 0x1A, 0x01, 0x40, 0x38, 0x06, 0x00, 0x40, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x00, 0x7F, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x43, 0xE0, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0,
  0x0C, 0xFF, 0xFF, 0xFE, 0xF0, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x1F, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0E, 0x0C, 0x00, 0x20, 0x76, 0x18,
  0xC6, 0x19, 0x81, 0x80,
};

const GFXglyph JetBrainsMono_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 18, 14, 6, -18 },
  { 8, 6, 8, 14, 4, -18 },
  { 14, 13, 18, 14, 1, -18 },
  { 44, 10, 24, 14, 2, -21 },
  { 74, 14, 18, 14, 0, -18 },
  { 106, 11, 18, 14, 2, -18 },
  { 131, 2, 8, 14, 6, -18 },
  { 133, 7, 23, 14, 5, -20 },
  { 154, 6, 23, 14, 3, -20 },
  { 172, 12, 13, 14, 1, -15 },
  { 192, 11, 12, 14, 2, -14 },
  { 209, 4, 8, 14, 5, -4 },
  { 213, 8, 1, 14, 3, -8 },
  { 214, 4, 3, 14, 5, -3 },
  { 216, 10, 23, 14, 2, -20 },
  { 245, 10, 18, 14, 2, -18 },
  { 268, 11, 18, 14, 2, -18 },
  { 293, 11, 18, 14, 2, -18 },
  { 318, 10, 18, 14, 2, -18 },
  { 341, 10, 18, 14, 2, -18 },
  { 364, 10, 18, 14, 2, -18 },
  { 387, 10, 18, 14, 2, -18 },
  { 410, 11, 18, 14, 2, -18 },
  { 435, 10, 18, 14, 2, -18 },
  { 458, 10, 18, 14, 2, -18 },
  { 481, 4, 13, 14, 5, -13 },
  { 488, 4, 17, 14, 5, -13 },
  { 497, 10, 12, 14, 2, -14 },
  { 512, 10, 6, 14, 2, -11 },
  { 520, 10, 12, 14, 2, -14 },
  { 535, 8, 18, 14, 4, -18 },
  { 553, 11, 22, 14, 2, -18 },
  { 584, 11, 18, 14, 2, -18 },
  { 609, 9, 18, 14, 3, -18 },
  { 630, 9, 18, 14, 3, -18 },
  { 651, 9, 18, 14, 3, -18 },
  { 672, 9, 18, 14, 3, -18 },
  { 693, 10, 18, 14, 3, -18 },
  { 716, 9, 18, 14, 3, -18 },
  { 737, 9, 18, 14, 3, -18 },
  { 758, 9, 18, 14, 3, -18 },
  { 779, 10, 18, 14, 2, -18 },
  { 802, 10, 18, 14, 3, -18 },
  { 825, 10, 18, 14, 3, -18 },
  { 848, 10, 18, 14, 2, -18 },
  { 871, 9, 18, 14, 3, -18 },
  { 892, 9, 18, 14, 3, -18 },
  { 913, 10, 18, 14, 3, -18 },
  { 936, 9, 22, 14, 3, -18 },
  { 961, 10, 18, 14, 3, -18 },
  { 984, 10, 18, 14, 2, -18 },
  { 1007, 12, 18, 14, 1, -18 },
  { 1034, 9, 18, 14, 3, -18 },
  { 1055, 11, 18, 14, 2, -18 },
  { 1080, 12, 18, 14, 1, -18 },
  { 1107, 12, 18, 14, 1, -18 },
  { 1134, 12, 18, 14, 1, -18 },
  { 1161, 10, 18, 14, 2, -18 },
  { 1184, 6, 23, 14, 5, -20 },
  { 1202, 10, 23, 14, 2, -20 },
  { 1231, 5, 23, 14, 4, -20 },
  { 1246, 10, 10, 14, 2, -18 },
  { 1259, 12, 1, 14, 1, 1 },
  { 1261, 4, 4, 14, 5, -19 },
  { 1263, 10, 13, 14, 2, -13 },
  { 1280, 9, 18, 14, 3, -18 },
  { 1301, 9, 13, 14, 3, -13 },
  { 1316, 9, 18, 14, 3, -18 },
  { 1337, 9, 13, 14, 3, -13 },
  { 1352, 11, 18, 14, 2, -18 },
  { 1377, 9, 17, 14, 3, -13 },
  { 1397, 9, 18, 14, 3, -18 },
  { 1418, 11, 18, 14, 2, -18 },
  { 1443, 9, 22, 14, 2, -18 },
  { 1468, 10, 18, 14, 3, -18 },
  { 1491, 12, 18, 14, 1, -18 },
  { 1518, 11, 13, 14, 2, -13 },
  { 1536, 9, 13, 14, 3, -13 },
  { 1551, 9, 13, 14, 3, -13 },
  { 1566, 9, 17, 14, 3, -13 },
  { 1586, 9, 17, 14, 3, -13 },
  { 1606, 9, 13, 14, 3, -13 },
  { 1621, 10, 13, 14, 2, -13 },
  { 1638, 10, 17, 14, 2, -17 },
  { 1660, 9, 13, 14, 3, -13 },
  { 1675, 11, 13, 14, 2, -13 },
  { 1693, 12, 13, 14, 1, -13 },
  { 1713, 11, 13, 14, 2, -13 },
  { 1731, 11, 17, 14, 2, -13 },
  { 1755, 10, 13, 14, 2, -13 },
  { 1772, 10, 23, 14, 2, -20 },
  { 1801, 1, 23, 14, 7, -20 },
  { 1804, 10, 23, 14, 2, -20 },
  { 1833, 10, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_Thin24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_THIN24PT7B_H_
