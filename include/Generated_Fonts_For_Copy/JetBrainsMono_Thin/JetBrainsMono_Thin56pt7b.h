#ifndef _JETBRAINSMONO_THIN56PT7B_H_
#define _JETBRAINSMONO_THIN56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x99, 0xF0, 0x1E,
  0x18, 0x78, 0x3C, 0x18, 0x3C, 0x38, 0x18, 0x1C, 0x70, 0x18, 0x0E, 0x70,
  0x18, 0x0E, 0x70, 0x18, 0x0E, 0x70, 0x18, 0x0E, 0x70, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x70, 0x18, 0x00, 0x78, 0x18, 0x00, 0x38, 0x18, 0x00, 0x3C,
  0x18, 0x00, 0x1E, 0x18, 0x00, 0x0F, 0x98, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x19, 0xF0, 0x00,
  0x18, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0xE0,
  0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x0E, 0x70,
  0x18, 0x0E, 0x78, 0x18, 0x1C, 0x3C, 0x18, 0x3C, 0x1F, 0x18, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x3F, 0xF0, 0x00,
  0x1C, 0xF0, 0xF0, 0x00, 0x71, 0xC0, 0xE0, 0x00, 0xC7, 0x00, 0xE0, 0x03,
  0x0E, 0x01, 0xC0, 0x0E, 0x18, 0x01, 0x80, 0x38, 0x30, 0x03, 0x00, 0x60,
  0x60, 0x06, 0x01, 0xC0, 0xC0, 0x0C, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x03,
  0x00, 0x30, 0x30, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC1, 0x80, 0x1C,
  0x03, 0x06, 0x00, 0x1C, 0x0E, 0x1C, 0x00, 0x1F, 0xF8, 0x70, 0x00, 0x1F,
  0xE0, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x07, 0xF8, 0x00, 0x0C, 0x3F, 0xF8, 0x00, 0x38, 0x70, 0x78, 0x00, 0xE1,
  0xC0, 0x70, 0x01, 0x83, 0x00, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x1C, 0x0C,
  0x01, 0xC0, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x30, 0x07, 0x03, 0x80, 0x60,
  0x0E, 0x0E, 0x00, 0xC0, 0x1C, 0x18, 0x01, 0x80, 0x38, 0x70, 0x03, 0x00,
  0x71, 0xC0, 0x06, 0x00, 0xC3, 0x00, 0x0E, 0x03, 0x8C, 0x00, 0x0E, 0x0E,
  0x38, 0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x1C,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x70, 0x00, 0x07, 0x87, 0x00, 0x03, 0xE0, 0x70, 0x03, 0xB8, 0x0F,
  0x00, 0x77, 0x00, 0xE0, 0x1C, 0xE0, 0x0E, 0x03, 0x98, 0x00, 0xE0, 0xE3,
  0x00, 0x1E, 0x1C, 0x60, 0x01, 0xC7, 0x0C, 0x00, 0x1C, 0xE1, 0x80, 0x01,
  0xF8, 0x30, 0x00, 0x3F, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x0F, 0x83, 0x80, 0x03, 0xF8, 0x70, 0x00, 0xF7, 0x0F, 0x00, 0x3C,
  0x70, 0xE0, 0x0F, 0x07, 0x1F, 0x07, 0xC0, 0x71, 0xFF, 0xF0, 0x0E, 0x0F,
  0xF8, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEE, 0xEE, 0xE0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x07, 0x00, 0x0B,
  0x80, 0x38, 0x03, 0xDF, 0x81, 0xC0, 0xFF, 0xFF, 0x86, 0x1F, 0xF0, 0xFF,
  0x33, 0xFC, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xE0, 0x06, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0xF0, 0x07,
  0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x9C, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0xF8,
  0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0x80, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xF0, 0x03, 0xC1, 0xF0,
  0x1E, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x98, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x07, 0xE0, 0x18, 0xFF, 0xE0, 0xE7, 0xFF, 0xE3, 0xB8, 0x07, 0xCE,
  0xC0, 0x0F, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0x70, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0xE0, 0x3E, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0xFF, 0xC0,
  0x1B, 0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x0F, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xC3, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE7, 0x80, 0x07, 0x81, 0xE0,
  0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x30, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x1F, 0x8F, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0xE7, 0xC0, 0x1F, 0x9E,
  0xF8, 0x03, 0x80, 0x5F, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0xFC, 0x03,
  0x80, 0x0F, 0x80, 0x70, 0x01, 0xF0, 0x0E, 0x00, 0x3E, 0x01, 0xC0, 0x07,
  0xC0, 0x38, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xE0, 0x1C,
  0x00, 0x7C, 0x03, 0x80, 0x0F, 0x80, 0x70, 0x01, 0xF0, 0x0E, 0x00, 0x3E,
  0x01, 0xC0, 0x0F, 0xC0, 0x38, 0x01, 0xF8, 0x07, 0x80, 0x7F, 0x00, 0x78,
  0x1B, 0xE0, 0x0F, 0xFF, 0x7E, 0x00, 0xFF, 0xCF, 0xC0, 0x07, 0xE0, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0,
  0x01, 0xE3, 0x80, 0x1F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1C, 0x00,
  0xFC, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x73, 0x80, 0x01, 0xC7, 0x80, 0x03, 0x87, 0x80, 0x1E, 0x07, 0xC0, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7C,
  0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x80, 0x01,
  0xC7, 0x80, 0x03, 0x87, 0x80, 0x1E, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x80, 0x03, 0x87,
  0x80, 0x0F, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xBE, 0xC0, 0x03,
  0x7D, 0x80, 0x0E, 0xFB, 0x80, 0x19, 0xF3, 0x00, 0x33, 0xE6, 0x00, 0xC7,
  0xCE, 0x01, 0x8F, 0x8C, 0x03, 0x1F, 0x1C, 0x0C, 0x3E, 0x18, 0x18, 0x7C,
  0x30, 0x70, 0xF8, 0x70, 0xC1, 0xF0, 0x61, 0x83, 0xE0, 0xC7, 0x07, 0xC1,
  0xCC, 0x0F, 0x81, 0x98, 0x1F, 0x03, 0x70, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF6, 0x00, 0x0F,
  0xB8, 0x00, 0x7D, 0xC0, 0x03, 0xE6, 0x00, 0x1F, 0x38, 0x00, 0xF8, 0xC0,
  0x07, 0xC6, 0x00, 0x3E, 0x38, 0x01, 0xF0, 0xC0, 0x0F, 0x87, 0x00, 0x7C,
  0x18, 0x03, 0xE0, 0xC0, 0x1F, 0x07, 0x00, 0xF8, 0x18, 0x07, 0xC0, 0xE0,
  0x3E, 0x03, 0x01, 0xF0, 0x18, 0x0F, 0x80, 0xE0, 0x7C, 0x03, 0x03, 0xE0,
  0x1C, 0x1F, 0x00, 0xE0, 0xF8, 0x03, 0x07, 0xC0, 0x1C, 0x3E, 0x00, 0x61,
  0xF0, 0x03, 0x8F, 0x80, 0x1C, 0x7C, 0x00, 0x63, 0xE0, 0x03, 0x9F, 0x00,
  0x0C, 0xF8, 0x00, 0x77, 0xC0, 0x03, 0xBE, 0x00, 0x0D, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xF0, 0x3E, 0x0F, 0x00, 0x38, 0x78, 0x00, 0x71, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78,
  0x00, 0x70, 0xF0, 0x03, 0xC1, 0xE0, 0x3E, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x07, 0x0E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xF8, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xF0,
  0x3E, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0xE0, 0x0E, 0xC0,
  0x0F, 0x00, 0x76, 0x00, 0x78, 0x03, 0xB0, 0x07, 0xC0, 0x1D, 0xC0, 0x33,
  0x00, 0xEE, 0x01, 0x98, 0x06, 0x70, 0x0C, 0xC0, 0x33, 0x80, 0x66, 0x01,
  0x8C, 0x03, 0x30, 0x0C, 0x60, 0x19, 0x80, 0xE3, 0x01, 0xCC, 0x07, 0x1C,
  0x0C, 0x70, 0x38, 0xE0, 0x61, 0x81, 0xC7, 0x03, 0x0C, 0x0C, 0x38, 0x18,
  0x60, 0x61, 0xC0, 0xC3, 0x03, 0x06, 0x06, 0x18, 0x18, 0x30, 0x60, 0xC1,
  0xC1, 0x83, 0x07, 0x0E, 0x0E, 0x18, 0x18, 0x70, 0x70, 0xC0, 0xC3, 0x83,
  0x86, 0x06, 0x18, 0x1C, 0x30, 0x30, 0xC0, 0xE1, 0x81, 0x86, 0x07, 0x18,
  0x0C, 0x30, 0x18, 0xC0, 0x71, 0x80, 0xC6, 0x01, 0x9C, 0x07, 0x30, 0x0C,
  0xE0, 0x39, 0x80, 0x67, 0x01, 0xCC, 0x03, 0x30, 0x0E, 0x40, 0x19, 0x80,
  0x76, 0x00, 0xCC, 0x03, 0xB0, 0x06, 0x60, 0x0D, 0x80, 0x3B, 0x00, 0x6C,
  0x00, 0xF8, 0x03, 0x60, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x18,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0xF0,
  0x03, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3E, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFB, 0xC0, 0x03, 0x73, 0xE0,
  0x1C, 0xE3, 0xFF, 0xF1, 0xC1, 0xFF, 0x83, 0x80, 0x78, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x1F, 0xF0, 0x39, 0xFF, 0xF0, 0xEF, 0x03, 0xE3, 0xB0, 0x03,
  0xCF, 0x80, 0x07, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6F, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xF8, 0x00, 0x73, 0xF0, 0x03, 0xCE, 0xE0, 0x3E, 0x39, 0xFF, 0xF0,
  0xE1, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xF8, 0x7E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1F,
  0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0xFF, 0x06, 0x1F, 0xFE, 0x31, 0xF0, 0x79, 0x9E, 0x00, 0x6D, 0xE0,
  0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x9C,
  0x00, 0x6C, 0x78, 0x0E, 0x61, 0xFF, 0xE3, 0x07, 0xFE, 0x18, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x3E, 0x0F, 0x00, 0x38,
  0x78, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFC, 0x18, 0x7F, 0xF8, 0xC7, 0xC1, 0xE6, 0x78, 0x01,
  0xB7, 0x80, 0x05, 0xB8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xD9, 0xF0, 0x0C, 0xC7, 0xFF,
  0xE6, 0x0F, 0xFC, 0x30, 0x0F, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x1F, 0xF0, 0x38, 0xFF, 0xF0, 0xEF,
  0x03, 0xE3, 0xB0, 0x03, 0xCF, 0x80, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0xE7, 0xE0, 0xFC,
  0x77, 0xFC, 0xFF, 0xBB, 0x1E, 0x43, 0xDE, 0x07, 0xC0, 0xFF, 0x01, 0xE0,
  0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C,
  0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01,
  0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E,
  0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07,
  0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80,
  0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0E, 0xE1, 0xFF,
  0x03, 0x8F, 0xFF, 0x0E, 0x70, 0x3E, 0x3B, 0x00, 0x3C, 0xF8, 0x00, 0x73,
  0xC0, 0x01, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x7E, 0x0F, 0x00, 0x38, 0x78,
  0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x08, 0x00, 0xE1, 0xFF, 0x03, 0x9F, 0xFF, 0x0E, 0xF0, 0x3E,
  0x3B, 0x00, 0x3C, 0xF8, 0x00, 0x73, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xF0, 0x00,
  0x3B, 0xC0, 0x00, 0xEF, 0x80, 0x07, 0x3F, 0x00, 0x3C, 0xEE, 0x03, 0xE3,
  0x9F, 0xFF, 0x0E, 0x1F, 0xF0, 0x38, 0x04, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x18,
  0x7F, 0xF8, 0xC7, 0xC0, 0xE6, 0x78, 0x01, 0xB7, 0x80, 0x07, 0xB8, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3B, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x01, 0xB1, 0xE0,
  0x39, 0x87, 0xFF, 0x8C, 0x1F, 0xF8, 0x60, 0x0E, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0xE1, 0xFF, 0x03,
  0x8F, 0xFF, 0x0E, 0xF0, 0x3E, 0x3B, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7C, 0x03, 0xE1, 0xE0, 0x01, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0xE0, 0x07, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x0F, 0x00, 0x38, 0x1F, 0x03, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0C,
  0x06, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00,
  0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x6E, 0x00, 0xF0, 0x06, 0x60,
  0x0F, 0x00, 0xE6, 0x01, 0xB0, 0x0E, 0x70, 0x19, 0x00, 0xE7, 0x01, 0x98,
  0x0E, 0x70, 0x19, 0x80, 0xC7, 0x01, 0x98, 0x0C, 0x30, 0x31, 0x81, 0xC3,
  0x03, 0x18, 0x1C, 0x38, 0x30, 0xC1, 0xC3, 0x83, 0x0C, 0x1C, 0x38, 0x30,
  0xC1, 0x83, 0x87, 0x0C, 0x18, 0x18, 0x60, 0xC3, 0x81, 0x86, 0x0E, 0x38,
  0x1C, 0x60, 0x63, 0x81, 0xC6, 0x06, 0x38, 0x1C, 0xE0, 0x63, 0x01, 0xCC,
  0x06, 0x30, 0x0C, 0xC0, 0x77, 0x00, 0xCC, 0x03, 0x70, 0x0E, 0xC0, 0x37,
  0x00, 0xEC, 0x03, 0x60, 0x0F, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0x60, 0x07,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0x07, 0x9C, 0x00, 0x03, 0x8F, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x07, 0x3F, 0xC0, 0x07, 0x7B, 0xE0,
  0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x38, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x0F, 0x0E, 0xC0, 0x07, 0xFE, 0xC0, 0x01, 0xFC,
};

const GFXglyph JetBrainsMono_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 6, 41, 34, 14, -41 },
  { 32, 15, 17, 34, 9, -41 },
  { 64, 30, 41, 34, 2, -41 },
  { 218, 24, 57, 34, 5, -49 },
  { 389, 31, 41, 34, 1, -41 },
  { 548, 27, 42, 34, 4, -41 },
  { 690, 4, 17, 34, 15, -41 },
  { 699, 16, 54, 34, 11, -47 },
  { 807, 16, 54, 34, 6, -47 },
  { 915, 29, 28, 34, 2, -34 },
  { 1017, 25, 26, 34, 4, -32 },
  { 1099, 9, 17, 34, 11, -8 },
  { 1119, 18, 3, 34, 8, -20 },
  { 1126, 8, 9, 34, 13, -8 },
  { 1135, 23, 52, 34, 5, -46 },
  { 1285, 23, 42, 34, 5, -41 },
  { 1406, 24, 41, 34, 6, -41 },
  { 1529, 25, 41, 34, 5, -41 },
  { 1658, 22, 42, 34, 5, -41 },
  { 1774, 21, 41, 34, 6, -41 },
  { 1882, 22, 42, 34, 6, -41 },
  { 1998, 24, 42, 34, 5, -41 },
  { 2124, 24, 41, 34, 5, -41 },
  { 2247, 24, 42, 34, 5, -41 },
  { 2373, 24, 41, 34, 5, -41 },
  { 2496, 8, 32, 34, 13, -31 },
  { 2528, 10, 40, 34, 11, -31 },
  { 2578, 24, 28, 34, 5, -32 },
  { 2662, 23, 15, 34, 5, -26 },
  { 2706, 24, 28, 34, 5, -32 },
  { 2790, 18, 41, 34, 10, -41 },
  { 2883, 27, 51, 34, 4, -41 },
  { 3056, 26, 41, 34, 4, -41 },
  { 3190, 23, 41, 34, 6, -41 },
  { 3308, 23, 42, 34, 6, -41 },
  { 3429, 22, 41, 34, 6, -41 },
  { 3542, 22, 41, 34, 7, -41 },
  { 3655, 23, 41, 34, 6, -41 },
  { 3773, 23, 42, 34, 6, -41 },
  { 3894, 21, 41, 34, 6, -41 },
  { 4002, 20, 41, 34, 7, -41 },
  { 4105, 23, 42, 34, 4, -41 },
  { 4226, 24, 41, 34, 6, -41 },
  { 4349, 22, 41, 34, 7, -41 },
  { 4462, 23, 41, 34, 5, -41 },
  { 4580, 21, 41, 34, 6, -41 },
  { 4688, 22, 42, 34, 6, -41 },
  { 4804, 24, 41, 34, 6, -41 },
  { 4927, 23, 51, 34, 6, -41 },
  { 5074, 24, 41, 34, 6, -41 },
  { 5197, 24, 42, 34, 5, -41 },
  { 5323, 27, 41, 34, 3, -41 },
  { 5462, 22, 42, 34, 6, -41 },
  { 5578, 26, 41, 34, 4, -41 },
  { 5712, 29, 41, 34, 2, -41 },
  { 5861, 28, 41, 34, 3, -41 },
  { 6005, 28, 41, 34, 3, -41 },
  { 6149, 23, 41, 34, 5, -41 },
  { 6267, 13, 52, 34, 12, -46 },
  { 6352, 23, 52, 34, 5, -46 },
  { 6502, 12, 52, 34, 9, -46 },
  { 6580, 22, 22, 34, 6, -41 },
  { 6641, 27, 3, 34, 3, 1 },
  { 6652, 10, 8, 34, 11, -44 },
  { 6662, 23, 32, 34, 5, -31 },
  { 6754, 22, 42, 34, 6, -41 },
  { 6870, 22, 32, 34, 6, -31 },
  { 6958, 21, 42, 34, 6, -41 },
  { 7069, 22, 32, 34, 6, -31 },
  { 7157, 25, 41, 34, 4, -41 },
  { 7286, 21, 41, 34, 6, -31 },
  { 7394, 22, 41, 34, 6, -41 },
  { 7507, 25, 43, 34, 5, -43 },
  { 7642, 20, 53, 34, 5, -43 },
  { 7775, 24, 41, 34, 6, -41 },
  { 7898, 27, 41, 34, 3, -41 },
  { 8037, 25, 31, 34, 4, -31 },
  { 8134, 22, 31, 34, 6, -31 },
  { 8220, 22, 32, 34, 6, -31 },
  { 8308, 22, 41, 34, 6, -31 },
  { 8421, 21, 41, 34, 6, -31 },
  { 8529, 22, 31, 34, 7, -31 },
  { 8615, 23, 32, 34, 5, -31 },
  { 8707, 24, 39, 34, 4, -39 },
  { 8824, 22, 32, 34, 6, -31 },
  { 8912, 25, 31, 34, 4, -31 },
  { 9009, 28, 31, 34, 3, -31 },
  { 9118, 25, 31, 34, 4, -31 },
  { 9215, 25, 41, 34, 4, -31 },
  { 9344, 22, 31, 34, 6, -31 },
  { 9430, 22, 52, 34, 6, -46 },
  { 9573, 3, 52, 34, 15, -46 },
  { 9593, 22, 52, 34, 6, -46 },
  { 9736, 24, 10, 34, 5, -25 },
};

const GFXfont JetBrainsMono_Thin56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_THIN56PT7B_H_
