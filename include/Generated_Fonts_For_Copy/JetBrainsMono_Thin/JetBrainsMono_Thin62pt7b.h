#ifndef _JETBRAINSMONO_THIN62PT7B_H_
#define _JETBRAINSMONO_THIN62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x3F,
  0xFF, 0xFF, 0xFB, 0xF7, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x07,
  0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xE3, 0x1F, 0x00, 0xF0, 0x60, 0xF0, 0x3C, 0x0C,
  0x0F, 0x0F, 0x01, 0x80, 0xE1, 0xC0, 0x30, 0x1E, 0x38, 0x06, 0x01, 0xC7,
  0x00, 0xC0, 0x38, 0xE0, 0x18, 0x07, 0x1C, 0x03, 0x00, 0xE3, 0x80, 0x60,
  0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x07, 0xC3, 0x00,
  0x00, 0x7F, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xCF, 0xC0, 0x00, 0x18, 0x7C,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x80, 0x01,
  0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x1C,
  0x00, 0x18, 0x03, 0xF0, 0x03, 0x00, 0x7F, 0x00, 0x60, 0x0E, 0xE0, 0x0C,
  0x01, 0xDC, 0x01, 0x80, 0x73, 0xC0, 0x30, 0x0E, 0x38, 0x06, 0x03, 0xC7,
  0x80, 0xC0, 0xF0, 0x7C, 0x18, 0x3C, 0x07, 0xF3, 0x3F, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x7F, 0xF8, 0x00, 0x07,
  0x1F, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x70, 0x00, 0x30, 0xE0, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0x18, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x38,
  0x01, 0xC0, 0x30, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x38, 0x07, 0x07,
  0x00, 0x07, 0x01, 0xE1, 0xC0, 0x00, 0x7C, 0xF8, 0x30, 0x00, 0x07, 0xFE,
  0x0E, 0x00, 0x00, 0x7F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xF0, 0x00, 0x03, 0x83,
  0xFF, 0x80, 0x00, 0x60, 0xF0, 0x78, 0x00, 0x1C, 0x3C, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x70, 0x01, 0xC0, 0xC0, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x60, 0x1C, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x80, 0xC0, 0x0E,
  0x00, 0x70, 0x38, 0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x01, 0xC3, 0x80,
  0x03, 0x80, 0x38, 0x70, 0x00, 0x78, 0x0E, 0x1C, 0x00, 0x07, 0xC7, 0xC7,
  0x00, 0x00, 0x7F, 0xF1, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x8E,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0xE0, 0x1E,
  0x00, 0x73, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x3C, 0x03, 0x8E, 0x00, 0x3C,
  0x0E, 0x1C, 0x00, 0x38, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x70, 0x00, 0x78,
  0xE0, 0xE0, 0x00, 0x7B, 0x81, 0xC0, 0x00, 0x7F, 0x03, 0x80, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x1D, 0xE0, 0x70, 0x00, 0x79, 0xE0,
  0xF0, 0x01, 0xE1, 0xC0, 0xF0, 0x0F, 0x81, 0xC1, 0xF8, 0x7E, 0x01, 0xC1,
  0xFF, 0xF8, 0x03, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x00, 0x01, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0xFC, 0x03, 0x80, 0x7E, 0xFF, 0x83, 0x81,
  0xFF, 0x3F, 0xE3, 0x8F, 0xFC, 0x0F, 0xF9, 0xBF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF0, 0x03,
  0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x01, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x1F, 0x01,
  0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x00, 0x1C,
  0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x1E, 0x78, 0x00, 0x1C, 0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00,
  0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x3F, 0x00,
  0x70, 0xFF, 0xE0, 0x38, 0xFF, 0xFC, 0x1C, 0xF0, 0x3F, 0x0E, 0xE0, 0x07,
  0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xF0, 0x7E,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0xFF, 0x80, 0x07, 0x7F, 0xFC, 0x01, 0xDF, 0xBF, 0xE0, 0x3F, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x83, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x2E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x03,
  0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xE0, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0x7F, 0x03, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0xFE,
  0xE0, 0x0F, 0xFF, 0x38, 0x00, 0x3F, 0x87, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF,
  0xC1, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8,
  0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xFE, 0x7E, 0x00, 0x7F, 0xFD,
  0xF8, 0x03, 0xE0, 0x37, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x38, 0x00, 0xFE,
  0x01, 0xE0, 0x03, 0xF8, 0x07, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x1F, 0x80,
  0x70, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0x00, 0x07, 0xE0, 0x1C,
  0x00, 0x1F, 0x80, 0x70, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0x00,
  0x07, 0xE0, 0x1C, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x7E, 0x01, 0xC0, 0x01,
  0xF8, 0x07, 0x80, 0x0F, 0xE0, 0x0E, 0x00, 0x3F, 0x80, 0x38, 0x01, 0xFE,
  0x00, 0xF0, 0x05, 0xF8, 0x01, 0xF8, 0xF7, 0xE0, 0x03, 0xFF, 0x9F, 0x80,
  0x07, 0xFC, 0x7E, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xC0, 0x03, 0xF0, 0xE0, 0x00,
  0x7C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3C,
  0xE0, 0x00, 0x3E, 0x70, 0x00, 0x7E, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xC0,
  0x00, 0x39, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1E,
  0x1C, 0x00, 0x0E, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00,
  0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF8, 0xE0, 0x03,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xC0,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0F, 0x80, 0x1F,
  0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x07, 0xC0,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFD, 0x80, 0x00, 0xDF, 0x70, 0x00, 0x37, 0xEC, 0x00,
  0x1D, 0xFB, 0x00, 0x06, 0x7E, 0xE0, 0x03, 0x9F, 0x98, 0x00, 0xE7, 0xE7,
  0x00, 0x31, 0xF9, 0xC0, 0x1C, 0x7E, 0x30, 0x06, 0x1F, 0x8E, 0x01, 0x8F,
  0xE3, 0x80, 0xE3, 0xF8, 0x60, 0x30, 0xFE, 0x1C, 0x0C, 0x3F, 0x83, 0x07,
  0x0F, 0xE0, 0xC1, 0x83, 0xF8, 0x38, 0xE0, 0xFE, 0x06, 0x38, 0x3F, 0x81,
  0xCC, 0x0F, 0xE0, 0x77, 0x03, 0xF8, 0x0D, 0x80, 0xFE, 0x03, 0xE0, 0x3F,
  0x80, 0xF8, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFD, 0x80, 0x01, 0xFB, 0x80, 0x03, 0xF7, 0x00, 0x07, 0xE7,
  0x00, 0x0F, 0xCE, 0x00, 0x1F, 0x8C, 0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x38,
  0x00, 0xFC, 0x38, 0x01, 0xF8, 0x70, 0x03, 0xF0, 0x60, 0x07, 0xE0, 0xE0,
  0x0F, 0xC1, 0xC0, 0x1F, 0x81, 0x80, 0x3F, 0x03, 0x80, 0x7E, 0x07, 0x00,
  0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x0C, 0x07, 0xE0, 0x1C, 0x0F,
  0xC0, 0x38, 0x1F, 0x80, 0x38, 0x3F, 0x00, 0x70, 0x7E, 0x00, 0x60, 0xFC,
  0x00, 0xE1, 0xF8, 0x01, 0xC3, 0xF0, 0x01, 0xC7, 0xE0, 0x03, 0x8F, 0xC0,
  0x03, 0x1F, 0x80, 0x07, 0x3F, 0x00, 0x0E, 0x7E, 0x00, 0x0E, 0xFC, 0x00,
  0x1D, 0xF8, 0x00, 0x19, 0xF0, 0x00, 0x3B, 0xE0, 0x00, 0x77, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x07, 0x83, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x03, 0xF0, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0x80, 0x01, 0xF0, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x3E, 0x38, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0xF8,
  0x01, 0xCE, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x36, 0x00, 0x73, 0x80, 0x1B,
  0x80, 0x39, 0xC0, 0x0D, 0xC0, 0x1C, 0xE0, 0x06, 0xE0, 0x0E, 0x30, 0x03,
  0x30, 0x07, 0x1C, 0x03, 0x98, 0x03, 0x8E, 0x01, 0xCC, 0x01, 0x87, 0x00,
  0xC6, 0x01, 0xC3, 0x80, 0x63, 0x80, 0xE1, 0xC0, 0x31, 0xC0, 0x70, 0xE0,
  0x18, 0xE0, 0x38, 0x70, 0x0C, 0x30, 0x1C, 0x18, 0x0E, 0x18, 0x0E, 0x0E,
  0x07, 0x0C, 0x07, 0x07, 0x03, 0x06, 0x03, 0x03, 0x81, 0x83, 0x01, 0x81,
  0xC0, 0xC1, 0xC1, 0xC0, 0xE0, 0x60, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x70,
  0x38, 0x38, 0x18, 0x38, 0x0C, 0x1C, 0x0C, 0x1C, 0x07, 0x0C, 0x06, 0x0E,
  0x03, 0x86, 0x03, 0x06, 0x01, 0xC3, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0xE3,
  0x80, 0x70, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0xE0, 0x1C, 0x60, 0x0C,
  0x70, 0x06, 0x30, 0x06, 0x38, 0x03, 0x98, 0x03, 0x1C, 0x01, 0xCC, 0x01,
  0xCC, 0x00, 0xE6, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x73, 0x00, 0x3B, 0x80,
  0x1B, 0x80, 0x1D, 0x80, 0x0D, 0xC0, 0x0E, 0xC0, 0x06, 0xE0, 0x03, 0x60,
  0x03, 0x70, 0x01, 0xF0, 0x01, 0xB8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC7, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x38,
  0x00, 0x70, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0x81, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0xEF, 0x1F, 0x80,
  0xFB, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F, 0xFC, 0x3C, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE7,
  0xFF, 0xE0, 0xEF, 0x01, 0xF0, 0xEC, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF0,
  0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x1C, 0xF8,
  0x00, 0x3C, 0xEE, 0x00, 0x78, 0xEF, 0x81, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0xE0,
  0x38, 0x3F, 0xF8, 0x70, 0xFF, 0xFC, 0xE3, 0xE0, 0x3D, 0xCF, 0x00, 0x1F,
  0xBC, 0x00, 0x1F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0xDC, 0x7C, 0x0F, 0xB8, 0x7F, 0xFE, 0x70,
  0x3F, 0xF0, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1F, 0x81, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xFE, 0x1C, 0x3F, 0xFF, 0x38, 0xF8, 0x0F, 0x73, 0xC0, 0x06, 0xEF, 0x00,
  0x07, 0xDC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x7B, 0xC0, 0x01, 0xF3, 0xC0, 0x06, 0xE3, 0xF0, 0x79, 0xC3, 0xFF,
  0xE3, 0x81, 0xFF, 0x87, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0,
  0xE7, 0x01, 0xF0, 0xEC, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0E, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xC0, 0x0E, 0x1C, 0xFF, 0x0F, 0xF3, 0xBF, 0xE3, 0xFF, 0x7C, 0x1E, 0x61,
  0xEF, 0x01, 0xF0, 0x1F, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00,
  0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03,
  0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03,
  0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F,
  0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C,
  0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC,
  0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0,
  0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0,
  0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0x80, 0x00, 0x3E,
  0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x01, 0xF0, 0xEC, 0x00,
  0x78, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0xE1, 0xFF,
  0xC0, 0xE7, 0xFF, 0xE0, 0xEF, 0x01, 0xF0, 0xEC, 0x00, 0x78, 0xF8, 0x00,
  0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF8, 0x00,
  0x1C, 0xF8, 0x00, 0x3C, 0xEE, 0x00, 0x78, 0xE7, 0x81, 0xF0, 0xE3, 0xFF,
  0xE0, 0xE1, 0xFF, 0xC0, 0xE0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x1C, 0x3F, 0xFF, 0x38, 0xF8, 0x0F,
  0x73, 0xC0, 0x07, 0xEF, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xEE, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x9E, 0x00, 0x37, 0x1F, 0x03, 0xEE,
  0x1F, 0xFF, 0x9C, 0x0F, 0xFC, 0x38, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xF0, 0xE7,
  0x01, 0xF8, 0xEC, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0xC3,
  0xC0, 0x01, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x1D, 0xC0, 0x0F, 0x00,
  0x3B, 0x80, 0x36, 0x00, 0x77, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xD8, 0x03,
  0x9C, 0x01, 0xB0, 0x07, 0x38, 0x03, 0x30, 0x0E, 0x38, 0x0E, 0x60, 0x1C,
  0x70, 0x18, 0xC0, 0x30, 0xE0, 0x31, 0x80, 0xE1, 0xC0, 0x63, 0x01, 0xC3,
  0x80, 0xC7, 0x03, 0x87, 0x03, 0x86, 0x07, 0x07, 0x07, 0x0C, 0x0E, 0x0E,
  0x0C, 0x18, 0x18, 0x1C, 0x18, 0x30, 0x70, 0x38, 0x30, 0x70, 0xE0, 0x70,
  0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0xC3, 0x80, 0xC3, 0x01, 0x87, 0x01, 0xC6,
  0x03, 0x0C, 0x03, 0x8C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x70,
  0x0C, 0xE0, 0x1C, 0xE0, 0x19, 0xC0, 0x19, 0x80, 0x33, 0x80, 0x3B, 0x00,
  0x76, 0x00, 0x76, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xE3, 0xFC, 0x00, 0x1C, 0xFF, 0xC0, 0x03, 0xBC, 0x3C, 0x00, 0x77, 0x03,
  0xC0, 0x0F, 0xC0, 0x3C, 0x01, 0xF8, 0x03, 0xC0, 0x3F, 0x00, 0x3C, 0x07,
  0xE0, 0x03, 0xC1, 0xDC, 0x00, 0x3F, 0xFB, 0x80, 0x03, 0xFE, 0x70, 0x00,
  0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 7, 45, 37, 15, -45 },
  { 41, 17, 18, 37, 10, -45 },
  { 80, 33, 45, 37, 2, -45 },
  { 266, 27, 63, 37, 5, -54 },
  { 479, 35, 46, 37, 1, -46 },
  { 681, 31, 47, 37, 4, -46 },
  { 864, 4, 18, 37, 17, -45 },
  { 873, 17, 59, 37, 13, -52 },
  { 999, 17, 59, 37, 7, -52 },
  { 1125, 32, 32, 37, 3, -38 },
  { 1253, 28, 29, 37, 5, -35 },
  { 1355, 10, 19, 37, 12, -9 },
  { 1379, 20, 3, 37, 9, -22 },
  { 1387, 9, 10, 37, 14, -9 },
  { 1399, 25, 58, 37, 6, -51 },
  { 1581, 25, 47, 37, 6, -46 },
  { 1728, 27, 45, 37, 6, -45 },
  { 1880, 28, 46, 37, 5, -46 },
  { 2041, 24, 46, 37, 6, -45 },
  { 2179, 24, 45, 37, 6, -45 },
  { 2314, 25, 46, 37, 6, -45 },
  { 2458, 27, 46, 37, 5, -45 },
  { 2614, 28, 45, 37, 5, -45 },
  { 2772, 26, 47, 37, 6, -46 },
  { 2925, 27, 46, 37, 5, -46 },
  { 3081, 9, 36, 37, 14, -35 },
  { 3122, 11, 45, 37, 12, -35 },
  { 3184, 26, 31, 37, 6, -36 },
  { 3285, 25, 17, 37, 6, -29 },
  { 3339, 26, 31, 37, 6, -36 },
  { 3440, 20, 45, 37, 11, -45 },
  { 3553, 30, 57, 37, 4, -46 },
  { 3767, 29, 45, 37, 4, -45 },
  { 3931, 25, 45, 37, 7, -45 },
  { 4072, 25, 47, 37, 7, -46 },
  { 4219, 24, 45, 37, 7, -45 },
  { 4354, 25, 45, 37, 7, -45 },
  { 4495, 26, 45, 37, 7, -45 },
  { 4642, 25, 47, 37, 7, -46 },
  { 4789, 23, 45, 37, 7, -45 },
  { 4919, 23, 45, 37, 7, -45 },
  { 5049, 26, 46, 37, 4, -45 },
  { 5199, 26, 45, 37, 7, -45 },
  { 5346, 26, 45, 37, 7, -45 },
  { 5493, 26, 45, 37, 6, -45 },
  { 5640, 23, 45, 37, 7, -45 },
  { 5770, 24, 47, 37, 7, -46 },
  { 5911, 26, 45, 37, 7, -45 },
  { 6058, 25, 57, 37, 7, -46 },
  { 6237, 26, 45, 37, 7, -45 },
  { 6384, 27, 47, 37, 5, -46 },
  { 6543, 29, 45, 37, 4, -45 },
  { 6707, 24, 46, 37, 7, -45 },
  { 6845, 29, 45, 37, 4, -45 },
  { 7009, 33, 45, 37, 2, -45 },
  { 7195, 31, 45, 37, 3, -45 },
  { 7370, 31, 45, 37, 3, -45 },
  { 7545, 26, 45, 37, 6, -45 },
  { 7692, 14, 58, 37, 14, -51 },
  { 7794, 25, 58, 37, 6, -51 },
  { 7976, 14, 58, 37, 10, -51 },
  { 8078, 25, 24, 37, 6, -45 },
  { 8153, 29, 2, 37, 4, 2 },
  { 8161, 11, 9, 37, 12, -49 },
  { 8174, 26, 36, 37, 5, -35 },
  { 8291, 24, 46, 37, 7, -45 },
  { 8429, 24, 36, 37, 7, -35 },
  { 8537, 23, 46, 37, 7, -45 },
  { 8670, 24, 36, 37, 7, -35 },
  { 8778, 28, 45, 37, 4, -45 },
  { 8936, 23, 46, 37, 7, -35 },
  { 9069, 24, 45, 37, 7, -45 },
  { 9204, 27, 47, 37, 6, -47 },
  { 9363, 22, 58, 37, 6, -47 },
  { 9523, 26, 45, 37, 7, -45 },
  { 9670, 30, 45, 37, 3, -45 },
  { 9839, 27, 35, 37, 5, -35 },
  { 9958, 24, 35, 37, 7, -35 },
  { 10063, 24, 36, 37, 7, -35 },
  { 10171, 24, 46, 37, 7, -35 },
  { 10309, 23, 46, 37, 7, -35 },
  { 10442, 24, 35, 37, 8, -35 },
  { 10547, 25, 36, 37, 6, -35 },
  { 10660, 27, 44, 37, 4, -44 },
  { 10809, 24, 35, 37, 7, -34 },
  { 10914, 27, 34, 37, 5, -34 },
  { 11029, 31, 34, 37, 3, -34 },
  { 11161, 28, 34, 37, 5, -34 },
  { 11280, 27, 45, 37, 5, -34 },
  { 11432, 25, 34, 37, 6, -34 },
  { 11539, 25, 58, 37, 6, -51 },
  { 11721, 3, 58, 37, 17, -51 },
  { 11743, 25, 58, 37, 6, -51 },
  { 11925, 27, 12, 37, 5, -28 },
};

const GFXfont JetBrainsMono_Thin62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_THIN62PT7B_H_
