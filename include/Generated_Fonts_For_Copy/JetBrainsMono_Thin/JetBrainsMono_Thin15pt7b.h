#ifndef _JETBRAINSMONO_THIN15PT7B_H_
#define _JETBRAINSMONO_THIN15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x60, 0xDC, 0xA5, 0x29, 0x00, 0x22, 0x48, 0x97, 0xF4, 0x48,
  0x91, 0x7F, 0x49, 0x12, 0x20, 0x10, 0x20, 0xF2, 0xA9, 0x2A, 0x14, 0x1C,
  0x14, 0x26, 0x4C, 0x97, 0xC2, 0x04, 0x00, 0x70, 0xC8, 0xA4, 0x92, 0x87,
  0x40, 0x40, 0x5C, 0x29, 0x24, 0xA2, 0x61, 0xC0, 0x38, 0x89, 0x02, 0x02,
  0x1C, 0x24, 0xC6, 0x85, 0x19, 0xC8, 0xF8, 0x12, 0x48, 0x88, 0x88, 0x88,
  0x88, 0x42, 0x10, 0x84, 0x21, 0x11, 0x11, 0x11, 0x11, 0x24, 0x80, 0x10,
  0x22, 0x4B, 0xE1, 0x05, 0x11, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04,
  0x00, 0x5A, 0xF8, 0x5C, 0x06, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20,
  0x40, 0x82, 0x04, 0x10, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x32, 0x60, 0xC1,
  0x82, 0x89, 0xF0, 0x10, 0xE2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23,
  0xF8, 0x7D, 0x0A, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83, 0xF8, 0x7C,
  0x10, 0x84, 0x18, 0x10, 0x41, 0x86, 0x17, 0x80, 0x0C, 0x21, 0x04, 0x21,
  0x14, 0x61, 0x7C, 0x10, 0x40, 0x7C, 0x81, 0x02, 0x07, 0xC8, 0x80, 0x81,
  0x82, 0x89, 0xE0, 0x08, 0x20, 0x81, 0x07, 0x88, 0xA0, 0xC1, 0x82, 0x89,
  0xF0, 0xFF, 0x06, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x80, 0x38,
  0x8A, 0x0A, 0x22, 0x47, 0x11, 0x41, 0x83, 0x05, 0xF0, 0x38, 0x8A, 0x0C,
  0x18, 0x28, 0x8F, 0x04, 0x08, 0x20, 0x80, 0xE8, 0x00, 0x17, 0xE8, 0x00,
  0x12, 0x90, 0x02, 0x18, 0xC2, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x80, 0xC0, 0x60, 0x20, 0x63, 0x18, 0x40, 0xE0, 0x82, 0x11, 0x32,
  0x10, 0x04, 0x30, 0x3C, 0x86, 0x0C, 0x19, 0xF2, 0x64, 0xC9, 0x93, 0x3E,
  0x04, 0x04, 0x07, 0x00, 0x10, 0x50, 0xA1, 0x42, 0x88, 0x91, 0x3E, 0x45,
  0x06, 0x08, 0xF2, 0x28, 0x61, 0x8B, 0xC8, 0xA1, 0x86, 0x2F, 0x00, 0x7A,
  0x28, 0x60, 0x82, 0x08, 0x20, 0x86, 0x27, 0x80, 0xF4, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7C, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0,
  0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x7A, 0x28, 0x60,
  0x82, 0x0B, 0xE1, 0x86, 0x27, 0x80, 0x8C, 0x63, 0x18, 0xFE, 0x31, 0x8C,
  0x62, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x1C, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x86, 0x17, 0x80, 0x86, 0x28, 0xA4, 0x93, 0x89, 0x24, 0x8A,
  0x28, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC7,
  0x8E, 0xAD, 0x5A, 0xB2, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x8C, 0x73, 0x9A,
  0xD6, 0xB3, 0x9C, 0x62, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x5C, 0xFA,
  0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x72, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x27, 0x04, 0x08, 0x10, 0xFA, 0x18, 0x61, 0x87, 0xE9,
  0x24, 0x8A, 0x28, 0x40, 0x3C, 0x8A, 0x0A, 0x04, 0x07, 0x01, 0x01, 0x83,
  0x05, 0xF0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x5C, 0x83, 0x05, 0x12, 0x24, 0x48,
  0x8A, 0x14, 0x28, 0x50, 0x40, 0x93, 0x26, 0xAD, 0x5A, 0xB5, 0x6A, 0xD5,
  0xAA, 0x89, 0x10, 0x82, 0x89, 0x11, 0x42, 0x82, 0x0A, 0x14, 0x44, 0x8A,
  0x08, 0x83, 0x05, 0x12, 0x22, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x83, 0xF8, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F,
  0x10, 0x50, 0xA2, 0x24, 0x58, 0xC0, 0xFE, 0x8C, 0x7D, 0x10, 0x4F, 0xC6,
  0x18, 0x5F, 0x84, 0x29, 0xB8, 0xC6, 0x31, 0x8C, 0x7E, 0xFA, 0x28, 0x60,
  0x82, 0x18, 0x9E, 0x08, 0x4B, 0xB8, 0xC6, 0x31, 0x8C, 0x7E, 0xFC, 0x63,
  0xF8, 0x42, 0x2F, 0x1E, 0x20, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x80, 0xFC, 0x63, 0x18, 0xC7, 0x65, 0x08, 0x5C, 0x84, 0x29, 0xB8, 0xC6,
  0x31, 0x8C, 0x62, 0x18, 0x00, 0x03, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23,
  0xF8, 0x0C, 0x00, 0x1E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0B, 0xC0,
  0x82, 0x08, 0x23, 0x8A, 0x4E, 0x24, 0x92, 0x28, 0x40, 0xE0, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0xFF, 0x26, 0x4C, 0x99, 0x32,
  0x64, 0xC9, 0xFC, 0x63, 0x18, 0xC6, 0x31, 0xFC, 0x63, 0x18, 0xC6, 0x2E,
  0xFC, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0xFC, 0x63, 0x18, 0xC6, 0x3F,
  0x08, 0x42, 0xFA, 0x18, 0x60, 0x82, 0x08, 0x20, 0x7C, 0x85, 0x03, 0xC0,
  0x40, 0x60, 0xBE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x70, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x82, 0x89, 0x12, 0x22, 0x85, 0x0A,
  0x08, 0x93, 0x26, 0xAD, 0x5A, 0xAD, 0x91, 0x22, 0xC6, 0x88, 0xA0, 0x82,
  0x85, 0x11, 0x41, 0x82, 0x89, 0x11, 0x22, 0x85, 0x04, 0x08, 0x10, 0x40,
  0x80, 0xF8, 0x44, 0x44, 0x22, 0x1F, 0x0E, 0x20, 0x40, 0x80, 0x82, 0x3C,
  0x08, 0x08, 0x20, 0x40, 0x80, 0x80, 0xC0, 0xFF, 0xFC, 0xE0, 0x20, 0x40,
  0x82, 0x02, 0x07, 0x88, 0x20, 0x20, 0x40, 0x82, 0x18, 0x00, 0x63, 0x26,
  0x30,
};

const GFXglyph JetBrainsMono_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 11, 9, 4, -11 },
  { 3, 5, 5, 9, 2, -11 },
  { 7, 7, 11, 9, 1, -11 },
  { 17, 7, 15, 9, 1, -13 },
  { 31, 9, 11, 9, 0, -11 },
  { 44, 7, 11, 9, 1, -11 },
  { 54, 1, 5, 9, 4, -11 },
  { 55, 4, 15, 9, 3, -13 },
  { 63, 4, 15, 9, 2, -13 },
  { 71, 7, 7, 9, 1, -9 },
  { 78, 7, 7, 9, 1, -8 },
  { 85, 2, 4, 9, 3, -2 },
  { 86, 5, 1, 9, 2, -5 },
  { 87, 3, 2, 9, 3, -2 },
  { 88, 7, 14, 9, 1, -12 },
  { 101, 7, 11, 9, 1, -11 },
  { 111, 7, 11, 9, 1, -11 },
  { 121, 7, 11, 9, 1, -11 },
  { 131, 6, 11, 9, 1, -11 },
  { 140, 6, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 7, 11, 9, 1, -11 },
  { 169, 7, 11, 9, 1, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 7, 11, 9, 1, -11 },
  { 199, 3, 8, 9, 3, -8 },
  { 202, 3, 10, 9, 3, -8 },
  { 206, 7, 8, 9, 1, -9 },
  { 213, 7, 4, 9, 1, -7 },
  { 217, 7, 8, 9, 1, -9 },
  { 224, 5, 11, 9, 3, -11 },
  { 231, 7, 14, 9, 1, -11 },
  { 244, 7, 11, 9, 1, -11 },
  { 254, 6, 11, 9, 2, -11 },
  { 263, 6, 11, 9, 2, -11 },
  { 272, 5, 11, 9, 2, -11 },
  { 279, 6, 11, 9, 2, -11 },
  { 288, 6, 11, 9, 2, -11 },
  { 297, 6, 11, 9, 2, -11 },
  { 306, 5, 11, 9, 2, -11 },
  { 313, 5, 11, 9, 2, -11 },
  { 320, 6, 11, 9, 1, -11 },
  { 329, 6, 11, 9, 2, -11 },
  { 338, 6, 11, 9, 2, -11 },
  { 347, 7, 11, 9, 1, -11 },
  { 357, 5, 11, 9, 2, -11 },
  { 364, 5, 11, 9, 2, -11 },
  { 371, 6, 11, 9, 2, -11 },
  { 380, 6, 14, 9, 2, -11 },
  { 391, 6, 11, 9, 2, -11 },
  { 400, 7, 11, 9, 1, -11 },
  { 410, 7, 11, 9, 1, -11 },
  { 420, 5, 11, 9, 2, -11 },
  { 427, 7, 11, 9, 1, -11 },
  { 437, 7, 11, 9, 1, -11 },
  { 447, 7, 11, 9, 1, -11 },
  { 457, 7, 11, 9, 1, -11 },
  { 467, 7, 11, 9, 1, -11 },
  { 477, 4, 14, 9, 3, -12 },
  { 484, 7, 14, 9, 1, -12 },
  { 497, 4, 14, 9, 2, -12 },
  { 504, 7, 6, 9, 1, -11 },
  { 510, 7, 1, 9, 1, 0 },
  { 511, 3, 2, 9, 3, -12 },
  { 512, 6, 8, 9, 1, -8 },
  { 518, 5, 11, 9, 2, -11 },
  { 525, 6, 8, 9, 2, -8 },
  { 531, 5, 11, 9, 2, -11 },
  { 538, 5, 8, 9, 2, -8 },
  { 543, 7, 11, 9, 1, -11 },
  { 553, 5, 11, 9, 2, -8 },
  { 560, 5, 11, 9, 2, -11 },
  { 567, 7, 11, 9, 1, -11 },
  { 577, 6, 14, 9, 1, -11 },
  { 588, 6, 11, 9, 2, -11 },
  { 597, 7, 11, 9, 1, -11 },
  { 607, 7, 8, 9, 1, -8 },
  { 614, 5, 8, 9, 2, -8 },
  { 619, 5, 8, 9, 2, -8 },
  { 624, 5, 11, 9, 2, -8 },
  { 631, 5, 11, 9, 2, -8 },
  { 638, 6, 8, 9, 2, -8 },
  { 644, 7, 8, 9, 1, -8 },
  { 651, 7, 11, 9, 1, -11 },
  { 661, 5, 8, 9, 2, -8 },
  { 666, 7, 8, 9, 1, -8 },
  { 673, 7, 8, 9, 1, -8 },
  { 680, 7, 8, 9, 1, -8 },
  { 687, 7, 11, 9, 1, -8 },
  { 697, 5, 8, 9, 2, -8 },
  { 702, 7, 14, 9, 1, -12 },
  { 715, 1, 14, 9, 4, -12 },
  { 717, 7, 14, 9, 1, -12 },
  { 730, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_Thin15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_THIN15PT7B_H_
