#ifndef _JETBRAINSMONO_THIN35PT7B_H_
#define _JETBRAINSMONO_THIN35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x44, 0x44, 0x44, 0x44, 0x44, 0x40, 0x00,
  0x6F, 0xFE, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x60, 0x01, 0x81, 0x80, 0x20, 0x30, 0x04, 0x04, 0x00, 0x80,
  0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x10, 0x7F, 0xFF,
  0xE0, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x40, 0x40, 0x08, 0x08,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x0C, 0x04, 0x01, 0x81, 0x80, 0x30, 0x30, 0x04, 0x06, 0x00, 0x80, 0x80,
  0x30, 0x10, 0x06, 0x06, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x7C, 0x03, 0xFE, 0x0C, 0x46, 0x30, 0x86, 0x61, 0x0C, 0x82, 0x0D,
  0x04, 0x1B, 0x08, 0x06, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x0E, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x04, 0xE0, 0x08, 0xE0, 0x10, 0xC0, 0x20, 0xC0, 0x41,
  0x80, 0x83, 0xC1, 0x07, 0x82, 0x0D, 0x84, 0x1B, 0x88, 0x63, 0xD7, 0x81,
  0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x1C,
  0x00, 0x2F, 0xE0, 0x0D, 0x86, 0x03, 0x60, 0xC0, 0x4C, 0x18, 0x11, 0x83,
  0x06, 0x30, 0x61, 0x86, 0x0C, 0x20, 0xC1, 0x8C, 0x08, 0x33, 0x01, 0xDC,
  0x40, 0x1F, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x80, 0x0C,
  0xFC, 0x03, 0x18, 0xC0, 0x46, 0x0C, 0x18, 0xC1, 0x86, 0x18, 0x30, 0x83,
  0x06, 0x20, 0x60, 0xCC, 0x0C, 0x1B, 0x01, 0x83, 0x40, 0x18, 0xD8, 0x01,
  0xF0, 0x03, 0xC0, 0x03, 0xFC, 0x01, 0xC3, 0x80, 0x60, 0x60, 0x30, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x18, 0xC0, 0x64, 0x18, 0x1B, 0x03,
  0x0C, 0xC0, 0x63, 0x30, 0x19, 0x8C, 0x03, 0x43, 0x00, 0x70, 0xC0, 0x0C,
  0x30, 0x07, 0x0C, 0x03, 0x61, 0x81, 0x8C, 0x71, 0xC1, 0x87, 0xE0, 0x70,
  0xFF, 0xFF, 0xFF, 0x69, 0x00, 0x01, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xC0, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x83, 0xC3, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x80, 0xBE, 0x10, 0xF9, 0xFA, 0x7C,
  0x07, 0xFC, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x31, 0x80,
  0x0E, 0x38, 0x01, 0x83, 0x00, 0x60, 0x30, 0x18, 0x03, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x39, 0xCC, 0xE7, 0x31, 0x98, 0xC6,
  0x20, 0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x08, 0x3C, 0x38, 0x78, 0x70, 0xF0,
  0x61, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x6C, 0x01, 0x98, 0x03, 0x18, 0x0C, 0x3E, 0xF8, 0x1F, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x40, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xF0, 0x30, 0x18, 0x60, 0x0C, 0xC0, 0x0C,
  0xC0, 0x06, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xD8, 0x06,
  0x38, 0x70, 0x7F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x7F, 0xFC, 0xFF, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7, 0x81, 0xBF, 0xC3, 0xC1,
  0xC7, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x2C, 0x00, 0x48, 0x01, 0x98, 0x03, 0x38, 0x0C, 0x3C,
  0x70, 0x1F, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0xBF, 0x87, 0xC7, 0x8E, 0x03, 0x98, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD8, 0x03, 0x18, 0x0C,
  0x3C, 0x78, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xB0, 0x03, 0x60, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xC0, 0x63, 0x00,
  0x66, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x02, 0x60, 0x0C, 0x60, 0x10,
  0x60, 0xE0, 0x73, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0x1C, 0x18, 0x0C, 0x60,
  0x0C, 0x80, 0x1B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD8, 0x03,
  0x30, 0x06, 0x3C, 0x38, 0x3F, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xC0, 0x63,
  0x00, 0x66, 0x00, 0x58, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1A, 0x00, 0x76, 0x00, 0xC6, 0x03, 0x87, 0xFE, 0x07, 0xCC,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x27, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xE0, 0x11, 0xF7, 0xDF, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xC7, 0x1C, 0x61,
  0x8C, 0x30, 0xC2, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x80,
  0x00, 0xF8, 0x0F, 0xF0, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x03, 0xC3, 0xF0, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x06, 0x03, 0x86, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x3E, 0xF0, 0x3F, 0xF8, 0x30, 0x7C, 0x18, 0x1E, 0x08, 0x0F, 0x04, 0x07,
  0x82, 0x03, 0xC1, 0x01, 0xE0, 0x80, 0xF0, 0x40, 0x78, 0x20, 0x3C, 0x18,
  0x1E, 0x0C, 0x1F, 0x03, 0xFF, 0x80, 0xFB, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x08, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x04, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x20, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x0F, 0xFE, 0x0F, 0xFF, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x11, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x00, 0xC0, 0xFE, 0x03, 0xFF, 0x8C,
  0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0B,
  0x00, 0x6C, 0x03, 0xB0, 0x1C, 0xFF, 0xC3, 0xFF, 0x8C, 0x03, 0x30, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xB0, 0x0E, 0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0x03, 0x38,
  0x06, 0xC0, 0x1B, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0x98, 0x0E,
  0x38, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFE, 0x30, 0x39, 0x80, 0x6C, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xD8, 0x0E, 0xFF, 0xC7, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0xFF, 0xEC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0x03,
  0x38, 0x06, 0xC0, 0x1B, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0x98,
  0x0E, 0x38, 0xF0, 0x7F, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x34, 0x00, 0x6C, 0x00,
  0x98, 0x03, 0x18, 0x0E, 0x3C, 0x78, 0x1F, 0xC0, 0xC0, 0x07, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0,
  0x61, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0F, 0xF8, 0x1F, 0xF0, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03, 0x18,
  0x03, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0C, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x80, 0xBD, 0x01, 0x7B, 0x06, 0xF2, 0x09, 0xE4, 0x13, 0xCC, 0x67,
  0x88, 0x8F, 0x19, 0x1E, 0x36, 0x3C, 0x28, 0x78, 0x70, 0xF0, 0x41, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xE8, 0x0F, 0x60, 0x7B, 0x03, 0xC8, 0x1E, 0x60,
  0xF1, 0x07, 0x8C, 0x3C, 0x61, 0xE1, 0x0F, 0x0C, 0x78, 0x23, 0xC1, 0x9E,
  0x0C, 0xF0, 0x27, 0x81, 0xBC, 0x05, 0xE0, 0x3F, 0x01, 0xB8, 0x05, 0xC0,
  0x3E, 0x00, 0xC0, 0x0F, 0x81, 0xFF, 0x18, 0x0D, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x06, 0x38, 0xE0, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0xEC, 0x03, 0x9F, 0xFE,
  0x3F, 0xE0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0F,
  0x80, 0xFF, 0x86, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x68, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x1B,
  0x00, 0x6C, 0x01, 0x98, 0x0C, 0x38, 0xE0, 0x7F, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0x01,
  0xE6, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x05,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC, 0x07, 0x9F, 0xFC, 0x30, 0x60, 0x60,
  0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x86, 0x03, 0x0C, 0x03, 0x18, 0x06,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x0D, 0x80, 0x1C, 0x07, 0xC0, 0x3F, 0xE0,
  0xC0, 0x63, 0x00, 0x66, 0x00, 0xC8, 0x00, 0xD0, 0x01, 0xB0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xD8, 0x01, 0xB8, 0x06, 0x3C, 0x38, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x06, 0x38, 0xE0, 0xFE, 0x00,
  0xC0, 0x01, 0xB0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x31, 0x80,
  0x10, 0xC0, 0x18, 0x60, 0x0C, 0x10, 0x04, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x01, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x06, 0x10,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x68, 0x1C,
  0x09, 0x03, 0x81, 0x20, 0x50, 0x26, 0x0A, 0x0C, 0xC1, 0x41, 0x98, 0x2C,
  0x33, 0x0D, 0x86, 0x61, 0xB0, 0xC4, 0x32, 0x10, 0x84, 0x42, 0x10, 0x88,
  0x43, 0x11, 0x08, 0x62, 0x33, 0x0C, 0xC6, 0x61, 0x98, 0xCC, 0x32, 0x09,
  0x86, 0x41, 0x20, 0x48, 0x24, 0x09, 0x04, 0x81, 0xA0, 0x90, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xC0, 0x01,
  0xB0, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x60, 0x18, 0x30, 0x06, 0x30, 0x01, 0x10, 0x00, 0xD8, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x30, 0x03, 0x08,
  0x03, 0x06, 0x01, 0x01, 0x01, 0x80, 0xC1, 0x80, 0x30, 0xC0, 0x18, 0xC0,
  0x06, 0x60, 0x03, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00,
  0xCC, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x18, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0x01,
  0x80, 0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x8C, 0x03, 0x18,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0xC0, 0x61, 0x80, 0xC6, 0x00, 0xDC,
  0x01, 0xC0, 0xFF, 0xFF, 0x80, 0xE0, 0xC3, 0x07, 0x01, 0x00, 0x3F, 0xC3,
  0x83, 0x8C, 0x06, 0x60, 0x0D, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x3F, 0xF3, 0xFF, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0D, 0x80, 0x77, 0x87, 0xC7, 0xF3, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x08, 0x1B, 0xFC, 0xF0, 0x77, 0x01, 0xB0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x06, 0xF8, 0x76,
  0x7E, 0x00, 0x02, 0x00, 0x7F, 0x87, 0x07, 0x18, 0x0E, 0xC0, 0x1B, 0x00,
  0x28, 0x00, 0xA0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0xB0, 0x06, 0xC0, 0x19, 0x80, 0xE3, 0x8F, 0x07,
  0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x08,
  0x67, 0xFB, 0x70, 0x7B, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x6C, 0x07, 0x70, 0xF8, 0xFC, 0xC0, 0x02, 0x01, 0xFF, 0x1C,
  0x1C, 0xC0, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x03, 0xC0, 0x1B,
  0x01, 0x8E, 0x1C, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x01, 0xFE,
  0xDC, 0x1E, 0xC0, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x07, 0x70,
  0x79, 0xFE, 0xC0, 0x86, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x71, 0xFF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x08, 0x1B, 0xFC, 0xF0, 0x77, 0x01, 0xB0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x78, 0xFF, 0x80, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x06, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0x7F, 0x80, 0xFF, 0x01, 0x83, 0x03, 0x07, 0x06, 0x06,
  0x0C, 0x06, 0x18, 0x0E, 0x30, 0x0C, 0x60, 0x0C, 0xC0, 0x1D, 0x80, 0x1C,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x08, 0x11, 0x7C, 0xFA,
  0x8E, 0x1E, 0x1C, 0x3C, 0x10, 0x70, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81,
  0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x02, 0x06,
  0xFF, 0x3C, 0x1D, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x02, 0x00, 0xFE, 0x1C, 0x1C,
  0xC0, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x01,
  0x8E, 0x38, 0x3F, 0x80, 0x02, 0x06, 0xFF, 0x3C, 0x1D, 0xC0, 0x6C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xBE, 0x19, 0x9F,
  0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x02,
  0x01, 0xFE, 0xDC, 0x1E, 0xC0, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1B, 0x01, 0xDC, 0x3E, 0x3F, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x03, 0x3F, 0x8D, 0x83, 0xB8,
  0x06, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xC0, 0x63, 0x00,
  0x66, 0x00, 0x4C, 0x00, 0x58, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0x40,
  0x06, 0xC0, 0x18, 0xE0, 0x70, 0xFF, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x60,
  0x31, 0xC7, 0x07, 0xF0, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x66,
  0x00, 0xC4, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x60, 0x60,
  0xC0, 0x41, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x90, 0x03, 0x60, 0x02, 0x80,
  0x05, 0x00, 0x0E, 0x00, 0xC1, 0xC1, 0xE0, 0xA0, 0xF0, 0x50, 0x78, 0x28,
  0x34, 0x14, 0x12, 0x0B, 0x09, 0x8D, 0x8C, 0xC4, 0x46, 0x62, 0x23, 0x31,
  0x11, 0x88, 0x88, 0x84, 0xC6, 0x43, 0x61, 0x61, 0xA0, 0xB0, 0xD0, 0x58,
  0x68, 0x2C, 0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x03, 0x00, 0xE0, 0x0E, 0xC0,
  0x18, 0xC0, 0x60, 0xC1, 0x81, 0x83, 0x01, 0x8C, 0x01, 0x90, 0x03, 0x60,
  0x03, 0x80, 0x07, 0x00, 0x0B, 0x00, 0x36, 0x00, 0xC6, 0x03, 0x06, 0x06,
  0x0C, 0x18, 0x0C, 0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x18, 0xC0, 0x07, 0x80,
  0x0D, 0x80, 0x33, 0x00, 0x62, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x0C, 0x08,
  0x18, 0x30, 0x10, 0x60, 0x31, 0x80, 0x63, 0x00, 0x66, 0x00, 0xD8, 0x00,
  0xB0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0xFE, 0x00, 0x07,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x3F, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x01,
  0xFC, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x07, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x7E, 0x00, 0xF8, 0x00,
  0x10, 0x06, 0xFC, 0x0F, 0x1C, 0x1E, 0x18, 0x3C, 0x18, 0x78, 0x1F, 0xB0,
  0x0E, 0x00,
};

const GFXglyph JetBrainsMono_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 4, 26, 21, 9, -26 },
  { 14, 9, 11, 21, 6, -26 },
  { 27, 19, 26, 21, 1, -26 },
  { 89, 15, 35, 21, 3, -30 },
  { 155, 19, 26, 21, 1, -26 },
  { 217, 18, 26, 21, 2, -26 },
  { 276, 3, 11, 21, 9, -26 },
  { 281, 10, 33, 21, 7, -29 },
  { 323, 10, 33, 21, 4, -29 },
  { 365, 19, 17, 21, 1, -21 },
  { 406, 15, 17, 21, 3, -20 },
  { 438, 5, 11, 21, 7, -5 },
  { 445, 11, 1, 21, 5, -12 },
  { 447, 5, 5, 21, 8, -5 },
  { 451, 15, 33, 21, 3, -29 },
  { 513, 15, 26, 21, 3, -26 },
  { 562, 16, 26, 21, 3, -26 },
  { 614, 16, 26, 21, 3, -26 },
  { 666, 14, 26, 21, 3, -26 },
  { 712, 14, 26, 21, 3, -26 },
  { 758, 15, 26, 21, 3, -26 },
  { 807, 15, 26, 21, 3, -26 },
  { 856, 15, 26, 21, 3, -26 },
  { 905, 15, 26, 21, 3, -26 },
  { 954, 15, 26, 21, 3, -26 },
  { 1003, 5, 20, 21, 8, -20 },
  { 1016, 6, 26, 21, 7, -20 },
  { 1036, 15, 17, 21, 3, -20 },
  { 1068, 15, 9, 21, 3, -16 },
  { 1085, 15, 17, 21, 3, -20 },
  { 1117, 12, 26, 21, 6, -26 },
  { 1156, 17, 32, 21, 2, -26 },
  { 1224, 17, 26, 21, 2, -26 },
  { 1280, 14, 26, 21, 4, -26 },
  { 1326, 14, 26, 21, 4, -26 },
  { 1372, 13, 26, 21, 4, -26 },
  { 1415, 14, 26, 21, 4, -26 },
  { 1461, 14, 26, 21, 4, -26 },
  { 1507, 14, 26, 21, 4, -26 },
  { 1553, 13, 26, 21, 4, -26 },
  { 1596, 13, 26, 21, 4, -26 },
  { 1639, 15, 26, 21, 2, -26 },
  { 1688, 15, 26, 21, 4, -26 },
  { 1737, 14, 26, 21, 4, -26 },
  { 1783, 15, 26, 21, 3, -26 },
  { 1832, 13, 26, 21, 4, -26 },
  { 1875, 13, 26, 21, 4, -26 },
  { 1918, 15, 26, 21, 4, -26 },
  { 1967, 14, 32, 21, 4, -26 },
  { 2023, 15, 26, 21, 4, -26 },
  { 2072, 15, 26, 21, 3, -26 },
  { 2121, 17, 26, 21, 2, -26 },
  { 2177, 13, 26, 21, 4, -26 },
  { 2220, 17, 26, 21, 2, -26 },
  { 2276, 19, 26, 21, 1, -26 },
  { 2338, 17, 26, 21, 2, -26 },
  { 2394, 17, 26, 21, 2, -26 },
  { 2450, 15, 26, 21, 3, -26 },
  { 2499, 8, 33, 21, 8, -29 },
  { 2532, 15, 33, 21, 3, -29 },
  { 2594, 8, 33, 21, 5, -29 },
  { 2627, 15, 14, 21, 3, -26 },
  { 2654, 17, 1, 21, 2, 1 },
  { 2657, 6, 4, 21, 7, -27 },
  { 2660, 14, 20, 21, 3, -20 },
  { 2695, 13, 26, 21, 4, -26 },
  { 2738, 14, 20, 21, 4, -20 },
  { 2773, 13, 26, 21, 4, -26 },
  { 2816, 13, 20, 21, 4, -20 },
  { 2849, 16, 26, 21, 2, -26 },
  { 2901, 13, 26, 21, 4, -20 },
  { 2944, 13, 26, 21, 4, -26 },
  { 2987, 16, 27, 21, 3, -27 },
  { 3041, 13, 33, 21, 3, -27 },
  { 3095, 15, 26, 21, 4, -26 },
  { 3144, 17, 26, 21, 2, -26 },
  { 3200, 15, 20, 21, 3, -20 },
  { 3238, 13, 20, 21, 4, -20 },
  { 3271, 13, 20, 21, 4, -20 },
  { 3304, 13, 26, 21, 4, -20 },
  { 3347, 13, 26, 21, 4, -20 },
  { 3390, 14, 20, 21, 4, -20 },
  { 3425, 15, 20, 21, 3, -20 },
  { 3463, 16, 25, 21, 2, -25 },
  { 3513, 13, 19, 21, 4, -19 },
  { 3544, 15, 19, 21, 3, -19 },
  { 3580, 17, 19, 21, 2, -19 },
  { 3621, 15, 19, 21, 3, -19 },
  { 3657, 15, 25, 21, 3, -19 },
  { 3704, 13, 19, 21, 4, -19 },
  { 3735, 15, 33, 21, 3, -29 },
  { 3797, 1, 33, 21, 10, -29 },
  { 3802, 15, 33, 21, 3, -29 },
  { 3864, 15, 7, 21, 3, -16 },
};

const GFXfont JetBrainsMono_Thin35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_THIN35PT7B_H_
