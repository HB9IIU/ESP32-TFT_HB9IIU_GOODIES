#ifndef _JETBRAINSMONO_THIN46PT7B_H_
#define _JETBRAINSMONO_THIN46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x00, 0x01, 0xC7,
  0xBF, 0xFD, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x00, 0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x06, 0x01, 0xC0, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x0C, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1E, 0x67, 0x83, 0x86, 0x1C, 0x30, 0x60, 0xC7, 0x06, 0x0E,
  0x60, 0x60, 0x66, 0x06, 0x06, 0x60, 0x60, 0x66, 0x06, 0x00, 0x70, 0x60,
  0x07, 0x06, 0x00, 0x38, 0x60, 0x03, 0xC6, 0x00, 0x1E, 0x60, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x6F, 0x00, 0x06, 0x38, 0x00,
  0x61, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x7C,
  0x06, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x07, 0xE0, 0x60, 0x66, 0x06, 0x0E,
  0x70, 0x60, 0xC3, 0xC6, 0x3C, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x00, 0xCF, 0xF0, 0x00, 0x63, 0x8E, 0x00, 0x31, 0x81,
  0xC0, 0x1C, 0x60, 0x30, 0x06, 0x18, 0x0C, 0x03, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x18, 0x06, 0x03, 0x0E,
  0x01, 0x80, 0xC3, 0x00, 0x60, 0x71, 0x80, 0x0E, 0x78, 0xC0, 0x01, 0xFC,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC3, 0xF0, 0x00, 0x71, 0xFF, 0x00, 0x18, 0xE0,
  0xC0, 0x0C, 0x30, 0x18, 0x06, 0x0C, 0x06, 0x01, 0x86, 0x01, 0x80, 0xC1,
  0x80, 0x60, 0x60, 0x60, 0x18, 0x38, 0x18, 0x06, 0x0C, 0x06, 0x01, 0x86,
  0x00, 0xC0, 0x63, 0x00, 0x30, 0x18, 0xC0, 0x0E, 0x0C, 0x60, 0x01, 0xFF,
  0x30, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x3C,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x38, 0x06, 0x00, 0x70,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3D, 0xC0, 0x00, 0xE1, 0xC0, 0x1B, 0x81, 0x80, 0x77, 0x03,
  0x80, 0xCC, 0x03, 0x83, 0x98, 0x03, 0x86, 0x30, 0x03, 0x18, 0x60, 0x07,
  0x30, 0xC0, 0x07, 0xC1, 0x80, 0x07, 0x83, 0x00, 0x06, 0x06, 0x00, 0x1E,
  0x0C, 0x00, 0x3E, 0x1C, 0x00, 0xEC, 0x18, 0x03, 0x8C, 0x38, 0x0E, 0x1C,
  0x3F, 0xF8, 0x1C, 0x3F, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xC0,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x70,
  0x00, 0x80, 0x80, 0x07, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3E, 0x01,
  0xC0, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x18, 0x06, 0xF8, 0x18, 0x1E, 0xFF, 0x18, 0xFF, 0x1F, 0xDB,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xE6, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x81,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x04, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x3C, 0x71,
  0xE3, 0xC7, 0x0E, 0x38, 0x70, 0xE1, 0x87, 0x0C, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x3E, 0x1E, 0x01,
  0xE7, 0x80, 0x1C, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x03, 0x8E, 0x00, 0x70, 0xF0, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xB0, 0x01, 0xC6, 0x00,
  0xF0, 0xC0, 0x3C, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xC6, 0x00, 0x0E,
  0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0x70, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x9C, 0x00, 0xE1,
  0xE0, 0x38, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x6E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE3,
  0xF8, 0x39, 0xFF, 0x8E, 0xC0, 0xF3, 0xE0, 0x1E, 0xF0, 0x03, 0xB8, 0x00,
  0x6E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xB8, 0x00, 0xE7, 0x00, 0x31, 0xE0, 0x3C, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x19, 0xFC, 0x03, 0xFF, 0xF0, 0x3C, 0x07, 0x87, 0x80, 0x1C, 0x70, 0x00,
  0xE6, 0x00, 0x0E, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0x60,
  0x00, 0xE7, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x78, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x1E, 0x1C, 0x00,
  0xE3, 0x00, 0x0C, 0xE0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x0D, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x80, 0x18, 0x38, 0x07,
  0x03, 0xC3, 0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x3C, 0x38,
  0x0E, 0x03, 0x83, 0x80, 0x18, 0xE0, 0x01, 0x98, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x06,
  0xC0, 0x01, 0xDC, 0x00, 0x71, 0xE0, 0x1E, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x38, 0x70, 0x00,
  0xC6, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x06, 0xE0,
  0x00, 0x67, 0x00, 0x0E, 0x70, 0x01, 0xC3, 0xC0, 0x3C, 0x1F, 0x1F, 0xC0,
  0xFF, 0x98, 0x00, 0xC3, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x38, 0xFD, 0xFF, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xFF, 0xFF, 0x7E, 0xF8,
  0x1C, 0x3F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xF0,
  0x3F, 0xC0, 0x7C, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x3E, 0x07, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0x98, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xCF, 0x00, 0xFF, 0xBC, 0x07,
  0x03, 0xF0, 0x18, 0x07, 0xC0, 0xE0, 0x1F, 0x03, 0x80, 0x3C, 0x0E, 0x00,
  0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0,
  0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x01, 0xF0, 0x18,
  0x07, 0xC0, 0x70, 0x3F, 0x00, 0xFF, 0xBC, 0x01, 0xFC, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x30, 0x00, 0x39,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x70, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x06,
  0x00, 0x60, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x18, 0x00, 0x61, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03,
  0x30, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x01, 0xC6, 0x01, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0x00, 0x1C, 0x60, 0x01, 0xCC, 0x00, 0x1D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0xE6,
  0x00, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83,
  0xC0, 0xF1, 0xC0, 0x0E, 0x60, 0x01, 0xB8, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01,
  0xD8, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x1C, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30,
  0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xF3, 0x00, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xB0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xC0, 0xF1, 0xC0, 0x0E,
  0x60, 0x01, 0xB8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00,
  0x38, 0xE0, 0x1C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x01, 0x8E, 0x00, 0x71, 0xE0,
  0x3C, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0,
  0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C,
  0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0,
  0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x18, 0x0C, 0x01,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0,
  0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC,
  0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x40, 0x07, 0xEC, 0x00, 0xFD, 0x80, 0x37,
  0x98, 0x06, 0xF3, 0x00, 0xDE, 0x60, 0x33, 0xC6, 0x06, 0x78, 0xC0, 0x8F,
  0x18, 0x31, 0xE1, 0x86, 0x3C, 0x30, 0x87, 0x82, 0x30, 0xF0, 0x66, 0x1E,
  0x0C, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xD8, 0x01, 0xF6, 0x00, 0x7C, 0xC0,
  0x1F, 0x30, 0x07, 0xCC, 0x01, 0xF1, 0x80, 0x7C, 0x60, 0x1F, 0x0C, 0x07,
  0xC3, 0x01, 0xF0, 0xC0, 0x7C, 0x18, 0x1F, 0x06, 0x07, 0xC1, 0xC1, 0xF0,
  0x30, 0x7C, 0x0C, 0x1F, 0x01, 0x87, 0xC0, 0x61, 0xF0, 0x1C, 0x7C, 0x03,
  0x1F, 0x00, 0xC7, 0xC0, 0x19, 0xF0, 0x06, 0x7C, 0x01, 0xDF, 0x00, 0x37,
  0xC0, 0x0D, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xC0, 0xE1, 0xC0, 0x1C, 0x60,
  0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x30,
  0xE0, 0x1C, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0,
  0x07, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xC0, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0x98, 0x00, 0xE7, 0x00, 0x30, 0xE0, 0x3C, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0xFF, 0xC0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x60, 0x01, 0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x1C, 0xC0, 0x1F, 0x1F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x70, 0x30,
  0x06, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x1C, 0x60,
  0x03, 0x8C, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x76, 0x00, 0x0E, 0xC0,
  0x00, 0xF8, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83,
  0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0xC0, 0x3C,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00,
  0x30, 0xE0, 0x3C, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x38, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x07, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xE0, 0x0E, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0xC0,
  0x3C, 0x06, 0xC0, 0x3C, 0x06, 0xE0, 0x2C, 0x06, 0x60, 0x2C, 0x06, 0x60,
  0x64, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0E, 0x60,
  0x66, 0x0C, 0x60, 0x46, 0x0C, 0x70, 0x46, 0x0C, 0x30, 0xC2, 0x0C, 0x30,
  0xC2, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x83, 0x18, 0x30, 0x83, 0x18, 0x39, 0x81, 0x18, 0x19, 0x81, 0x18, 0x19,
  0x81, 0x98, 0x19, 0x81, 0x98, 0x19, 0x81, 0x98, 0x19, 0x01, 0x98, 0x19,
  0x01, 0xB0, 0x1B, 0x00, 0xB0, 0x1F, 0x00, 0xB0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x38, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x01, 0xC0,
  0x0E, 0x01, 0x80, 0x18, 0x03, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x07, 0x03,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x18, 0x60, 0x00,
  0x60, 0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x07, 0x0E, 0x00,
  0x06, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x80, 0x01,
  0x83, 0x00, 0x07, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x70, 0x00, 0x70, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xE6, 0x00, 0x00,
  0xDC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x80, 0x38, 0x60, 0x0E, 0x1C,
  0x03, 0x03, 0x01, 0xC0, 0xE0, 0x60, 0x38, 0x38, 0x06, 0x0C, 0x01, 0xC7,
  0x00, 0x31, 0xC0, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x3E, 0x7C, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x01, 0x98,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0xFF, 0xFE, 0x7F, 0xFF, 0xDE, 0x00, 0x3B, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x03, 0xDC, 0x00, 0x7B, 0xC0, 0x3F, 0x3F, 0xFE, 0xE1, 0xFF, 0x1C, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xF0, 0x31, 0xFF, 0x0C, 0xE1, 0xE3,
  0x60, 0x1C, 0xF0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0xEF, 0x00, 0x3B, 0x60, 0x1C, 0xCF,
  0xFE, 0x31, 0xFE, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0xE0,
  0x1C, 0x70, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x38, 0xE0, 0x1C, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x03, 0xC1, 0xC3,
  0xFE, 0x73, 0xE3, 0xDC, 0xE0, 0x1F, 0x70, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0xF7, 0x00,
  0x3C, 0xE0, 0x3F, 0x1F, 0xFD, 0xC3, 0xFC, 0x70, 0x03, 0xE0, 0x03, 0xFF,
  0x03, 0xE3, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x38,
  0xE0, 0x1C, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xFE, 0x73, 0xE3, 0xDC, 0xE0, 0x1F, 0x70, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x0F, 0x70, 0x07,
  0xCE, 0x03, 0x71, 0xFF, 0x9C, 0x1F, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0xF0, 0x31, 0xFF, 0x0C, 0xE3, 0xE3, 0x60, 0x1C, 0xF0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x7F, 0xFC,
  0x3F, 0xF8, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E,
  0x38, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x71,
  0xC0, 0x06, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x1C,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x0F, 0x07, 0x8D, 0xF8, 0xFC, 0xF1, 0xD8, 0xEE, 0x0F, 0x07,
  0xC0, 0xE0, 0x7C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0x01, 0xF0, 0x31, 0xFF, 0x0C,
  0xE3, 0xE3, 0x60, 0x1C, 0xD0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xE3,
  0xE0, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x30, 0xE0, 0x1C,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x31, 0xFF, 0x0C, 0xE1, 0xE3,
  0x60, 0x1C, 0xF0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0xEF, 0x00, 0x33, 0x60, 0x1C, 0xCF,
  0xFE, 0x31, 0xFE, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xFE, 0x73, 0xE3, 0xDD, 0xC0, 0x1F, 0x70, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0xF7,
  0x00, 0x3C, 0xE0, 0x3F, 0x1F, 0xFD, 0xC3, 0xFC, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x01, 0xF0, 0x31, 0xFF, 0x0C, 0xE3, 0xE3, 0x60, 0x1C,
  0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x1C, 0x00, 0xE7,
  0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x3E, 0x00, 0x06, 0xC0, 0x00, 0xDC, 0x00, 0x39, 0xC0, 0x0E, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0x60, 0x03, 0x9C,
  0x00, 0xC3, 0x80, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3B,
  0x00, 0x01, 0x9C, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x60, 0x03, 0x83, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x18, 0x06, 0xC0, 0x70, 0x0D, 0x80, 0xF0, 0x1B,
  0x01, 0xE0, 0x76, 0x02, 0xC0, 0xCC, 0x04, 0x81, 0x9C, 0x19, 0x03, 0x18,
  0x33, 0x06, 0x30, 0x66, 0x0C, 0x60, 0x8C, 0x38, 0xC1, 0x18, 0x61, 0x86,
  0x10, 0xC3, 0x8C, 0x21, 0x83, 0x18, 0x63, 0x06, 0x30, 0xC6, 0x0C, 0x41,
  0x9C, 0x19, 0x83, 0x30, 0x33, 0x02, 0x60, 0x76, 0x06, 0xC0, 0x6C, 0x0D,
  0x80, 0xD0, 0x1B, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x70, 0x00, 0x79, 0xC0, 0x03, 0x07, 0x00, 0x38, 0x18,
  0x03, 0x80, 0xE0, 0x18, 0x03, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x70, 0xC0,
  0x01, 0xCE, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0x70, 0x00, 0x39, 0xC0, 0x03, 0x86, 0x00,
  0x18, 0x38, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x1C, 0x0C, 0x00,
  0x70, 0xE0, 0x01, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x0C, 0x00,
  0x70, 0x70, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x0C, 0x01,
  0x80, 0x60, 0x0E, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0E, 0x1C,
  0x00, 0x30, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x37, 0xF8, 0x03, 0xE1, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x7C, 0x03,
  0x86, 0xC0, 0x1F, 0xEC, 0x00, 0x7C,
};

const GFXglyph JetBrainsMono_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 34, 28, 11, -34 },
  { 27, 12, 14, 28, 8, -34 },
  { 48, 24, 34, 28, 2, -34 },
  { 150, 20, 46, 28, 4, -40 },
  { 265, 26, 34, 28, 1, -34 },
  { 376, 23, 34, 28, 3, -34 },
  { 474, 3, 14, 28, 12, -34 },
  { 480, 13, 45, 28, 9, -39 },
  { 554, 13, 45, 28, 5, -39 },
  { 628, 24, 23, 28, 2, -28 },
  { 697, 21, 21, 28, 3, -26 },
  { 753, 7, 14, 28, 9, -7 },
  { 766, 15, 2, 28, 6, -16 },
  { 770, 7, 6, 28, 10, -6 },
  { 776, 19, 43, 28, 4, -38 },
  { 879, 19, 34, 28, 4, -34 },
  { 960, 19, 34, 28, 5, -34 },
  { 1041, 20, 34, 28, 4, -34 },
  { 1126, 19, 34, 28, 4, -34 },
  { 1207, 17, 34, 28, 5, -34 },
  { 1280, 18, 34, 28, 5, -34 },
  { 1357, 20, 34, 28, 4, -34 },
  { 1442, 20, 34, 28, 4, -34 },
  { 1527, 19, 34, 28, 4, -34 },
  { 1608, 20, 34, 28, 4, -34 },
  { 1693, 7, 26, 28, 10, -26 },
  { 1716, 8, 33, 28, 9, -26 },
  { 1749, 19, 23, 28, 4, -27 },
  { 1804, 19, 12, 28, 4, -21 },
  { 1833, 19, 23, 28, 4, -27 },
  { 1888, 15, 34, 28, 8, -34 },
  { 1952, 22, 42, 28, 3, -34 },
  { 2068, 21, 34, 28, 3, -34 },
  { 2158, 19, 34, 28, 5, -34 },
  { 2239, 18, 34, 28, 5, -34 },
  { 2316, 18, 34, 28, 5, -34 },
  { 2393, 17, 34, 28, 6, -34 },
  { 2466, 19, 34, 28, 5, -34 },
  { 2547, 18, 34, 28, 5, -34 },
  { 2624, 18, 34, 28, 5, -34 },
  { 2701, 16, 34, 28, 6, -34 },
  { 2769, 19, 34, 28, 3, -34 },
  { 2850, 20, 34, 28, 5, -34 },
  { 2935, 18, 34, 28, 6, -34 },
  { 3012, 19, 34, 28, 4, -34 },
  { 3093, 18, 34, 28, 5, -34 },
  { 3170, 18, 34, 28, 5, -34 },
  { 3247, 20, 34, 28, 5, -34 },
  { 3332, 18, 42, 28, 5, -34 },
  { 3427, 19, 34, 28, 5, -34 },
  { 3508, 20, 34, 28, 4, -34 },
  { 3593, 22, 34, 28, 3, -34 },
  { 3687, 18, 34, 28, 5, -34 },
  { 3764, 21, 34, 28, 3, -34 },
  { 3854, 24, 34, 28, 2, -34 },
  { 3956, 23, 34, 28, 2, -34 },
  { 4054, 23, 34, 28, 2, -34 },
  { 4152, 19, 34, 28, 4, -34 },
  { 4233, 10, 43, 28, 10, -38 },
  { 4287, 19, 43, 28, 4, -38 },
  { 4390, 10, 43, 28, 7, -38 },
  { 4444, 18, 18, 28, 5, -34 },
  { 4485, 22, 2, 28, 3, 1 },
  { 4491, 8, 6, 28, 9, -36 },
  { 4497, 19, 26, 28, 4, -26 },
  { 4559, 18, 34, 28, 5, -34 },
  { 4636, 18, 26, 28, 5, -26 },
  { 4695, 18, 34, 28, 5, -34 },
  { 4772, 18, 26, 28, 5, -26 },
  { 4831, 21, 34, 28, 3, -34 },
  { 4921, 18, 34, 28, 5, -26 },
  { 4998, 18, 34, 28, 5, -34 },
  { 5075, 21, 35, 28, 4, -35 },
  { 5167, 17, 43, 28, 4, -35 },
  { 5259, 19, 34, 28, 5, -34 },
  { 5340, 23, 34, 28, 2, -34 },
  { 5438, 20, 26, 28, 4, -26 },
  { 5503, 18, 26, 28, 5, -26 },
  { 5562, 18, 26, 28, 5, -26 },
  { 5621, 18, 34, 28, 5, -26 },
  { 5698, 18, 34, 28, 5, -26 },
  { 5775, 18, 26, 28, 6, -26 },
  { 5834, 19, 26, 28, 4, -26 },
  { 5896, 20, 32, 28, 3, -32 },
  { 5976, 18, 25, 28, 5, -25 },
  { 6033, 21, 25, 28, 3, -25 },
  { 6099, 23, 25, 28, 2, -25 },
  { 6171, 21, 25, 28, 3, -25 },
  { 6237, 21, 33, 28, 3, -25 },
  { 6324, 18, 25, 28, 5, -25 },
  { 6381, 18, 43, 28, 5, -38 },
  { 6478, 2, 43, 28, 13, -38 },
  { 6489, 18, 43, 28, 5, -38 },
  { 6586, 20, 8, 28, 4, -20 },
};

const GFXfont JetBrainsMono_Thin46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_THIN46PT7B_H_
