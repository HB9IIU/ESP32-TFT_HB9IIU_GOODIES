#ifndef _JETBRAINSMONO_THIN28PT7B_H_
#define _JETBRAINSMONO_THIN28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x1F, 0xF0, 0xC7, 0x8F, 0x1C,
  0x38, 0x70, 0xE1, 0xC1, 0x06, 0x08, 0x08, 0x10, 0x10, 0x60, 0x20, 0x80,
  0x41, 0x0F, 0xFF, 0xDF, 0xFF, 0x84, 0x18, 0x08, 0x30, 0x10, 0x40, 0x60,
  0x80, 0x81, 0x01, 0x06, 0x1F, 0xFF, 0x84, 0x10, 0x18, 0x20, 0x30, 0x40,
  0x40, 0x80, 0x83, 0x01, 0x04, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x70,
  0x1F, 0xC3, 0x26, 0x62, 0x34, 0x21, 0x42, 0x16, 0x20, 0x62, 0x03, 0x20,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x26, 0x02, 0x30, 0x21, 0x02, 0x1C, 0x21,
  0x42, 0x16, 0x23, 0x32, 0x61, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x10, 0x00, 0xF8, 0x0F, 0x18, 0x14, 0x10, 0x48, 0x21, 0x10, 0x46, 0x20,
  0x88, 0x63, 0x20, 0x6C, 0xC0, 0x71, 0x00, 0x04, 0x00, 0x18, 0x00, 0x27,
  0xC0, 0x98, 0x82, 0x21, 0x8C, 0x41, 0x10, 0x82, 0x41, 0x05, 0x82, 0x1A,
  0x06, 0x28, 0x07, 0xC0, 0x0F, 0x00, 0x7E, 0x03, 0x0C, 0x18, 0x18, 0x60,
  0x61, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xE0, 0x06, 0xC0, 0x31,
  0x82, 0x82, 0x12, 0x0C, 0x48, 0x1A, 0x20, 0x38, 0x80, 0x42, 0x03, 0x8C,
  0x1B, 0x18, 0xC6, 0x7E, 0x0C, 0xFF, 0xD5, 0x01, 0x07, 0x1C, 0x30, 0x60,
  0x60, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x38, 0x1C, 0x07, 0x80, 0xE0,
  0x38, 0x1C, 0x0C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x70,
  0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x04, 0x10, 0x5E, 0x23,
  0xC7, 0x5C, 0x01, 0xC0, 0x02, 0x80, 0x0D, 0x80, 0x31, 0x00, 0x43, 0x01,
  0x83, 0x06, 0x02, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x39, 0x8C, 0xC6, 0x31, 0x18, 0xFF, 0x80, 0x7F, 0xF7, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x0E,
  0x07, 0xF1, 0x83, 0x60, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x86, 0x38, 0xC7, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x0F,
  0x01, 0xB8, 0xE3, 0xF8, 0x0E, 0x01, 0xA0, 0x62, 0x0C, 0x20, 0x82, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x07, 0x01,
  0xFE, 0x18, 0x18, 0x80, 0x6C, 0x01, 0x60, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x18,
  0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x58, 0x19, 0x86, 0x1F,
  0x80, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x64, 0x0D, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xFF, 0xF8, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xD8, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0xFC, 0xE0, 0xD8, 0x0F, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x03, 0x80, 0x78, 0x09, 0x83, 0x1F, 0x80, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x2F, 0xC7, 0x06,
  0x60, 0x34, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x36, 0x02,
  0x30, 0x61, 0xF8, 0xFF, 0xFE, 0x00, 0xF0, 0x05, 0x80, 0x6C, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x0E, 0x07, 0xF1, 0x83, 0x60, 0x38, 0x03, 0x00, 0x70, 0x1A, 0x02, 0x60,
  0xC3, 0x60, 0x38, 0x19, 0xC6, 0x0D, 0x80, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x01, 0xB0, 0x63, 0xF8, 0x07, 0x01, 0xFC, 0x30, 0x66, 0x03, 0x40,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x03, 0x60, 0x33, 0xDE, 0x0F,
  0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0x31, 0xE7, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xC3, 0x18, 0x61, 0x84, 0x30,
  0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x20, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C,
  0x01, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x06, 0x03,
  0x03, 0x1F, 0x0E, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1C,
  0x0E, 0x00, 0x07, 0x80, 0xFF, 0x0C, 0x0C, 0xC0, 0x2C, 0x01, 0xE0, 0x06,
  0x00, 0x30, 0x19, 0x83, 0xEC, 0x30, 0xE1, 0x03, 0x08, 0x18, 0x40, 0xC2,
  0x06, 0x10, 0x30, 0x81, 0x84, 0x0C, 0x30, 0xE0, 0xFB, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x28,
  0x01, 0x40, 0x1A, 0x00, 0x98, 0x04, 0x40, 0x22, 0x03, 0x10, 0x10, 0xC0,
  0x82, 0x04, 0x10, 0x60, 0xC2, 0x06, 0x1F, 0xF1, 0x80, 0x8C, 0x06, 0x40,
  0x32, 0x00, 0xB0, 0x05, 0x00, 0x30, 0xFF, 0x90, 0x1A, 0x01, 0x40, 0x38,
  0x03, 0x00, 0xE0, 0x1C, 0x02, 0x81, 0xDF, 0xE2, 0x03, 0x40, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x07, 0x7F, 0x80, 0x0E, 0x07,
  0xF1, 0x83, 0x60, 0x3C, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x38, 0x0D, 0x01,
  0xB0, 0x63, 0xF8, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x50, 0x1A, 0x0E, 0x7F, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xF0, 0xFF,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x3C, 0x03,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43, 0xF8, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x38, 0x0D, 0x01, 0xB0, 0x63, 0xF8, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFE,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x43, 0xFF, 0x07, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x28, 0x0D, 0x83, 0x0F, 0xC0, 0x80, 0x38, 0x06, 0x80, 0x48,
  0x0C, 0x80, 0x88, 0x18, 0x81, 0x08, 0x30, 0x82, 0x0F, 0xE0, 0x83, 0x08,
  0x30, 0x81, 0x88, 0x18, 0x80, 0xC8, 0x0C, 0x80, 0x48, 0x06, 0x80, 0x28,
  0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x78, 0x1E, 0x82, 0xD0,
  0x5A, 0x13, 0x22, 0x64, 0x4C, 0xD1, 0x8A, 0x31, 0x46, 0x10, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0xC0,
  0x74, 0x0E, 0x81, 0xD8, 0x39, 0x07, 0x20, 0xE6, 0x1C, 0x43, 0x8C, 0x70,
  0x8E, 0x11, 0xC3, 0x38, 0x27, 0x06, 0xE0, 0x5C, 0x0B, 0x81, 0xF0, 0x1E,
  0x03, 0xC0, 0x30, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x28, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0D, 0x01, 0x30, 0x63, 0xF0, 0xFF, 0xC8, 0x06, 0x80,
  0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x68, 0x1C, 0xFF,
  0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x28, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x0D, 0x01, 0x30, 0x63, 0xF8, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0xFF, 0x88, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x02, 0x80, 0x6F, 0xFC, 0xFF, 0x08, 0x20, 0x83, 0x08, 0x10, 0x81,
  0x88, 0x0C, 0x80, 0xC8, 0x06, 0x80, 0x68, 0x03, 0x07, 0x01, 0xFC, 0x30,
  0x66, 0x03, 0x40, 0x14, 0x01, 0x60, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0F,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xC0, 0x14, 0x01, 0x60,
  0x33, 0x06, 0x1F, 0xC0, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x68, 0x09, 0x83, 0x1F, 0x80, 0xC0, 0x1E, 0x00, 0x90, 0x04, 0x80, 0x66,
  0x03, 0x10, 0x10, 0x80, 0x86, 0x0C, 0x30, 0x40, 0x82, 0x04, 0x10, 0x31,
  0x81, 0x88, 0x04, 0x40, 0x26, 0x01, 0xB0, 0x05, 0x00, 0x28, 0x01, 0xC0,
  0x0C, 0x00, 0xC3, 0x87, 0x85, 0x0B, 0x0A, 0x12, 0x14, 0x24, 0x28, 0x48,
  0x50, 0x90, 0xA1, 0x23, 0x46, 0x64, 0x4C, 0xC8, 0x91, 0x91, 0x21, 0x22,
  0x42, 0x44, 0x84, 0x89, 0x0A, 0x12, 0x14, 0x3C, 0x38, 0x38, 0x70, 0x60,
  0xE0, 0xC0, 0xC1, 0x80, 0x60, 0x0C, 0xC0, 0x61, 0x01, 0x06, 0x0C, 0x08,
  0x20, 0x31, 0x00, 0x4C, 0x01, 0xA0, 0x03, 0x80, 0x0C, 0x00, 0x28, 0x01,
  0xA0, 0x04, 0x40, 0x31, 0x80, 0x82, 0x06, 0x0C, 0x30, 0x10, 0x80, 0x66,
  0x00, 0xB0, 0x03, 0xC0, 0x0D, 0x80, 0x22, 0x01, 0x8C, 0x04, 0x10, 0x30,
  0x60, 0x80, 0x86, 0x03, 0x10, 0x04, 0x40, 0x1A, 0x00, 0x28, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0xFF, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x7F, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xF0, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0xFC, 0x0E, 0x01, 0x40, 0x6C, 0x09, 0x83, 0x10, 0x63, 0x08, 0x23, 0x06,
  0x40, 0x58, 0x0C, 0xFF, 0xF8, 0xC4, 0x23, 0x07, 0x01, 0xFC, 0x30, 0x66,
  0x02, 0x40, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x3F, 0xF6, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x34, 0x03, 0x60, 0xF3, 0xFB, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x61, 0x7F, 0x28, 0x36, 0x02, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0A, 0x83, 0x4F, 0xC0, 0x0E,
  0x07, 0xF1, 0x83, 0x60, 0x38, 0x07, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x1C, 0x06, 0x80, 0x98, 0x31, 0xFC, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xE6, 0x7E, 0xD8, 0x3E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0D, 0x83, 0x9F,
  0xB0, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x28, 0x07, 0x00, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x0C, 0x06, 0x80, 0x98, 0x31, 0xF8, 0x03,
  0xF8, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x03, 0xFF, 0xE0, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x0E, 0x07, 0xED, 0x83,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x34, 0x0E, 0xE7, 0xC7, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x63,
  0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x61, 0x7F, 0x28, 0x36, 0x02,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF,
  0xF0, 0x01, 0xC0, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x07, 0x3F, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1, 0x8C,
  0x10, 0xC3, 0x0F, 0xE0, 0xFE, 0x0C, 0x30, 0xC1, 0x0C, 0x18, 0xC0, 0xCC,
  0x04, 0xC0, 0x6C, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x7F, 0x18, 0x65, 0xEF, 0xB1, 0x85, 0x84, 0x3C, 0x21, 0xE1,
  0x0F, 0x08, 0x78, 0x43, 0xC2, 0x1E, 0x10, 0xF0, 0x87, 0x84, 0x3C, 0x21,
  0xE1, 0x0F, 0x08, 0x78, 0x43, 0x06, 0x13, 0xF2, 0x83, 0x60, 0x2C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x28, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x06, 0x80, 0x98, 0x31,
  0xF8, 0x06, 0x17, 0xF2, 0x83, 0x60, 0x2C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xA8, 0x34, 0xFC, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0E, 0x07, 0xED, 0x83, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xD8, 0x39, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0C,
  0x17, 0xF3, 0x03, 0x40, 0x68, 0x05, 0x00, 0xA0, 0x1C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0E, 0x0F, 0xFB,
  0x01, 0xE0, 0x38, 0x01, 0x80, 0x10, 0x03, 0xE0, 0x0F, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0xD8, 0x11, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x0F, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x3F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x34, 0x04, 0xC3, 0x8F, 0xC0, 0xC0, 0x1A,
  0x00, 0x98, 0x0C, 0xC0, 0x42, 0x02, 0x18, 0x30, 0x41, 0x02, 0x08, 0x18,
  0xC0, 0x44, 0x02, 0x20, 0x1B, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0xC1,
  0x05, 0x0A, 0x14, 0x28, 0x50, 0xA3, 0x62, 0x8D, 0x8A, 0x22, 0x48, 0x89,
  0x12, 0x24, 0x48, 0x91, 0x63, 0x45, 0x8F, 0x14, 0x18, 0x70, 0x60, 0xC1,
  0x83, 0x00, 0xE0, 0x31, 0x01, 0x0C, 0x10, 0x31, 0x80, 0x88, 0x06, 0x80,
  0x1C, 0x00, 0xE0, 0x05, 0x00, 0x4C, 0x06, 0x30, 0x20, 0x82, 0x06, 0x30,
  0x1B, 0x00, 0x60, 0xC0, 0x1A, 0x01, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x18,
  0x20, 0x41, 0x03, 0x18, 0x08, 0x80, 0x64, 0x03, 0x60, 0x0A, 0x00, 0x70,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0xFF, 0xE0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x3F, 0xF8, 0x01, 0xE0, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x0F, 0xC1, 0xF8, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x7E, 0x0F, 0xC2, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x40, 0x18, 0x1E,
  0x00, 0x7C, 0x1C, 0x61, 0xC3, 0x1C, 0x1B, 0xC0, 0x60,
};

const GFXglyph JetBrainsMono_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 7, 8, 17, 5, -20 },
  { 16, 15, 20, 17, 1, -20 },
  { 54, 12, 28, 17, 2, -24 },
  { 96, 15, 21, 17, 1, -21 },
  { 136, 14, 21, 17, 2, -21 },
  { 173, 2, 8, 17, 7, -20 },
  { 175, 8, 27, 17, 6, -24 },
  { 202, 8, 27, 17, 3, -24 },
  { 229, 15, 14, 17, 1, -17 },
  { 256, 13, 13, 17, 2, -16 },
  { 278, 5, 8, 17, 5, -4 },
  { 283, 9, 1, 17, 4, -10 },
  { 285, 4, 4, 17, 6, -4 },
  { 287, 11, 26, 17, 3, -23 },
  { 323, 11, 21, 17, 3, -21 },
  { 352, 12, 20, 17, 3, -20 },
  { 382, 13, 21, 17, 2, -21 },
  { 417, 11, 20, 17, 3, -20 },
  { 445, 11, 20, 17, 3, -20 },
  { 473, 11, 20, 17, 3, -20 },
  { 501, 12, 20, 17, 2, -20 },
  { 531, 13, 20, 17, 2, -20 },
  { 564, 11, 21, 17, 3, -21 },
  { 593, 12, 21, 17, 2, -21 },
  { 625, 4, 16, 17, 6, -16 },
  { 633, 6, 20, 17, 5, -16 },
  { 648, 11, 14, 17, 3, -16 },
  { 668, 11, 8, 17, 3, -13 },
  { 679, 11, 14, 17, 3, -16 },
  { 699, 9, 20, 17, 5, -20 },
  { 722, 13, 26, 17, 2, -21 },
  { 765, 13, 20, 17, 2, -20 },
  { 798, 11, 20, 17, 3, -20 },
  { 826, 11, 21, 17, 3, -21 },
  { 855, 11, 20, 17, 3, -20 },
  { 883, 11, 20, 17, 3, -20 },
  { 911, 12, 20, 17, 3, -20 },
  { 941, 11, 21, 17, 3, -21 },
  { 970, 11, 20, 17, 3, -20 },
  { 998, 10, 20, 17, 3, -20 },
  { 1023, 11, 20, 17, 2, -20 },
  { 1051, 12, 20, 17, 3, -20 },
  { 1081, 12, 20, 17, 3, -20 },
  { 1111, 11, 20, 17, 3, -20 },
  { 1139, 11, 20, 17, 3, -20 },
  { 1167, 11, 21, 17, 3, -21 },
  { 1196, 12, 20, 17, 3, -20 },
  { 1226, 11, 26, 17, 3, -21 },
  { 1262, 12, 20, 17, 3, -20 },
  { 1292, 12, 21, 17, 2, -21 },
  { 1324, 13, 20, 17, 2, -20 },
  { 1357, 11, 20, 17, 3, -20 },
  { 1385, 13, 20, 17, 2, -20 },
  { 1418, 15, 20, 17, 1, -20 },
  { 1456, 14, 20, 17, 1, -20 },
  { 1491, 14, 20, 17, 1, -20 },
  { 1526, 11, 20, 17, 3, -20 },
  { 1554, 6, 26, 17, 6, -23 },
  { 1574, 11, 26, 17, 3, -23 },
  { 1610, 7, 26, 17, 4, -23 },
  { 1633, 11, 10, 17, 3, -20 },
  { 1647, 13, 1, 17, 2, 1 },
  { 1649, 4, 4, 17, 6, -22 },
  { 1651, 12, 16, 17, 2, -16 },
  { 1675, 11, 20, 17, 3, -20 },
  { 1703, 11, 16, 17, 3, -16 },
  { 1725, 11, 20, 17, 3, -20 },
  { 1753, 11, 16, 17, 3, -16 },
  { 1775, 13, 20, 17, 2, -20 },
  { 1808, 11, 21, 17, 3, -16 },
  { 1837, 11, 20, 17, 3, -20 },
  { 1865, 12, 21, 17, 3, -21 },
  { 1897, 10, 26, 17, 3, -21 },
  { 1930, 12, 20, 17, 3, -20 },
  { 1960, 14, 20, 17, 1, -20 },
  { 1995, 13, 16, 17, 2, -16 },
  { 2021, 11, 16, 17, 3, -16 },
  { 2043, 11, 16, 17, 3, -16 },
  { 2065, 11, 21, 17, 3, -16 },
  { 2094, 11, 21, 17, 3, -16 },
  { 2123, 11, 16, 17, 4, -16 },
  { 2145, 11, 16, 17, 3, -16 },
  { 2167, 12, 20, 17, 2, -20 },
  { 2197, 11, 15, 17, 3, -15 },
  { 2218, 13, 15, 17, 2, -15 },
  { 2243, 14, 15, 17, 1, -15 },
  { 2270, 13, 15, 17, 2, -15 },
  { 2295, 13, 20, 17, 2, -15 },
  { 2328, 11, 15, 17, 3, -15 },
  { 2349, 11, 26, 17, 3, -23 },
  { 2385, 1, 26, 17, 8, -23 },
  { 2389, 11, 26, 17, 3, -23 },
  { 2425, 12, 5, 17, 2, -12 },
};

const GFXfont JetBrainsMono_Thin28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_THIN28PT7B_H_
