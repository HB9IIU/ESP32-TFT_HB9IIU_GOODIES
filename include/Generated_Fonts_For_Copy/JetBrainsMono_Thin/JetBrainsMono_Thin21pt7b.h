#ifndef _JETBRAINSMONO_THIN21PT7B_H_
#define _JETBRAINSMONO_THIN21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x01, 0xF0, 0xC7, 0x14, 0x51, 0x45, 0x10,
  0x08, 0x42, 0x10, 0x42, 0x08, 0x4F, 0xFE, 0x21, 0x04, 0x41, 0x08, 0x21,
  0x04, 0x23, 0xFF, 0x11, 0x04, 0x20, 0x84, 0x10, 0x80, 0x08, 0x04, 0x02,
  0x0F, 0xC4, 0x94, 0x4E, 0x21, 0x90, 0x48, 0x1C, 0x03, 0x81, 0x60, 0x90,
  0x46, 0x23, 0x11, 0xC9, 0x1F, 0x02, 0x01, 0x00, 0x80, 0x78, 0x14, 0x42,
  0x44, 0x44, 0x44, 0x44, 0x84, 0xD0, 0x32, 0x00, 0x20, 0x04, 0xE0, 0x91,
  0x09, 0x11, 0x11, 0x21, 0x14, 0x11, 0xC1, 0xE0, 0x0C, 0x06, 0x60, 0x84,
  0x10, 0xC2, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x48, 0x58, 0x8A, 0x1A, 0x41,
  0x48, 0x11, 0x83, 0x10, 0x93, 0xE3, 0xFC, 0x04, 0x73, 0x08, 0x41, 0x0C,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x40, 0x83, 0x03, 0x04, 0x81,
  0x81, 0x02, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C,
  0x21, 0x38, 0x80, 0x04, 0x00, 0x80, 0x10, 0x42, 0x1E, 0x5E, 0x3E, 0x03,
  0x00, 0xD0, 0x13, 0x04, 0x30, 0x82, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x6D, 0x2D, 0x00, 0xFE, 0xDF,
  0x80, 0x01, 0x80, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x00, 0x08,
  0x3F, 0x10, 0x50, 0x28, 0x1C, 0x0E, 0x07, 0x13, 0x99, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x09, 0x0C, 0x7C, 0x1C, 0x16, 0x33, 0x11, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x63, 0xFE, 0x18, 0x33,
  0x30, 0x50, 0x38, 0x08, 0x04, 0x04, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x01, 0xFF, 0xFF, 0x02, 0x06, 0x04, 0x08, 0x18, 0x06, 0x01,
  0x01, 0x01, 0x01, 0x81, 0x81, 0x43, 0x3E, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x10, 0x21, 0x41, 0x41, 0x81, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x7F, 0x60,
  0x30, 0x18, 0x08, 0x04, 0xF2, 0x8D, 0x82, 0x01, 0x00, 0xC0, 0x60, 0x28,
  0x12, 0x18, 0xF8, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0xF9, 0x82,
  0x81, 0xC0, 0x60, 0x30, 0x18, 0x12, 0x08, 0xF8, 0xFF, 0xC0, 0x60, 0x50,
  0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x08, 0x3B, 0x10, 0x50, 0x28, 0x1A, 0x09, 0x0C, 0x68, 0x3C, 0x21,
  0x30, 0x50, 0x18, 0x0C, 0x0F, 0x04, 0x7C, 0x08, 0x3B, 0x30, 0x50, 0x18,
  0x0C, 0x06, 0x03, 0x02, 0x43, 0x1F, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60,
  0x60, 0xDF, 0x80, 0x00, 0x1B, 0xF0, 0x67, 0x70, 0x00, 0x00, 0x06, 0x64,
  0x4C, 0x80, 0x01, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00, 0xF8, 0x08, 0x10,
  0x30, 0x40, 0x83, 0x3C, 0x40, 0x81, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x04,
  0x0E, 0xE6, 0x0D, 0x01, 0x40, 0x60, 0x18, 0x7E, 0x31, 0x88, 0x62, 0x18,
  0x86, 0x21, 0x88, 0x61, 0x18, 0x7D, 0x00, 0x40, 0x18, 0x03, 0x00, 0x38,
  0x0C, 0x03, 0x00, 0xA0, 0x28, 0x12, 0x04, 0x41, 0x10, 0x84, 0x21, 0x08,
  0x23, 0xF9, 0x02, 0x40, 0x90, 0x1C, 0x04, 0xFE, 0x40, 0xA0, 0x50, 0x28,
  0x14, 0x0A, 0x19, 0xFC, 0x81, 0x40, 0x60, 0x30, 0x18, 0x1C, 0x1B, 0xF8,
  0x08, 0x3B, 0x10, 0x50, 0x38, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0E, 0x09, 0x04, 0x7C, 0xFE, 0x83, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x08, 0x3B, 0x10, 0x50, 0x38, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x47, 0xE0, 0x30, 0x18, 0x0E, 0x09, 0x04, 0x7C, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x3F, 0x80, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x38, 0x14, 0x0B, 0x08, 0xF8, 0x80, 0xC0, 0xA0,
  0x50, 0x48, 0x24, 0x22, 0x11, 0xF8, 0x84, 0x43, 0x20, 0x90, 0x68, 0x14,
  0x0E, 0x02, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xC1, 0xE1, 0x68, 0xB4, 0x5A, 0x4C, 0xA6,
  0x53, 0x11, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0xC1, 0xC1,
  0xA1, 0xA1, 0x91, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x85, 0x83, 0x83,
  0x81, 0x18, 0x66, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x43, 0x3E, 0xFF, 0x40, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x05, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x08, 0x3B,
  0x10, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28,
  0x14, 0x09, 0x0C, 0x7C, 0x06, 0x01, 0x00, 0x40, 0x30, 0xFE, 0x40, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x05, 0xFC, 0x84, 0x42, 0x20, 0x90, 0x48, 0x14,
  0x0A, 0x02, 0x08, 0x3B, 0x10, 0x50, 0x38, 0x06, 0x01, 0x00, 0x60, 0x0E,
  0x01, 0x80, 0x40, 0x18, 0x0C, 0x07, 0x04, 0x7C, 0xFF, 0xC1, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0x43, 0x3E, 0xC0, 0x50, 0x14, 0x09, 0x82, 0x20,
  0x88, 0x22, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x03, 0x00,
  0xC0, 0x84, 0x31, 0x86, 0x29, 0x45, 0x28, 0xA4, 0x94, 0x92, 0x92, 0x92,
  0x52, 0x4A, 0x49, 0x46, 0x28, 0xC5, 0x18, 0x43, 0x08, 0x60, 0xC0, 0x58,
  0x22, 0x18, 0x44, 0x12, 0x02, 0x80, 0xC0, 0x30, 0x0A, 0x04, 0x81, 0x10,
  0x84, 0x20, 0x90, 0x1C, 0x04, 0xC0, 0x68, 0x09, 0x82, 0x10, 0x43, 0x10,
  0x22, 0x06, 0x80, 0x50, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0xFF, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x18, 0x08, 0x08, 0x04, 0x04, 0x03, 0xFE, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x7E, 0x18, 0x0A, 0x05, 0x04, 0xC2, 0x22, 0x11, 0x05, 0x03,
  0xFF, 0xC0, 0xC3, 0x1C, 0x62, 0x41, 0x81, 0x01, 0x1F, 0x61, 0x81, 0x81,
  0x81, 0xC3, 0x7D, 0x80, 0x80, 0x80, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0xC3, 0xBE, 0x1C, 0x31, 0x90, 0x50, 0x28, 0x0C,
  0x02, 0x01, 0x00, 0x81, 0xE0, 0x90, 0x47, 0xC0, 0x01, 0x01, 0x01, 0x1D,
  0x63, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x1C,
  0x62, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x81, 0x41, 0x3E, 0x07,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x1D, 0x63, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC1, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x03, 0x3C, 0x80, 0x80,
  0x80, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x06, 0x0C, 0x00, 0x07, 0xE0,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x37,
  0xC0, 0x80, 0x40, 0x20, 0x10, 0x18, 0x14, 0x1A, 0x09, 0x08, 0xF8, 0x46,
  0x21, 0x10, 0x48, 0x34, 0x0A, 0x02, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x7C, 0xF3, 0x4E, 0xE2, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4,
  0x62, 0x31, 0x10, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x1C, 0x62, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x3E, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC1, 0xC3, 0xBE, 0x80, 0x80, 0x80, 0x80, 0x1D, 0x63, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xB8,
  0xC6, 0x83, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C,
  0x21, 0xB0, 0x50, 0x1C, 0x03, 0x80, 0x3C, 0x02, 0x00, 0xC0, 0x70, 0x4F,
  0xC0, 0x08, 0x02, 0x00, 0x83, 0xFF, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x78, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x43, 0x3E, 0x80, 0xC0, 0x60, 0x48,
  0x24, 0x12, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x06, 0x03, 0x00, 0x84, 0x30,
  0x8A, 0x31, 0x25, 0x24, 0xA4, 0x94, 0x92, 0x92, 0x94, 0x52, 0x86, 0x30,
  0xC6, 0x10, 0xC0, 0x80, 0xA0, 0x90, 0x84, 0x41, 0x40, 0xC0, 0x60, 0x28,
  0x26, 0x21, 0x10, 0x50, 0x30, 0x80, 0xC0, 0xF0, 0x48, 0x24, 0x21, 0x10,
  0x88, 0x68, 0x14, 0x0A, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0xFF,
  0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x40, 0xFF, 0x07,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x08, 0x78, 0x02, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0xE0, 0xFF, 0xFF, 0xE0,
  0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x07, 0xC4,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x3C, 0x00, 0xF0, 0xC4,
  0x63, 0x70, 0x40,
};

const GFXglyph JetBrainsMono_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -15 },
  { 12, 11, 15, 13, 1, -15 },
  { 33, 9, 21, 13, 2, -18 },
  { 57, 12, 15, 13, 0, -15 },
  { 80, 11, 16, 13, 1, -16 },
  { 102, 1, 6, 13, 6, -15 },
  { 103, 6, 21, 13, 4, -18 },
  { 119, 6, 21, 13, 2, -18 },
  { 135, 11, 11, 13, 1, -13 },
  { 151, 9, 10, 13, 2, -12 },
  { 163, 3, 6, 13, 4, -3 },
  { 166, 7, 1, 13, 3, -7 },
  { 167, 3, 3, 13, 5, -3 },
  { 169, 9, 19, 13, 2, -17 },
  { 191, 9, 16, 13, 2, -16 },
  { 209, 9, 15, 13, 2, -15 },
  { 226, 9, 16, 13, 2, -16 },
  { 244, 8, 15, 13, 2, -15 },
  { 259, 8, 15, 13, 2, -15 },
  { 274, 9, 15, 13, 2, -15 },
  { 291, 9, 15, 13, 2, -15 },
  { 308, 9, 15, 13, 2, -15 },
  { 325, 9, 16, 13, 2, -16 },
  { 343, 9, 16, 13, 2, -16 },
  { 361, 3, 12, 13, 5, -12 },
  { 366, 4, 15, 13, 4, -12 },
  { 374, 9, 10, 13, 2, -12 },
  { 386, 9, 6, 13, 2, -10 },
  { 393, 9, 10, 13, 2, -12 },
  { 405, 7, 15, 13, 4, -15 },
  { 419, 10, 20, 13, 1, -16 },
  { 444, 10, 15, 13, 1, -15 },
  { 463, 9, 15, 13, 2, -15 },
  { 480, 9, 16, 13, 2, -16 },
  { 498, 8, 15, 13, 2, -15 },
  { 513, 8, 15, 13, 3, -15 },
  { 528, 9, 15, 13, 2, -15 },
  { 545, 9, 16, 13, 2, -16 },
  { 563, 8, 15, 13, 2, -15 },
  { 578, 7, 15, 13, 3, -15 },
  { 592, 9, 15, 13, 1, -15 },
  { 609, 9, 15, 13, 2, -15 },
  { 626, 8, 15, 13, 3, -15 },
  { 641, 9, 15, 13, 2, -15 },
  { 658, 8, 15, 13, 2, -15 },
  { 673, 8, 16, 13, 2, -16 },
  { 689, 9, 15, 13, 2, -15 },
  { 706, 9, 20, 13, 2, -16 },
  { 729, 9, 15, 13, 2, -15 },
  { 746, 9, 16, 13, 2, -16 },
  { 764, 10, 15, 13, 1, -15 },
  { 783, 8, 15, 13, 2, -15 },
  { 798, 10, 15, 13, 1, -15 },
  { 817, 11, 15, 13, 1, -15 },
  { 838, 10, 15, 13, 1, -15 },
  { 857, 11, 15, 13, 1, -15 },
  { 878, 9, 15, 13, 2, -15 },
  { 895, 4, 19, 13, 5, -17 },
  { 905, 9, 19, 13, 2, -17 },
  { 927, 5, 19, 13, 3, -17 },
  { 939, 9, 8, 13, 2, -15 },
  { 948, 10, 1, 13, 1, 0 },
  { 950, 4, 2, 13, 4, -16 },
  { 951, 8, 12, 13, 2, -12 },
  { 963, 8, 15, 13, 2, -15 },
  { 978, 9, 12, 13, 2, -12 },
  { 992, 8, 15, 13, 2, -15 },
  { 1007, 8, 12, 13, 2, -12 },
  { 1019, 10, 15, 13, 1, -15 },
  { 1038, 8, 16, 13, 2, -12 },
  { 1054, 8, 15, 13, 2, -15 },
  { 1069, 9, 16, 13, 2, -16 },
  { 1087, 7, 20, 13, 2, -16 },
  { 1105, 9, 15, 13, 2, -15 },
  { 1122, 10, 15, 13, 1, -15 },
  { 1141, 9, 12, 13, 2, -12 },
  { 1155, 8, 12, 13, 2, -12 },
  { 1167, 8, 12, 13, 2, -12 },
  { 1179, 8, 16, 13, 2, -12 },
  { 1195, 8, 16, 13, 2, -12 },
  { 1211, 8, 12, 13, 3, -12 },
  { 1223, 9, 12, 13, 2, -12 },
  { 1237, 10, 15, 13, 1, -15 },
  { 1256, 8, 12, 13, 2, -12 },
  { 1268, 9, 12, 13, 2, -12 },
  { 1282, 11, 12, 13, 1, -12 },
  { 1299, 9, 12, 13, 2, -12 },
  { 1313, 9, 16, 13, 2, -12 },
  { 1331, 8, 12, 13, 2, -12 },
  { 1343, 9, 19, 13, 2, -17 },
  { 1365, 1, 19, 13, 6, -17 },
  { 1368, 9, 19, 13, 2, -17 },
  { 1390, 9, 4, 13, 2, -9 },
};

const GFXfont JetBrainsMono_Thin21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_THIN21PT7B_H_
