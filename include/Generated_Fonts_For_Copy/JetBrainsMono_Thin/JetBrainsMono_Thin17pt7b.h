#ifndef _JETBRAINSMONO_THIN17PT7B_H_
#define _JETBRAINSMONO_THIN17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x4F, 0x99, 0x99, 0x90, 0x11, 0x11, 0x08, 0x9F, 0xF2,
  0x21, 0x11, 0x10, 0x88, 0xFF, 0x22, 0x11, 0x09, 0x00, 0x08, 0x08, 0x18,
  0x6E, 0x4A, 0x49, 0x48, 0x68, 0x18, 0x0E, 0x0A, 0x09, 0x89, 0x4A, 0x3E,
  0x08, 0x08, 0x20, 0x56, 0x28, 0x8A, 0x24, 0x8A, 0x1C, 0x80, 0x40, 0x24,
  0x16, 0x85, 0x12, 0x45, 0x11, 0xC3, 0x80, 0x18, 0x12, 0x10, 0x88, 0x04,
  0x01, 0x01, 0x41, 0x22, 0x8A, 0x43, 0x21, 0x90, 0xC7, 0x98, 0xF8, 0x19,
  0x10, 0x84, 0x42, 0x10, 0x84, 0x20, 0x84, 0x30, 0xC1, 0xC1, 0x04, 0x20,
  0x84, 0x21, 0x08, 0x42, 0x11, 0x08, 0x98, 0x08, 0x08, 0x89, 0x7E, 0x08,
  0x14, 0x24, 0x42, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x6D,
  0x29, 0x00, 0xFC, 0xF0, 0x06, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0x31, 0x9A, 0x14, 0x18, 0x30, 0x6C,
  0xC9, 0x83, 0x06, 0x0C, 0x27, 0x80, 0x31, 0xA2, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x47, 0xF0, 0x18, 0x66, 0x42, 0x81, 0x01, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x7F, 0xFC, 0x21, 0x04, 0x38, 0x10, 0x41,
  0x06, 0x18, 0x5E, 0x0C, 0x41, 0x08, 0x21, 0x18, 0x61, 0xFC, 0x10, 0x41,
  0xFD, 0x02, 0x04, 0x0F, 0x90, 0x81, 0x01, 0x03, 0x0A, 0x13, 0xC0, 0x0C,
  0x10, 0x10, 0x20, 0x38, 0x66, 0x42, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFF,
  0x81, 0x82, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30,
  0x9A, 0x14, 0x18, 0x49, 0x8C, 0x24, 0x85, 0x06, 0x0C, 0x27, 0x80, 0x18,
  0x66, 0x42, 0x81, 0x81, 0x41, 0x42, 0x3E, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x7C, 0x00, 0xF0, 0x2D, 0x80, 0x03, 0x69, 0x48, 0x02, 0x18, 0xC6, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0x80, 0xC0,
  0x60, 0x21, 0x8C, 0x60, 0x80, 0xF0, 0x20, 0x41, 0x08, 0xE4, 0x10, 0x40,
  0x04, 0x30, 0x1C, 0x62, 0x41, 0x81, 0x81, 0x8F, 0x91, 0x91, 0x91, 0x91,
  0x91, 0x8F, 0x80, 0x40, 0x40, 0x3C, 0x18, 0x18, 0x14, 0x24, 0x24, 0x24,
  0x22, 0x42, 0x7E, 0x42, 0x81, 0x81, 0xFD, 0x0A, 0x0C, 0x28, 0x5F, 0x21,
  0x41, 0x83, 0x06, 0x17, 0xC0, 0x30, 0x9A, 0x14, 0x18, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x0C, 0x27, 0x80, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x7E, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x07,
  0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x04, 0x00,
  0x30, 0x9A, 0x14, 0x18, 0x10, 0x20, 0x4F, 0x83, 0x06, 0x0C, 0x27, 0x80,
  0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x61, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x03, 0x05, 0x0B, 0xE0, 0x83, 0x0A, 0x14, 0x48, 0x9E, 0x22, 0x44,
  0x85, 0x0A, 0x14, 0x10, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x07, 0xF0, 0x87, 0x8F, 0x2E, 0x5B, 0x36, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0x87, 0x1C, 0x69, 0xA6, 0x99, 0x65, 0x8E, 0x38, 0xE1, 0x31,
  0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFD, 0x06, 0x0C,
  0x18, 0x31, 0xBC, 0x40, 0x81, 0x02, 0x04, 0x00, 0x30, 0x9A, 0x14, 0x28,
  0x50, 0xA1, 0x42, 0x85, 0x0A, 0x14, 0x27, 0x81, 0x01, 0x03, 0xFD, 0x06,
  0x0C, 0x18, 0x31, 0xBC, 0x44, 0x89, 0x0A, 0x14, 0x10, 0x18, 0x66, 0x42,
  0x41, 0x40, 0x60, 0x18, 0x06, 0x02, 0x01, 0x81, 0x42, 0x3E, 0xFF, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x81, 0x41, 0x42, 0x42, 0x42,
  0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x18, 0x98, 0xCC, 0xA6, 0x53, 0x29,
  0x54, 0xAA, 0x94, 0xCA, 0x65, 0x33, 0x18, 0x88, 0x40, 0xC1, 0x42, 0x24,
  0x24, 0x18, 0x08, 0x18, 0x24, 0x24, 0x42, 0x42, 0x81, 0x81, 0x42, 0x42,
  0x24, 0x24, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFC, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x07, 0xF0, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x8F, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x80, 0x81, 0x03, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F,
  0x30, 0x61, 0x22, 0x48, 0x50, 0xC0, 0xFF, 0xC4, 0x18, 0x4D, 0x08, 0x10,
  0x2F, 0xE0, 0xC1, 0x42, 0xFC, 0x82, 0x0B, 0x33, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x7E, 0x30, 0x9A, 0x14, 0x18, 0x10, 0x20, 0x41, 0x84, 0xF0, 0x04,
  0x13, 0x53, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x31, 0x38, 0x61, 0x87,
  0xF8, 0x20, 0x85, 0xE0, 0x1F, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x31, 0x38, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10,
  0x41, 0x78, 0x82, 0x0B, 0x33, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x30,
  0x20, 0x00, 0x0F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x0C,
  0x30, 0x00, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xBC, 0x81,
  0x02, 0x0C, 0x28, 0x51, 0x24, 0x78, 0x89, 0x12, 0x14, 0x10, 0xF0, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x26, 0xD9,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x33, 0x38, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x31, 0x38, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0,
  0x33, 0x38, 0x61, 0x86, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x80, 0x31, 0x38,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x04, 0x11, 0xDA, 0x0C, 0x18,
  0x10, 0x20, 0x40, 0x81, 0x00, 0x11, 0x9A, 0x0C, 0x0C, 0x07, 0x81, 0x01,
  0x82, 0xF8, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x0E, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xC1, 0x42, 0x42,
  0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x89, 0x99, 0x99, 0x99, 0x55, 0x66,
  0x66, 0x66, 0x62, 0xC3, 0x24, 0x24, 0x18, 0x18, 0x14, 0x24, 0x42, 0xC1,
  0xC1, 0x42, 0x42, 0x22, 0x24, 0x14, 0x18, 0x18, 0x08, 0x10, 0x10, 0x30,
  0xFC, 0x20, 0x84, 0x20, 0x84, 0x20, 0xFC, 0x0E, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x78, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0xFF, 0xFF, 0xC0,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x0F, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x60, 0x21, 0xD1, 0x89, 0x86,
};

const GFXglyph JetBrainsMono_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -12 },
  { 7, 9, 12, 10, 1, -12 },
  { 21, 8, 17, 10, 1, -15 },
  { 38, 10, 13, 10, 0, -13 },
  { 55, 9, 13, 10, 1, -13 },
  { 70, 1, 5, 10, 5, -12 },
  { 71, 5, 16, 10, 3, -14 },
  { 81, 5, 16, 10, 2, -14 },
  { 91, 8, 8, 10, 1, -10 },
  { 99, 8, 8, 10, 1, -10 },
  { 107, 3, 6, 10, 3, -3 },
  { 110, 6, 1, 10, 2, -6 },
  { 111, 2, 2, 10, 4, -2 },
  { 112, 7, 16, 10, 2, -14 },
  { 126, 7, 13, 10, 2, -13 },
  { 138, 7, 12, 10, 2, -12 },
  { 149, 8, 13, 10, 1, -13 },
  { 162, 6, 12, 10, 2, -12 },
  { 171, 6, 12, 10, 2, -12 },
  { 180, 7, 12, 10, 2, -12 },
  { 191, 8, 12, 10, 1, -12 },
  { 203, 8, 12, 10, 1, -12 },
  { 215, 7, 13, 10, 2, -13 },
  { 227, 8, 13, 10, 1, -13 },
  { 240, 2, 10, 10, 4, -10 },
  { 243, 3, 13, 10, 3, -10 },
  { 248, 7, 9, 10, 2, -10 },
  { 256, 7, 5, 10, 2, -8 },
  { 261, 7, 9, 10, 2, -10 },
  { 269, 6, 12, 10, 3, -12 },
  { 278, 8, 16, 10, 1, -13 },
  { 294, 8, 12, 10, 1, -12 },
  { 306, 7, 12, 10, 2, -12 },
  { 317, 7, 13, 10, 2, -13 },
  { 329, 6, 12, 10, 2, -12 },
  { 338, 7, 12, 10, 2, -12 },
  { 349, 7, 12, 10, 2, -12 },
  { 360, 7, 13, 10, 2, -13 },
  { 372, 6, 12, 10, 2, -12 },
  { 381, 6, 12, 10, 2, -12 },
  { 390, 7, 12, 10, 1, -12 },
  { 401, 7, 12, 10, 2, -12 },
  { 412, 7, 12, 10, 2, -12 },
  { 423, 7, 12, 10, 2, -12 },
  { 434, 6, 12, 10, 2, -12 },
  { 443, 6, 13, 10, 2, -13 },
  { 453, 7, 12, 10, 2, -12 },
  { 464, 7, 16, 10, 2, -13 },
  { 478, 7, 12, 10, 2, -12 },
  { 489, 8, 13, 10, 1, -13 },
  { 502, 8, 12, 10, 1, -12 },
  { 514, 6, 12, 10, 2, -12 },
  { 523, 8, 12, 10, 1, -12 },
  { 535, 9, 12, 10, 1, -12 },
  { 549, 8, 12, 10, 1, -12 },
  { 561, 8, 12, 10, 1, -12 },
  { 573, 7, 12, 10, 2, -12 },
  { 584, 4, 16, 10, 4, -14 },
  { 592, 7, 16, 10, 2, -14 },
  { 606, 3, 16, 10, 3, -14 },
  { 612, 7, 6, 10, 2, -12 },
  { 618, 8, 1, 10, 1, 0 },
  { 619, 3, 2, 10, 3, -13 },
  { 620, 7, 10, 10, 1, -10 },
  { 629, 6, 12, 10, 2, -12 },
  { 638, 7, 10, 10, 2, -10 },
  { 647, 6, 12, 10, 2, -12 },
  { 656, 6, 10, 10, 2, -10 },
  { 664, 8, 12, 10, 1, -12 },
  { 676, 6, 13, 10, 2, -10 },
  { 686, 6, 12, 10, 2, -12 },
  { 695, 7, 13, 10, 2, -13 },
  { 707, 6, 16, 10, 2, -13 },
  { 719, 7, 12, 10, 2, -12 },
  { 730, 8, 12, 10, 1, -12 },
  { 742, 8, 10, 10, 1, -10 },
  { 752, 6, 10, 10, 2, -10 },
  { 760, 6, 10, 10, 2, -10 },
  { 768, 6, 13, 10, 2, -10 },
  { 778, 6, 13, 10, 2, -10 },
  { 788, 7, 10, 10, 2, -10 },
  { 797, 7, 10, 10, 2, -10 },
  { 806, 8, 12, 10, 1, -12 },
  { 818, 6, 9, 10, 2, -9 },
  { 825, 8, 9, 10, 1, -9 },
  { 834, 8, 9, 10, 1, -9 },
  { 843, 8, 9, 10, 1, -9 },
  { 852, 8, 12, 10, 1, -9 },
  { 864, 6, 9, 10, 2, -9 },
  { 871, 7, 16, 10, 2, -14 },
  { 885, 1, 16, 10, 5, -14 },
  { 887, 7, 16, 10, 2, -14 },
  { 901, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Thin17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_THIN17PT7B_H_
