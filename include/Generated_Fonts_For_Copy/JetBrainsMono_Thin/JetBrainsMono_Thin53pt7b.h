#ifndef _JETBRAINSMONO_THIN53PT7B_H_
#define _JETBRAINSMONO_THIN53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x47, 0xFF, 0xFF, 0xF7, 0x80, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0,
  0x06, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18,
  0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x30, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x06, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0x33, 0xE0, 0x78, 0x61, 0xE0,
  0xE0, 0xC1, 0xC3, 0x81, 0x81, 0xC7, 0x03, 0x03, 0x8C, 0x06, 0x03, 0x98,
  0x0C, 0x07, 0x30, 0x18, 0x0E, 0x60, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC0,
  0xC0, 0x03, 0x81, 0x80, 0x03, 0x83, 0x00, 0x07, 0x86, 0x00, 0x07, 0xCC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0x9F, 0x00, 0x03, 0x0F, 0x00, 0x06, 0x0F, 0x00, 0x0C, 0x0E,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x3E,
  0x01, 0x80, 0x6C, 0x03, 0x00, 0xD8, 0x06, 0x03, 0xB8, 0x0C, 0x07, 0x70,
  0x18, 0x0E, 0x70, 0x30, 0x38, 0xF0, 0x60, 0xE0, 0xF8, 0xC7, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x1C, 0x7F, 0xC0, 0x00, 0x63, 0xC7, 0x80, 0x03,
  0x1C, 0x06, 0x00, 0x1C, 0x70, 0x1C, 0x00, 0xE1, 0x80, 0x30, 0x03, 0x06,
  0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x03, 0x01, 0x80,
  0x30, 0x18, 0x06, 0x00, 0xC0, 0xE0, 0x18, 0x03, 0x07, 0x00, 0x60, 0x0C,
  0x18, 0x01, 0xC0, 0x70, 0xC0, 0x03, 0x01, 0x87, 0x00, 0x0F, 0xBE, 0x18,
  0x00, 0x1F, 0xF0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC1, 0xFC, 0x00, 0x06, 0x1F, 0xF8, 0x00, 0x38, 0x60, 0x70, 0x00,
  0xC3, 0x80, 0xE0, 0x06, 0x0C, 0x03, 0x80, 0x38, 0x30, 0x06, 0x01, 0xC0,
  0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0xC0, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x03, 0x00, 0x61, 0xC0, 0x0C, 0x03,
  0x86, 0x00, 0x38, 0x0C, 0x30, 0x00, 0x70, 0x71, 0xC0, 0x00, 0xFF, 0x8E,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x1C, 0xE0, 0x38, 0x07, 0x18, 0x07, 0x00, 0xE7, 0x00, 0x70,
  0x38, 0xE0, 0x07, 0x07, 0x1C, 0x00, 0x71, 0xC3, 0x80, 0x0E, 0x30, 0x70,
  0x00, 0xEE, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0xC0, 0x60, 0x00, 0xFC, 0x0E, 0x00, 0x1D, 0xC1, 0xC0,
  0x07, 0x38, 0x3C, 0x01, 0xC3, 0x83, 0xC0, 0xF0, 0x38, 0x3F, 0xFC, 0x03,
  0x83, 0xFE, 0x00, 0x38, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEE, 0x66, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x38, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x67, 0xC0,
  0x60, 0x3E, 0xFF, 0x86, 0x1F, 0xF1, 0xFE, 0x67, 0xF8, 0x03, 0xF7, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFC, 0xFE, 0x0F, 0x80, 0x7C, 0x38, 0x00, 0x71, 0xC0, 0x01,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xE0, 0x7E, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1F,
  0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xC0,
  0x03, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x60, 0x1C, 0x00,
  0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0x78, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3B, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0xE0,
  0x3C, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x1F, 0xF8, 0x1C, 0xFF, 0xF0,
  0x77, 0x03, 0xE1, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x60, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x1E, 0x03, 0xE0, 0x3F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x7F, 0x80, 0x3B, 0xFF, 0xC0, 0x6E, 0x07,
  0xC1, 0xF0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x38, 0xF0, 0x00, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x7E, 0x07, 0x00, 0x3C, 0x38, 0x00, 0x71,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x38, 0xE0, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x80, 0x78, 0x07, 0x03, 0xC0, 0x0F, 0x3C, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0x0F, 0x01, 0xE0,
  0x1E, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xC0, 0x00, 0xEE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9E, 0x00,
  0x1C, 0x3E, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0xF0, 0x03, 0x81,
  0xC0, 0x03, 0x87, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE1, 0xF0, 0x0F,
  0x81, 0xFF, 0xF7, 0x00, 0xFF, 0xDC, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x06, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0x07, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00,
  0x78, 0x7E, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0xF7, 0xE0, 0x1E, 0x07, 0xF8,
  0x0F, 0x00, 0xFE, 0x03, 0x80, 0x1F, 0x80, 0xE0, 0x07, 0xE0, 0x38, 0x01,
  0xF8, 0x0E, 0x00, 0x7E, 0x03, 0x80, 0x1F, 0x80, 0xE0, 0x07, 0xE0, 0x38,
  0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03, 0x80, 0x1F, 0x80, 0xE0, 0x07, 0xE0,
  0x38, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03, 0x80, 0x1F, 0x80, 0xE0, 0x0F,
  0xE0, 0x1C, 0x03, 0xF8, 0x07, 0xE7, 0xFE, 0x00, 0xFF, 0xDD, 0x80, 0x0F,
  0xC7, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xC3, 0x80, 0x01, 0x83, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81,
  0x80, 0x03, 0x81, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0x00,
  0x70, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0x80, 0x07, 0x8C,
  0x00, 0x1E, 0x60, 0x00, 0x73, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x60,
  0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x3C,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x00, 0xFC, 0x60, 0x00, 0xF3, 0x00,
  0x03, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xB0, 0x00, 0x3D, 0x80, 0x03, 0xCC,
  0x01, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xC1, 0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00,
  0x03, 0x9C, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0xE0, 0x3C, 0x0F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x04, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0C, 0x00, 0xF8, 0xC0, 0x03, 0xCC, 0x00, 0x1E, 0xC0, 0x00, 0xEC, 0x00,
  0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x78, 0xC0,
  0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCE,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xC1, 0xF0, 0x70, 0x03,
  0xC7, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x03, 0x9C, 0x00, 0x3C, 0x70, 0x03,
  0xC3, 0xE0, 0x3C, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0x70, 0x01, 0xC1, 0xE0, 0x3E, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x18, 0x00, 0x0E,
  0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83,
  0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x80, 0x60, 0x07, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x0E,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x78,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xF1, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC6,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x06, 0xF6, 0x00, 0x1B, 0xD8,
  0x00, 0xFF, 0x30, 0x03, 0x7C, 0xC0, 0x0D, 0xF3, 0x00, 0x67, 0xC6, 0x01,
  0x9F, 0x18, 0x06, 0x7C, 0x70, 0x31, 0xF0, 0xC0, 0xC7, 0xC3, 0x03, 0x1F,
  0x0E, 0x18, 0x7C, 0x18, 0x61, 0xF0, 0x63, 0x87, 0xC0, 0xCC, 0x1F, 0x03,
  0x30, 0x7C, 0x0D, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xD8, 0x00,
  0x7D, 0xC0, 0x07, 0xCC, 0x00, 0x7C, 0xC0, 0x07, 0xCE, 0x00, 0x7C, 0x60,
  0x07, 0xC6, 0x00, 0x7C, 0x30, 0x07, 0xC3, 0x00, 0x7C, 0x38, 0x07, 0xC1,
  0x80, 0x7C, 0x18, 0x07, 0xC1, 0xC0, 0x7C, 0x0C, 0x07, 0xC0, 0xE0, 0x7C,
  0x06, 0x07, 0xC0, 0x60, 0x7C, 0x07, 0x07, 0xC0, 0x30, 0x7C, 0x03, 0x87,
  0xC0, 0x18, 0x7C, 0x01, 0x87, 0xC0, 0x1C, 0x7C, 0x00, 0xC7, 0xC0, 0x0E,
  0x7C, 0x00, 0x67, 0xC0, 0x06, 0x7C, 0x00, 0x77, 0xC0, 0x03, 0x7C, 0x00,
  0x3B, 0xC0, 0x01, 0xBC, 0x00, 0x1B, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C,
  0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x30, 0x00, 0x7C, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x1F, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0x83, 0xE0, 0x70, 0x03, 0x87, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01,
  0xDC, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x1C,
  0x00, 0x38, 0xF0, 0x03, 0x83, 0xC0, 0x7C, 0x0F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x05, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x30,
  0x00, 0x78, 0xC0, 0x00, 0xF3, 0x00, 0x01, 0xEC, 0x00, 0x03, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x7B, 0x00, 0x03, 0xCC, 0x00, 0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x0E, 0x03,
  0x00, 0x38, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00,
  0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x03,
  0x8C, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0x07, 0xC0,
  0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x18,
  0x00, 0x07, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xE0, 0x01, 0xC1, 0xF0,
  0x0F, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x3E,
  0x07, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x60, 0x0F, 0x00, 0x66,
  0x00, 0xF0, 0x06, 0x60, 0x19, 0x80, 0xE6, 0x01, 0x98, 0x0E, 0x70, 0x19,
  0x80, 0xE7, 0x01, 0x98, 0x0E, 0x70, 0x19, 0x80, 0xC3, 0x01, 0x98, 0x0C,
  0x30, 0x19, 0x80, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03,
  0x0C, 0x1C, 0x38, 0x30, 0xC1, 0xC3, 0x83, 0x0C, 0x1C, 0x38, 0x30, 0xC1,
  0x83, 0x83, 0x0C, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18,
  0x60, 0x61, 0x81, 0x86, 0x06, 0x18, 0x1C, 0x60, 0x63, 0x81, 0xC6, 0x06,
  0x38, 0x1C, 0x40, 0x63, 0x01, 0xCC, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0E, 0xC0,
  0x37, 0x00, 0xE8, 0x03, 0x70, 0x0F, 0x80, 0x36, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18,
  0x1C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3C, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0xF3, 0x80, 0x07, 0xCF, 0x80, 0x77, 0x1F,
  0xFF, 0x9C, 0x1F, 0xF8, 0x70, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x80, 0xC3, 0xFE, 0x0C,
  0xFF, 0xF8, 0xDC, 0x03, 0xCD, 0x80, 0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xED,
  0x80, 0x1C, 0xCC, 0x03, 0xCC, 0x7F, 0xF8, 0xC3, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x78, 0x07, 0x87, 0x80,
  0x1E, 0x38, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00, 0x00,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x07, 0x1E, 0x00, 0x78, 0x7C,
  0x0F, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x07, 0x0F,
  0xFC, 0x71, 0xFF, 0xE7, 0x3C, 0x03, 0x77, 0x00, 0x1F, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x07, 0x71, 0xFF, 0xE7, 0x07, 0xFC, 0x70,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C,
  0x78, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC7, 0x1F, 0xFE,
  0x73, 0xC0, 0x37, 0x70, 0x01, 0xF7, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x70, 0x00, 0xF7, 0x00, 0x1F, 0x3C, 0x03, 0x71, 0xF9, 0xF7, 0x0F, 0xFC,
  0x70, 0x3F, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x03, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x80, 0xC3, 0xFE,
  0x0C, 0xFF, 0xF8, 0xCC, 0x03, 0xCD, 0x80, 0x1E, 0xF0, 0x00, 0xEE, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80,
  0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x1E,
  0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0E,
  0x03, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0x80, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xC0, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0x80, 0x60, 0xEF, 0xE1, 0xFC,
  0xFF, 0xF3, 0xFC, 0xF0, 0x7E, 0x0E, 0xF0, 0x3C, 0x0E, 0xE0, 0x38, 0x06,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0x00, 0x78, 0x0C, 0x3F, 0xE0, 0xCF, 0xFF, 0x8C, 0xC0, 0x3C, 0xD8, 0x01,
  0xED, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xC0,
  0x3C, 0x78, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x67, 0x00, 0x0E, 0x78, 0x01, 0xC3, 0xC0,
  0x3C, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x78, 0x0C,
  0x3F, 0xF0, 0xCF, 0xFF, 0x8D, 0xC0, 0x3C, 0xD8, 0x01, 0xEF, 0x00, 0x0E,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6F,
  0x00, 0x0E, 0xD8, 0x01, 0xCC, 0xC0, 0x3C, 0xC7, 0xFF, 0x8C, 0x3F, 0xE0,
  0xC0, 0x70, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC7, 0x1F, 0xFE, 0x73, 0xC0, 0x37, 0x70,
  0x01, 0xF7, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x77, 0x1F,
  0xFE, 0x70, 0x7F, 0xC7, 0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xF8, 0x0C, 0x3F, 0xF0, 0xCF, 0xFF,
  0x8D, 0xC0, 0x3C, 0xD8, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x79, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0x98, 0x00, 0x01, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x67, 0x80, 0x03, 0x8F, 0x00,
  0x3C, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x80, 0x1C, 0x3E, 0x07, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x01, 0xE0,
  0x1F, 0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0x98, 0x04, 0x80, 0x66, 0x03,
  0x30, 0x19, 0x80, 0xCC, 0x0E, 0x70, 0x33, 0x03, 0x9C, 0x0C, 0xC0, 0xE7,
  0x02, 0x30, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x61,
  0xC3, 0x86, 0x18, 0x70, 0xE1, 0x86, 0x18, 0x38, 0xC1, 0xC6, 0x06, 0x30,
  0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x1C, 0xC0, 0xCE, 0x07,
  0x60, 0x3B, 0x01, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x81, 0xC0, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x3E,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x06, 0x3F,
  0x80, 0x0C, 0xFF, 0x80, 0x1B, 0x83, 0x80, 0x36, 0x03, 0x80, 0x6C, 0x03,
  0x80, 0xF8, 0x07, 0x83, 0xF0, 0x07, 0x87, 0xE0, 0x07, 0xFD, 0xC0, 0x03,
  0xF0,
};

const GFXglyph JetBrainsMono_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 6, 39, 32, 13, -39 },
  { 31, 14, 16, 32, 9, -39 },
  { 59, 28, 39, 32, 2, -39 },
  { 196, 23, 53, 32, 4, -46 },
  { 349, 30, 39, 32, 1, -39 },
  { 496, 27, 40, 32, 3, -39 },
  { 631, 4, 16, 32, 14, -39 },
  { 639, 15, 51, 32, 11, -45 },
  { 735, 15, 51, 32, 6, -45 },
  { 831, 28, 27, 32, 2, -32 },
  { 926, 24, 25, 32, 4, -30 },
  { 1001, 9, 16, 32, 10, -8 },
  { 1019, 17, 3, 32, 7, -19 },
  { 1026, 8, 8, 32, 12, -7 },
  { 1034, 22, 50, 32, 5, -44 },
  { 1172, 22, 40, 32, 5, -39 },
  { 1282, 23, 39, 32, 5, -39 },
  { 1395, 24, 39, 32, 4, -39 },
  { 1512, 21, 40, 32, 5, -39 },
  { 1617, 21, 39, 32, 5, -39 },
  { 1720, 22, 40, 32, 5, -39 },
  { 1830, 23, 40, 32, 4, -39 },
  { 1945, 24, 39, 32, 4, -39 },
  { 2062, 22, 40, 32, 5, -39 },
  { 2172, 23, 39, 32, 4, -39 },
  { 2285, 8, 31, 32, 12, -30 },
  { 2316, 10, 38, 32, 10, -30 },
  { 2364, 22, 27, 32, 5, -31 },
  { 2439, 22, 15, 32, 5, -25 },
  { 2481, 22, 27, 32, 5, -31 },
  { 2556, 18, 39, 32, 9, -39 },
  { 2644, 26, 48, 32, 3, -39 },
  { 2800, 24, 39, 32, 4, -39 },
  { 2917, 21, 39, 32, 6, -39 },
  { 3020, 21, 40, 32, 6, -39 },
  { 3125, 20, 39, 32, 6, -39 },
  { 3223, 21, 39, 32, 6, -39 },
  { 3326, 22, 39, 32, 6, -39 },
  { 3434, 21, 40, 32, 6, -39 },
  { 3539, 20, 39, 32, 6, -39 },
  { 3637, 19, 39, 32, 6, -39 },
  { 3730, 21, 40, 32, 4, -39 },
  { 3835, 23, 39, 32, 6, -39 },
  { 3948, 22, 39, 32, 6, -39 },
  { 4056, 22, 39, 32, 5, -39 },
  { 4164, 20, 39, 32, 6, -39 },
  { 4262, 20, 40, 32, 6, -39 },
  { 4362, 22, 39, 32, 6, -39 },
  { 4470, 21, 49, 32, 6, -39 },
  { 4599, 22, 39, 32, 6, -39 },
  { 4707, 23, 40, 32, 4, -39 },
  { 4822, 26, 39, 32, 3, -39 },
  { 4949, 20, 40, 32, 6, -39 },
  { 5049, 24, 39, 32, 4, -39 },
  { 5166, 28, 39, 32, 2, -39 },
  { 5303, 26, 39, 32, 3, -39 },
  { 5430, 26, 39, 32, 3, -39 },
  { 5557, 22, 39, 32, 5, -39 },
  { 5665, 12, 50, 32, 12, -44 },
  { 5740, 22, 50, 32, 5, -44 },
  { 5878, 12, 50, 32, 8, -44 },
  { 5953, 22, 21, 32, 5, -39 },
  { 6011, 26, 3, 32, 3, 1 },
  { 6021, 9, 8, 32, 11, -42 },
  { 6030, 22, 31, 32, 4, -30 },
  { 6116, 20, 40, 32, 6, -39 },
  { 6216, 21, 31, 32, 6, -30 },
  { 6298, 20, 40, 32, 6, -39 },
  { 6398, 20, 31, 32, 6, -30 },
  { 6476, 24, 39, 32, 4, -39 },
  { 6593, 20, 40, 32, 6, -30 },
  { 6693, 20, 39, 32, 6, -39 },
  { 6791, 23, 41, 32, 5, -41 },
  { 6909, 19, 51, 32, 5, -41 },
  { 7031, 22, 39, 32, 6, -39 },
  { 7139, 26, 39, 32, 3, -39 },
  { 7266, 24, 30, 32, 4, -30 },
  { 7356, 20, 30, 32, 6, -30 },
  { 7431, 20, 31, 32, 6, -30 },
  { 7509, 20, 40, 32, 6, -30 },
  { 7609, 20, 40, 32, 6, -30 },
  { 7709, 20, 30, 32, 7, -30 },
  { 7784, 22, 31, 32, 5, -30 },
  { 7870, 23, 37, 32, 4, -37 },
  { 7977, 20, 30, 32, 6, -29 },
  { 8052, 24, 29, 32, 4, -29 },
  { 8139, 26, 29, 32, 3, -29 },
  { 8234, 24, 29, 32, 4, -29 },
  { 8321, 24, 39, 32, 4, -29 },
  { 8438, 21, 29, 32, 5, -29 },
  { 8515, 22, 50, 32, 5, -44 },
  { 8653, 2, 50, 32, 15, -44 },
  { 8666, 22, 50, 32, 5, -44 },
  { 8804, 23, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_Thin53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_THIN53PT7B_H_
