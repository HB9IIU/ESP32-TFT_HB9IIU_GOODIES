#ifndef _JETBRAINSMONO_THIN41PT7B_H_
#define _JETBRAINSMONO_THIN41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0x8C, 0x61,
  0x08, 0x42, 0x10, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x60,
  0x60, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x10, 0x01,
  0x80, 0xC0, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0xFF, 0xFF, 0xF8, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x20, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x04, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1C, 0x47, 0x0C, 0x10, 0xE3, 0x04,
  0x19, 0xC1, 0x07, 0x60, 0x40, 0xD8, 0x10, 0x37, 0x04, 0x00, 0xC1, 0x00,
  0x30, 0x40, 0x06, 0x10, 0x01, 0xE4, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x04, 0xF0, 0x01, 0x0C, 0x00, 0x41, 0x80, 0x10, 0x70, 0x04,
  0x0C, 0x01, 0x03, 0xE0, 0x40, 0xD8, 0x10, 0x36, 0x04, 0x0D, 0x81, 0x07,
  0x70, 0x41, 0x8E, 0x10, 0xE1, 0xF5, 0xF0, 0x1F, 0xF0, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x1F,
  0x00, 0x06, 0x7F, 0x80, 0x19, 0x83, 0x00, 0x62, 0x03, 0x00, 0x8C, 0x06,
  0x03, 0x18, 0x0C, 0x0C, 0x30, 0x18, 0x30, 0x60, 0x30, 0x60, 0xC0, 0x61,
  0x81, 0x80, 0xC6, 0x01, 0x83, 0x08, 0x03, 0x8E, 0x30, 0x03, 0xF8, 0xC0,
  0x00, 0x83, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x87, 0xE0, 0x03, 0x18, 0x60, 0x0C, 0x60, 0x60, 0x10, 0xC0, 0xC0,
  0x61, 0x81, 0x81, 0x83, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x30,
  0x18, 0x18, 0xC0, 0x30, 0x31, 0x00, 0x60, 0x66, 0x00, 0x7F, 0x98, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x70, 0x30, 0x03, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF0,
  0x00, 0x73, 0x00, 0x0E, 0x18, 0x06, 0xC1, 0xC0, 0x6C, 0x0E, 0x0C, 0xC0,
  0x60, 0xCC, 0x03, 0x18, 0xC0, 0x19, 0x8C, 0x01, 0xF0, 0xC0, 0x0F, 0x0C,
  0x00, 0x60, 0xC0, 0x0F, 0x0C, 0x00, 0xF8, 0xC0, 0x19, 0x86, 0x03, 0x0C,
  0x7D, 0xE0, 0x63, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0x60, 0x00, 0x70,
  0x1F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x20, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x02, 0x01, 0x80, 0x5E, 0x0C, 0x0F,
  0xFE, 0x63, 0xF8, 0xFD, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0D,
  0x00, 0x00, 0xEC, 0x00, 0x06, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x06, 0x00,
  0x70, 0x38, 0x03, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x80, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x78, 0xE1,
  0xC3, 0x8E, 0x1C, 0x30, 0x60, 0xC3, 0x06, 0x08, 0x00, 0xFF, 0xF8, 0x31,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xEE,
  0x00, 0x37, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x87,
  0x83, 0xC1, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0x70, 0x01, 0x9C, 0x01,
  0xC7, 0x01, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x76, 0x00, 0x71, 0x80, 0x38, 0x60, 0x1C, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xE0, 0x1C, 0x18, 0x01,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x70, 0x0C, 0x3F,
  0xFC, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x7F, 0xFF, 0x3F, 0xFF, 0x98, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x38, 0x0C, 0xFF, 0x06, 0xC3, 0xE3, 0xC0, 0x71, 0xC0, 0x1C, 0xC0,
  0x06, 0x60, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x01, 0x98, 0x01,
  0x86, 0x01, 0xC1, 0xF7, 0xC0, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x19, 0xF8,
  0x07, 0xFF, 0x83, 0xC0, 0x70, 0xE0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x76,
  0x00, 0x0D, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x01, 0xDC, 0x00, 0x63, 0x00, 0x38, 0x70, 0x1C, 0x0F, 0xBE,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x70, 0x00,
  0x6E, 0x00, 0x0D, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xE6,
  0x00, 0x33, 0x00, 0x1B, 0x80, 0x07, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x01,
  0x9C, 0x01, 0x87, 0x01, 0xC1, 0xC1, 0x80, 0x3B, 0x80, 0x0F, 0x00, 0x0E,
  0xE0, 0x1C, 0x3C, 0x1C, 0x07, 0x18, 0x01, 0xDC, 0x00, 0x6C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0x98, 0x00,
  0xCE, 0x01, 0xC3, 0xF7, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x81,
  0xC0, 0x70, 0xC0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x76, 0x00, 0x0D, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01,
  0xDC, 0x00, 0x63, 0x80, 0x38, 0x70, 0x1E, 0x0F, 0xFB, 0x01, 0xFD, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x47, 0xFF, 0xFF, 0xF7, 0xC0, 0x3C, 0xFD, 0xFB,
  0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x38, 0xF1, 0xC3, 0x87, 0x1C, 0x38, 0x60, 0xC1, 0x86, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x0E, 0x18, 0x00, 0xE7, 0x00, 0x0C, 0xC0,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF9, 0xE0, 0x3F, 0xBC, 0x0E, 0x1F, 0x83, 0x80, 0xF0, 0x60, 0x1E, 0x0C,
  0x03, 0xC1, 0x80, 0x78, 0x30, 0x0F, 0x06, 0x01, 0xE0, 0xC0, 0x3C, 0x18,
  0x07, 0x83, 0x00, 0xF0, 0x60, 0x1E, 0x0C, 0x03, 0xC0, 0xC0, 0xF8, 0x1C,
  0x3F, 0x01, 0xFD, 0xE0, 0x0E, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x0C, 0x01, 0x83, 0xFF, 0xF0, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xC0, 0x3C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0,
  0x1C, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF,
  0xF8, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xE6,
  0x00, 0x33, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x9C, 0x01,
  0xC7, 0x01, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xC3, 0x01,
  0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x03, 0xCF,
  0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF9,
  0xFF, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFE,
  0x0E, 0x03, 0x8E, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x60,
  0x03, 0xB0, 0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x70,
  0x01, 0x98, 0x01, 0xC6, 0x01, 0xC3, 0xF7, 0xC0, 0x7F, 0x80, 0xC0, 0x03,
  0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00,
  0x71, 0x80, 0x30, 0xC0, 0x38, 0x60, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x03, 0xFF, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x30, 0x1C, 0x18, 0x06, 0x0C, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x71, 0x80,
  0x18, 0xC0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1C, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xBD, 0x00, 0xDE, 0xC0, 0x4F, 0x20, 0x67, 0x98, 0x33, 0xCC,
  0x11, 0xE2, 0x18, 0xF1, 0x8C, 0x78, 0xC4, 0x3C, 0x26, 0x1E, 0x1B, 0x0F,
  0x0D, 0x07, 0x83, 0x83, 0xC1, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1D, 0x80, 0x3B, 0x00, 0x72, 0x00, 0xE6, 0x01, 0xCC,
  0x03, 0x8C, 0x07, 0x18, 0x0E, 0x10, 0x1C, 0x30, 0x38, 0x60, 0x70, 0x60,
  0xE0, 0xC1, 0xC0, 0x83, 0x81, 0x87, 0x03, 0x0E, 0x03, 0x1C, 0x06, 0x38,
  0x04, 0x70, 0x0C, 0xE0, 0x19, 0xC0, 0x1B, 0x80, 0x37, 0x00, 0x6E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x38,
  0x0E, 0x70, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70,
  0x06, 0x38, 0x0E, 0x1F, 0x7C, 0x0F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE, 0x30,
  0x07, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x33, 0x00, 0xF9, 0xFF, 0xF0, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x06, 0x60, 0x03, 0x30, 0x01, 0x9C, 0x01, 0x87, 0x01, 0xC1, 0xF7,
  0xC0, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x07,
  0x18, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x73,
  0x01, 0xF1, 0xFF, 0xF0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x1C, 0x07, 0xFC,
  0x03, 0xFF, 0x81, 0xC0, 0x70, 0xC0, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x66,
  0x00, 0x0D, 0x80, 0x03, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x18, 0xE0,
  0x0E, 0x1F, 0xBF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x70, 0x06, 0x38, 0x0E, 0x1F, 0x7C, 0x0F, 0xF0, 0xC0, 0x00, 0x78,
  0x00, 0x1B, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x87, 0x00, 0x60, 0x60, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x61, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xD0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xF0, 0x14, 0x07, 0x80, 0xA0, 0x3C, 0x0D, 0x01, 0x60, 0x68,
  0x1B, 0x03, 0x60, 0xC8, 0x1B, 0x06, 0x60, 0x98, 0x33, 0x04, 0xC1, 0x98,
  0x22, 0x0C, 0xC3, 0x10, 0x66, 0x18, 0x82, 0x30, 0xC6, 0x31, 0x86, 0x31,
  0x84, 0x21, 0x8C, 0x31, 0x0C, 0x61, 0x88, 0x23, 0x0C, 0xC1, 0x18, 0x66,
  0x08, 0xC3, 0x30, 0x64, 0x19, 0x83, 0x20, 0xC8, 0x1B, 0x02, 0x40, 0xD8,
  0x1A, 0x02, 0xC0, 0xF0, 0x16, 0x07, 0x80, 0xB0, 0x3C, 0x05, 0x81, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x60, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x1C, 0x01, 0x80, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x60, 0x70,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x00, 0xD8,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x19,
  0x80, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x30, 0x0E,
  0x03, 0x00, 0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3,
  0x00, 0x06, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3B, 0x00, 0x01,
  0x98, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x01, 0x81, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFE, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x76,
  0x00, 0x31, 0x80, 0x38, 0xC0, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x06, 0x01, 0x83, 0x00, 0x63, 0x80, 0x31, 0x80, 0x1D, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0x83, 0x87, 0x00, 0x63, 0x00, 0x39, 0x80, 0x0D,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xE3, 0xFF,
  0xF3, 0x80, 0x1B, 0x80, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x77, 0x80, 0x79, 0xFB, 0xEC, 0x3F, 0xC6,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x63, 0xF0, 0xDF, 0xF1, 0xE0, 0x73, 0x80, 0x36, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x37, 0x80, 0xED, 0xEF, 0x99, 0xFE, 0x00, 0x07, 0xE0, 0x0F,
  0xFC, 0x0E, 0x07, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0D,
  0x80, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xFB, 0xE0, 0x3F, 0xE0, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x70, 0x0F, 0x60, 0x07, 0x60, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x07, 0x70, 0x07, 0x30, 0x0F, 0x1E, 0x7B, 0x0F, 0xE3, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x60, 0x03,
  0x70, 0x06, 0x38, 0x0E, 0x1F, 0x7C, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x70, 0x0F,
  0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x07, 0x70, 0x07, 0x38, 0x0B, 0x1F, 0x7B, 0x0F, 0xE3, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x7C, 0x1F, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x63, 0xF0, 0xDF, 0xF1, 0xE0, 0x73, 0x80,
  0x36, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x1F, 0xF8, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x03, 0x18, 0x03,
  0x8C, 0x01, 0x86, 0x01, 0x83, 0x01, 0xC1, 0x81, 0xC0, 0xC0, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x18, 0x38, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0xC1,
  0x80, 0x70, 0xC0, 0x18, 0x60, 0x0E, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00,
  0x76, 0x00, 0x1C, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0x0F, 0x37, 0xE7, 0xEF, 0x1E,
  0x1F, 0x83, 0x83, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03,
  0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0,
  0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C,
  0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0C, 0xC7, 0xE1,
  0xBF, 0xE3, 0xC0, 0xE7, 0x00, 0x6C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C,
  0x30, 0x06, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x06, 0x38, 0x0E,
  0x1F, 0x7C, 0x0F, 0xF0, 0xC7, 0xE1, 0xBF, 0xE3, 0xC0, 0xE7, 0x00, 0x6C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x6F, 0x01, 0xDB, 0xDF, 0x33, 0xFC, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x70, 0x07, 0x60, 0x07, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0F, 0x1E, 0x7B, 0x0F, 0xE3, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0xC3, 0xE0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0, 0x0E, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8C, 0x00, 0xE6, 0x00, 0x37, 0x00, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x67, 0x00, 0x71, 0xF1, 0xF0, 0x7F, 0xF0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x06, 0x38, 0x0E,
  0x1F, 0x7C, 0x0F, 0xF0, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x03,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x06,
  0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x60, 0x1E, 0x03,
  0x81, 0xB0, 0x1C, 0x0C, 0xC0, 0xA0, 0x66, 0x05, 0x03, 0x30, 0x68, 0x19,
  0x83, 0x60, 0xCC, 0x13, 0x0C, 0x60, 0x98, 0x61, 0x84, 0x43, 0x0C, 0x62,
  0x18, 0x63, 0x18, 0xC3, 0x18, 0xC6, 0x18, 0x86, 0x60, 0xC4, 0x33, 0x03,
  0x60, 0x98, 0x1B, 0x04, 0xC0, 0xD8, 0x36, 0x06, 0x81, 0xA0, 0x34, 0x0D,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x60, 0x00, 0xCE,
  0x00, 0x30, 0xC0, 0x0E, 0x0C, 0x01, 0x81, 0xC0, 0x60, 0x18, 0x1C, 0x01,
  0x83, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0xCE, 0x00, 0x30, 0xC0, 0x06,
  0x0C, 0x01, 0x81, 0xC0, 0x60, 0x18, 0x1C, 0x01, 0x83, 0x00, 0x38, 0xC0,
  0x03, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x0C, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x87, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x01,
  0xE0, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x3E, 0x00, 0xDF, 0xE0, 0x36, 0x1C,
  0x0D, 0x03, 0x83, 0xC0, 0x60, 0xF0, 0x0E, 0x6C, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 30, 25, 10, -30 },
  { 20, 11, 12, 25, 7, -30 },
  { 37, 22, 30, 25, 1, -30 },
  { 120, 18, 42, 25, 3, -36 },
  { 215, 23, 30, 25, 1, -30 },
  { 302, 20, 30, 25, 3, -30 },
  { 377, 3, 12, 25, 11, -30 },
  { 382, 12, 39, 25, 8, -34 },
  { 441, 11, 39, 25, 5, -34 },
  { 495, 21, 21, 25, 2, -25 },
  { 551, 19, 19, 25, 3, -23 },
  { 597, 7, 13, 25, 8, -6 },
  { 609, 13, 1, 25, 6, -14 },
  { 611, 6, 6, 25, 9, -6 },
  { 616, 17, 39, 25, 4, -34 },
  { 699, 17, 30, 25, 4, -30 },
  { 763, 18, 30, 25, 4, -30 },
  { 831, 19, 30, 25, 3, -30 },
  { 903, 16, 30, 25, 4, -30 },
  { 963, 16, 30, 25, 4, -30 },
  { 1023, 17, 30, 25, 4, -30 },
  { 1087, 18, 30, 25, 3, -30 },
  { 1155, 19, 30, 25, 3, -30 },
  { 1227, 17, 30, 25, 4, -30 },
  { 1291, 18, 30, 25, 3, -30 },
  { 1359, 6, 23, 25, 9, -23 },
  { 1377, 7, 30, 25, 8, -23 },
  { 1404, 17, 21, 25, 4, -24 },
  { 1449, 17, 11, 25, 4, -19 },
  { 1473, 17, 21, 25, 4, -24 },
  { 1518, 14, 30, 25, 7, -30 },
  { 1571, 19, 37, 25, 3, -30 },
  { 1659, 19, 30, 25, 3, -30 },
  { 1731, 16, 30, 25, 5, -30 },
  { 1791, 17, 30, 25, 4, -30 },
  { 1855, 15, 30, 25, 5, -30 },
  { 1912, 16, 30, 25, 5, -30 },
  { 1972, 17, 30, 25, 5, -30 },
  { 2036, 17, 30, 25, 4, -30 },
  { 2100, 15, 30, 25, 5, -30 },
  { 2157, 15, 30, 25, 5, -30 },
  { 2214, 17, 30, 25, 3, -30 },
  { 2278, 17, 30, 25, 5, -30 },
  { 2342, 17, 30, 25, 5, -30 },
  { 2406, 17, 30, 25, 4, -30 },
  { 2470, 15, 30, 25, 5, -30 },
  { 2527, 16, 30, 25, 4, -30 },
  { 2587, 17, 30, 25, 5, -30 },
  { 2651, 17, 37, 25, 4, -30 },
  { 2730, 17, 30, 25, 5, -30 },
  { 2794, 18, 30, 25, 3, -30 },
  { 2862, 20, 30, 25, 2, -30 },
  { 2937, 16, 30, 25, 4, -30 },
  { 2997, 19, 30, 25, 3, -30 },
  { 3069, 21, 30, 25, 2, -30 },
  { 3148, 20, 30, 25, 2, -30 },
  { 3223, 21, 30, 25, 2, -30 },
  { 3302, 17, 30, 25, 4, -30 },
  { 3366, 9, 39, 25, 9, -34 },
  { 3410, 17, 39, 25, 4, -34 },
  { 3493, 10, 39, 25, 6, -34 },
  { 3542, 17, 16, 25, 4, -30 },
  { 3576, 20, 2, 25, 2, 1 },
  { 3581, 7, 6, 25, 8, -32 },
  { 3587, 17, 23, 25, 3, -23 },
  { 3636, 15, 30, 25, 5, -30 },
  { 3693, 17, 23, 25, 4, -23 },
  { 3742, 16, 30, 25, 4, -30 },
  { 3802, 16, 23, 25, 4, -23 },
  { 3848, 18, 30, 25, 3, -30 },
  { 3916, 16, 30, 25, 4, -23 },
  { 3976, 15, 30, 25, 5, -30 },
  { 4033, 18, 31, 25, 4, -31 },
  { 4103, 15, 38, 25, 4, -31 },
  { 4175, 17, 30, 25, 5, -30 },
  { 4239, 20, 30, 25, 2, -30 },
  { 4314, 18, 23, 25, 3, -23 },
  { 4366, 15, 23, 25, 5, -23 },
  { 4410, 16, 23, 25, 4, -23 },
  { 4456, 15, 30, 25, 5, -23 },
  { 4513, 16, 30, 25, 4, -23 },
  { 4573, 16, 23, 25, 5, -23 },
  { 4619, 17, 23, 25, 4, -23 },
  { 4668, 18, 29, 25, 3, -29 },
  { 4734, 16, 23, 25, 4, -23 },
  { 4780, 18, 23, 25, 3, -23 },
  { 4832, 21, 23, 25, 2, -23 },
  { 4893, 19, 23, 25, 3, -23 },
  { 4948, 18, 30, 25, 3, -23 },
  { 5016, 16, 23, 25, 4, -23 },
  { 5062, 17, 39, 25, 4, -34 },
  { 5145, 2, 39, 25, 11, -34 },
  { 5155, 17, 39, 25, 4, -34 },
  { 5238, 18, 7, 25, 3, -18 },
};

const GFXfont JetBrainsMono_Thin41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_THIN41PT7B_H_
