#ifndef _JETBRAINSMONO_THIN49PT7B_H_
#define _JETBRAINSMONO_THIN49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFF, 0xDE, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76,
  0x03, 0xB0, 0x1D, 0x80, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x18, 0x03, 0x80,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x1C, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x00,
  0x60, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x06,
  0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x80, 0xF9, 0x9E, 0x07, 0x0C, 0x38, 0x70, 0x60, 0xE3, 0x03, 0x07,
  0x38, 0x18, 0x19, 0xC0, 0xC0, 0xEE, 0x06, 0x07, 0x70, 0x30, 0x03, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x83, 0x00, 0x0F, 0x18, 0x00,
  0x3C, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0D,
  0xF0, 0x00, 0x63, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xC0, 0xE0,
  0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x80, 0xF8, 0x0C, 0x07, 0xC0, 0x60,
  0x3E, 0x03, 0x03, 0xB0, 0x18, 0x1D, 0xC0, 0xC0, 0xC7, 0x06, 0x0E, 0x1E,
  0x31, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x63, 0xFC, 0x00, 0x1C, 0xE1, 0xC0, 0x03,
  0x38, 0x1C, 0x00, 0xC6, 0x01, 0x80, 0x30, 0xC0, 0x30, 0x0E, 0x18, 0x06,
  0x01, 0x83, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x1C, 0x0C, 0x03, 0x03, 0x01,
  0x80, 0x60, 0xC0, 0x30, 0x0C, 0x30, 0x06, 0x03, 0x86, 0x00, 0xE0, 0x61,
  0x80, 0x0F, 0xFC, 0x60, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x87,
  0xF0, 0x00, 0x61, 0xFF, 0x00, 0x0C, 0x70, 0x70, 0x03, 0x0C, 0x06, 0x00,
  0xC1, 0x80, 0xE0, 0x38, 0x70, 0x0C, 0x06, 0x0E, 0x01, 0x81, 0x81, 0xC0,
  0x30, 0x60, 0x38, 0x06, 0x0C, 0x07, 0x00, 0xC3, 0x00, 0xE0, 0x18, 0xC0,
  0x0C, 0x07, 0x38, 0x01, 0x80, 0xC6, 0x00, 0x38, 0x39, 0x80, 0x03, 0xFE,
  0x70, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x87,
  0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x70, 0xE0,
  0x07, 0x60, 0x70, 0x06, 0xE0, 0x38, 0x0E, 0xE0, 0x1C, 0x0C, 0xE0, 0x0C,
  0x1C, 0xE0, 0x0E, 0x18, 0xE0, 0x07, 0x38, 0xE0, 0x03, 0xF0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xF0, 0xE0, 0x01,
  0xB0, 0x60, 0x03, 0xB8, 0x70, 0x07, 0x1C, 0x38, 0x1E, 0x0E, 0x3F, 0xFC,
  0x06, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xD8, 0x00, 0x0C,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xC0, 0x07, 0x80,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x60, 0x1C, 0x03, 0xFE, 0x06, 0x0F, 0xDF, 0xE3, 0x1F,
  0xC1, 0xFD, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x02, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x3E, 0x0F, 0x87, 0x80, 0x3C, 0x70, 0x01, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x06, 0xE0, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC3, 0xE0, 0x78, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0x70, 0x01, 0xE3, 0x80, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x1C, 0x07,
  0x00, 0xC0, 0x38, 0x04, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x3C, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x00, 0x0E, 0x38, 0x01, 0xC1, 0xE0, 0x3C, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x20, 0x06, 0x3F,
  0xE0, 0x67, 0xFF, 0x86, 0xC0, 0x78, 0x78, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0xE6, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01,
  0xC3, 0xC0, 0x78, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0xC0, 0x03,
  0xBF, 0xE0, 0x1B, 0xFF, 0xC1, 0xF0, 0x0F, 0x0E, 0x00, 0x38, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x36, 0x00, 0x03,
  0xB0, 0x00, 0x1D, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xF0,
  0x1E, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3, 0x80, 0x07, 0x18,
  0x00, 0x39, 0xC0, 0x00, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x06, 0x0E, 0x00, 0x70, 0x38,
  0x0F, 0x00, 0xF0, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0x0E, 0x00, 0xE0, 0x3C, 0x0E, 0x00, 0x70, 0xE0, 0x01, 0xCE, 0x00,
  0x0E, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEE, 0x00, 0x0E, 0x38, 0x00,
  0xF0, 0xF0, 0x0F, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xC0, 0xF0, 0x78, 0x01, 0xC3, 0x80, 0x07, 0x38, 0x00,
  0x39, 0x80, 0x00, 0xCC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0x80, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x71, 0xC0, 0x07, 0x87, 0x00, 0x78, 0x3F,
  0x1E, 0xC0, 0x7F, 0xEC, 0x00, 0xF8, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x8F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0x1F, 0x1F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x78, 0x3C, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xC7, 0xE0,
  0x1F, 0xF7, 0xE0, 0x3F, 0x7F, 0xE0, 0x38, 0x0F, 0xE0, 0x70, 0x07, 0xE0,
  0x70, 0x07, 0xE0, 0x60, 0x07, 0xE0, 0x60, 0x07, 0xE0, 0x60, 0x07, 0xE0,
  0x60, 0x07, 0xE0, 0x60, 0x07, 0xE0, 0x60, 0x07, 0xE0, 0x60, 0x07, 0xE0,
  0x60, 0x07, 0xE0, 0x60, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x38, 0x0F, 0xE0, 0x3C, 0x1F, 0xE0, 0x1F, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8E, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0xC0,
  0x0E, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x0C, 0x03, 0x00, 0x18, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0x87, 0x00,
  0x03, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xE0, 0x3F, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x6E, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x01, 0xC1,
  0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0x83, 0xF8, 0x70, 0x03, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x37,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1C, 0xE0,
  0x07, 0x9C, 0x07, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCC, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07,
  0x83, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x67, 0x00,
  0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x66,
  0x00, 0x03, 0x30, 0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x38, 0x00,
  0xE0, 0xF0, 0x1E, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x63, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38,
  0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xC0,
  0xE0, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x0E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xBF, 0x00, 0x1B,
  0xD8, 0x01, 0xBD, 0x80, 0x33, 0xD8, 0x03, 0x3C, 0xC0, 0x33, 0xCC, 0x06,
  0x3C, 0x60, 0x63, 0xC6, 0x04, 0x3C, 0x60, 0xC7, 0xC3, 0x0C, 0x7C, 0x31,
  0x87, 0xC3, 0x18, 0x7C, 0x19, 0x87, 0xC1, 0xB0, 0x7C, 0x1B, 0x07, 0xC0,
  0xF0, 0x7C, 0x0E, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xD8, 0x00, 0xFB, 0x00,
  0x1F, 0x70, 0x03, 0xE6, 0x00, 0x7C, 0xC0, 0x0F, 0x8C, 0x01, 0xF1, 0x80,
  0x3E, 0x38, 0x07, 0xC3, 0x00, 0xF8, 0x60, 0x1F, 0x06, 0x03, 0xE0, 0xC0,
  0x7C, 0x1C, 0x0F, 0x81, 0x81, 0xF0, 0x30, 0x3E, 0x03, 0x07, 0xC0, 0x60,
  0xF8, 0x0E, 0x1F, 0x00, 0xC3, 0xE0, 0x18, 0x7C, 0x03, 0x8F, 0x80, 0x31,
  0xF0, 0x07, 0x3E, 0x00, 0x67, 0xC0, 0x0C, 0xF8, 0x01, 0xDF, 0x00, 0x1B,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1C, 0x01, 0xE7, 0x00, 0x1C, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x3B,
  0x80, 0x06, 0x38, 0x01, 0xC7, 0x80, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x38, 0x07, 0xF1, 0xC0, 0x03, 0xCE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x1E, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x38, 0x70, 0x01, 0xC6,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x0E, 0x60, 0x00, 0xE7, 0x00, 0x0C, 0x38, 0x01, 0xC3, 0xC0, 0x78,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x38, 0x0F, 0xF1,
  0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x01,
  0xE7, 0x00, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0x80, 0xF0, 0x38,
  0x01, 0xC3, 0x80, 0x07, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xCE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0x80, 0x00,
  0xEE, 0x00, 0x06, 0x38, 0x00, 0x70, 0xF0, 0x0F, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B,
  0x80, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x67,
  0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x38, 0x30, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0xC0,
  0x07, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00,
  0x1C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1B,
  0x00, 0xB0, 0x0D, 0x80, 0xD8, 0x0E, 0xC0, 0x64, 0x07, 0x60, 0x33, 0x03,
  0x30, 0x19, 0x81, 0x9C, 0x0C, 0xC0, 0xCE, 0x06, 0x60, 0x67, 0x02, 0x30,
  0x31, 0x83, 0x18, 0x18, 0xC1, 0x8C, 0x1C, 0x60, 0xC3, 0x0E, 0x30, 0x61,
  0x86, 0x18, 0x30, 0xC3, 0x0E, 0x10, 0x61, 0x87, 0x08, 0x30, 0xC3, 0x8C,
  0x18, 0x60, 0xC6, 0x0C, 0x30, 0x63, 0x02, 0x18, 0x31, 0x81, 0x9C, 0x18,
  0xC0, 0xCC, 0x0C, 0x40, 0x66, 0x07, 0x20, 0x33, 0x03, 0xB0, 0x19, 0x81,
  0xD8, 0x0C, 0xC0, 0x6C, 0x02, 0x60, 0x36, 0x01, 0xB0, 0x1A, 0x00, 0xF8,
  0x0D, 0x00, 0x78, 0x06, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0x80, 0x01, 0x83,
  0x80, 0x01, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xC7, 0x00, 0x01, 0xC3, 0x00, 0x01, 0x83,
  0x80, 0x03, 0x81, 0x80, 0x03, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x70, 0x1C,
  0x00, 0x30, 0x06, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00,
  0x70, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x07, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x39, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00, 0x39, 0x80, 0x03,
  0x1C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x38, 0x01, 0x83, 0x00, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x0E, 0x03, 0xC1, 0xC0, 0x0E, 0x38, 0x00, 0x63, 0x00, 0x07, 0x70,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3C, 0x00, 0x37, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x0B, 0x3C, 0x03, 0xB1, 0xFF,
  0xF3, 0x0F, 0xFC, 0x30, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x7F, 0xC3, 0x9F, 0xFC, 0x76, 0x03, 0xCF, 0x80, 0x1D, 0xE0,
  0x01, 0xBC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x06, 0xF8, 0x01, 0xDD, 0x80,
  0x73, 0x9F, 0xFC, 0x71, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1C,
  0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x66, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x3C, 0x07, 0x81, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0xFF, 0x0C, 0x7F, 0xF9, 0x9E, 0x03, 0xB3, 0x80, 0x16, 0xE0, 0x03, 0xD8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xD8, 0x00, 0x3B, 0x80, 0x0F, 0x38, 0x01, 0x67, 0x80, 0xEC, 0x7F,
  0xF9, 0x83, 0xFC, 0x30, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xF0, 0x1E, 0x1C,
  0x00, 0xE7, 0x00, 0x1C, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x01, 0xDC, 0x00, 0x31, 0xC0,
  0x0E, 0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x63, 0xFF, 0xCC, 0xF0, 0x1D,
  0x9C, 0x00, 0xB7, 0x00, 0x1E, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x16, 0x70, 0x06, 0xC7, 0x83, 0x98,
  0x7F, 0xE3, 0x03, 0xF0, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x7F, 0xC3, 0x9F, 0xFC, 0x76, 0x03, 0xCF,
  0x80, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x30, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3F, 0x0F, 0xFF, 0x07, 0xFC,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x07, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x38,
  0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x38,
  0x0C, 0x07, 0x00, 0xC0, 0x70, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0C, 0x07,
  0x00, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xC0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0,
  0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC,
  0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xC7, 0xE3, 0x7F, 0x9F,
  0xCF, 0x0E, 0x83, 0xB8, 0x1E, 0x06, 0xE0, 0x70, 0x1B, 0x01, 0xC0, 0x7C,
  0x03, 0x01, 0xF0, 0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03,
  0x01, 0xF0, 0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01,
  0xF0, 0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01, 0xF0,
  0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01, 0xF0, 0x0C,
  0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01, 0xC0, 0xE3, 0xFE,
  0x1C, 0xFF, 0xE3, 0xB0, 0x1E, 0x7C, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x1E, 0x1C, 0x00,
  0xE7, 0x00, 0x0C, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x31, 0xC0, 0x0E,
  0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xE3, 0xFE, 0x1C, 0xFF,
  0xE3, 0xB0, 0x1E, 0x7C, 0x00, 0xEF, 0x00, 0x0D, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x37, 0xC0, 0x0E, 0xEC, 0x03, 0x9C, 0xFF, 0xE3, 0x8F, 0xF8,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF8,
  0x63, 0xFF, 0xCC, 0xF0, 0x1D, 0x9C, 0x00, 0xB7, 0x00, 0x1E, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0E,
  0xC0, 0x01, 0xDC, 0x00, 0x79, 0xC0, 0x0B, 0x3C, 0x07, 0x63, 0xFF, 0xCC,
  0x1F, 0xE1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0xE3, 0xFE, 0x1C, 0xFF, 0xE3, 0xB0, 0x1E, 0x7C, 0x00, 0xEF, 0x00, 0x1D,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x38, 0x03,
  0xC7, 0x00, 0x0E, 0x60, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x67, 0x00, 0x0E, 0x78, 0x01, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x71, 0xC0, 0x0E, 0x3C,
  0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x66, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x70, 0x00, 0x30, 0xC0, 0x01, 0xC3,
  0x00, 0x06, 0x0E, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0xC0,
  0x0C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x38, 0x06, 0x00, 0x60, 0x38,
  0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x01, 0xB0, 0x0E, 0x01, 0xD8, 0x07, 0x00, 0xEC, 0x03, 0xC0, 0x67, 0x01,
  0x60, 0x33, 0x81, 0xB0, 0x18, 0xC0, 0xC8, 0x0C, 0x60, 0x64, 0x0E, 0x30,
  0x33, 0x07, 0x18, 0x11, 0x83, 0x0E, 0x18, 0xC1, 0x87, 0x0C, 0x60, 0xC1,
  0x86, 0x10, 0x60, 0xC3, 0x0C, 0x70, 0x61, 0x86, 0x30, 0x31, 0x83, 0x18,
  0x1C, 0xC1, 0x8C, 0x0E, 0x60, 0xC6, 0x03, 0x30, 0x33, 0x01, 0x98, 0x1B,
  0x80, 0xC8, 0x0D, 0x80, 0x6C, 0x06, 0xC0, 0x36, 0x03, 0x60, 0x1F, 0x01,
  0xB0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x00, 0x39, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x38, 0x1C, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0x60, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x86, 0x00,
  0x06, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x37, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x38,
  0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x01, 0x80, 0x70, 0x07, 0x01,
  0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xEE, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00,
  0x0C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x06, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x06,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x87,
  0x00, 0x06, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x19, 0xFC, 0x00, 0xDC,
  0x70, 0x07, 0xC1, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x70,
  0xF8, 0x01, 0xFE, 0xC0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 6, 36, 29, 12, -36 },
  { 28, 13, 15, 29, 8, -36 },
  { 53, 26, 36, 29, 2, -36 },
  { 170, 21, 50, 29, 4, -43 },
  { 302, 27, 36, 29, 1, -36 },
  { 424, 24, 36, 29, 3, -36 },
  { 532, 3, 15, 29, 13, -36 },
  { 538, 14, 47, 29, 10, -41 },
  { 621, 13, 47, 29, 6, -41 },
  { 698, 25, 25, 29, 2, -30 },
  { 777, 22, 23, 29, 4, -28 },
  { 841, 8, 15, 29, 9, -7 },
  { 856, 16, 2, 29, 7, -17 },
  { 860, 7, 7, 29, 11, -7 },
  { 867, 20, 46, 29, 5, -41 },
  { 982, 20, 36, 29, 5, -36 },
  { 1072, 21, 36, 29, 5, -36 },
  { 1167, 22, 36, 29, 4, -36 },
  { 1266, 20, 36, 29, 4, -36 },
  { 1356, 19, 36, 29, 5, -36 },
  { 1442, 20, 36, 29, 5, -36 },
  { 1532, 21, 36, 29, 4, -36 },
  { 1627, 22, 36, 29, 4, -36 },
  { 1726, 21, 36, 29, 4, -36 },
  { 1821, 21, 36, 29, 4, -36 },
  { 1916, 7, 27, 29, 11, -27 },
  { 1940, 9, 35, 29, 9, -27 },
  { 1980, 21, 24, 29, 4, -28 },
  { 2043, 20, 13, 29, 5, -23 },
  { 2076, 21, 24, 29, 4, -28 },
  { 2139, 17, 36, 29, 8, -36 },
  { 2216, 24, 45, 29, 3, -36 },
  { 2351, 23, 36, 29, 3, -36 },
  { 2455, 20, 36, 29, 5, -36 },
  { 2545, 20, 36, 29, 5, -36 },
  { 2635, 19, 36, 29, 5, -36 },
  { 2721, 19, 36, 29, 6, -36 },
  { 2807, 20, 36, 29, 6, -36 },
  { 2897, 20, 36, 29, 5, -36 },
  { 2987, 19, 36, 29, 5, -36 },
  { 3073, 18, 36, 29, 6, -36 },
  { 3154, 21, 36, 29, 3, -36 },
  { 3249, 21, 36, 29, 5, -36 },
  { 3344, 20, 36, 29, 6, -36 },
  { 3434, 20, 36, 29, 5, -36 },
  { 3524, 19, 36, 29, 5, -36 },
  { 3610, 19, 36, 29, 5, -36 },
  { 3696, 21, 36, 29, 5, -36 },
  { 3791, 20, 45, 29, 5, -36 },
  { 3904, 21, 36, 29, 5, -36 },
  { 3999, 21, 36, 29, 4, -36 },
  { 4094, 23, 36, 29, 3, -36 },
  { 4198, 19, 36, 29, 5, -36 },
  { 4284, 23, 36, 29, 3, -36 },
  { 4388, 25, 36, 29, 2, -36 },
  { 4501, 24, 36, 29, 3, -36 },
  { 4609, 25, 36, 29, 2, -36 },
  { 4722, 21, 36, 29, 4, -36 },
  { 4817, 11, 46, 29, 11, -41 },
  { 4881, 20, 46, 29, 5, -41 },
  { 4996, 11, 46, 29, 8, -41 },
  { 5060, 20, 19, 29, 5, -36 },
  { 5108, 23, 2, 29, 3, 1 },
  { 5114, 8, 6, 29, 10, -38 },
  { 5120, 20, 27, 29, 4, -27 },
  { 5188, 19, 36, 29, 5, -36 },
  { 5274, 20, 27, 29, 5, -27 },
  { 5342, 19, 36, 29, 5, -36 },
  { 5428, 19, 27, 29, 5, -27 },
  { 5493, 23, 36, 29, 3, -36 },
  { 5597, 19, 36, 29, 5, -27 },
  { 5683, 19, 36, 29, 5, -36 },
  { 5769, 21, 37, 29, 5, -37 },
  { 5867, 17, 46, 29, 5, -37 },
  { 5965, 20, 36, 29, 6, -36 },
  { 6055, 24, 36, 29, 2, -36 },
  { 6163, 22, 27, 29, 4, -27 },
  { 6238, 19, 27, 29, 5, -27 },
  { 6303, 19, 27, 29, 5, -27 },
  { 6368, 19, 36, 29, 5, -27 },
  { 6454, 19, 36, 29, 5, -27 },
  { 6540, 19, 27, 29, 6, -27 },
  { 6605, 20, 27, 29, 5, -27 },
  { 6673, 22, 35, 29, 3, -35 },
  { 6770, 19, 27, 29, 5, -27 },
  { 6835, 22, 27, 29, 4, -27 },
  { 6910, 25, 27, 29, 2, -27 },
  { 6995, 22, 27, 29, 4, -27 },
  { 7070, 22, 36, 29, 4, -27 },
  { 7169, 19, 27, 29, 5, -27 },
  { 7234, 20, 46, 29, 5, -41 },
  { 7349, 3, 46, 29, 13, -41 },
  { 7367, 20, 46, 29, 5, -41 },
  { 7482, 21, 9, 29, 4, -22 },
};

const GFXfont JetBrainsMono_Thin49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_THIN49PT7B_H_
