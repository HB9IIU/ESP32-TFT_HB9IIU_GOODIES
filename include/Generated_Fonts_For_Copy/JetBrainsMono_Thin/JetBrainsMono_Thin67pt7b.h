#ifndef _JETBRAINSMONO_THIN67PT7B_H_
#define _JETBRAINSMONO_THIN67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F,
  0x7F, 0x3E, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xF8, 0x71, 0xF8, 0x0F, 0x83, 0x83, 0xE0, 0xF0, 0x1C, 0x0F, 0x07, 0x80,
  0xE0, 0x3C, 0x38, 0x07, 0x01, 0xE3, 0xC0, 0x38, 0x07, 0x1E, 0x01, 0xC0,
  0x3C, 0xE0, 0x0E, 0x01, 0xE7, 0x00, 0x70, 0x0F, 0x38, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0xE3, 0x80, 0x00, 0x1F, 0xDC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0E, 0xFE, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x80, 0x3B, 0x80, 0x1C, 0x01, 0xFC, 0x00, 0xE0, 0x0E, 0xE0, 0x07,
  0x00, 0x77, 0x80, 0x38, 0x03, 0xBC, 0x01, 0xC0, 0x3C, 0xF0, 0x0E, 0x01,
  0xC7, 0xC0, 0x70, 0x1E, 0x1F, 0x03, 0x81, 0xE0, 0x7E, 0x1C, 0x3E, 0x01,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1C,
  0x3F, 0xF8, 0x00, 0x00, 0xE1, 0xFF, 0xF0, 0x00, 0x07, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x38, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1C,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x38,
  0x00, 0x07, 0xFF, 0xC1, 0xC0, 0x00, 0x0F, 0xFE, 0x0E, 0x00, 0x00, 0x0F,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0x00, 0x01, 0xC1, 0xFF,
  0xC0, 0x00, 0x0E, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x78, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x07, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x03, 0xC3, 0x80, 0x00,
  0x3F, 0x7E, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0x3C, 0x70,
  0x03, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0x07, 0x8F, 0x00, 0x1E, 0x01, 0xC3,
  0xC0, 0x03, 0xC0, 0xF0, 0xF0, 0x00, 0x78, 0x38, 0x3C, 0x00, 0x1E, 0x1E,
  0x0F, 0x00, 0x03, 0xC7, 0x03, 0xC0, 0x00, 0x7B, 0xC0, 0xF0, 0x00, 0x0F,
  0xE0, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0xFF, 0x01, 0xC0, 0x00, 0x79, 0xE0, 0x78, 0x00, 0x3C, 0x38, 0x0F,
  0x00, 0x1F, 0x07, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x7E, 0x1F, 0x80, 0x3C,
  0x0F, 0xFF, 0xC0, 0x07, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x1E, 0x00, 0x05, 0xC0, 0x07, 0x80, 0x0F, 0xFE, 0x01,
  0xE0, 0x1F, 0xFF, 0xF0, 0x38, 0x1F, 0xF3, 0xFF, 0x0C, 0x3F, 0xF0, 0x1F,
  0xF3, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xF8,
  0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF,
  0x01, 0xF8, 0x0F, 0xF0, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF7, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x0E,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x7C, 0x03, 0x80, 0x07, 0xC0, 0x1C, 0x00,
  0x3C, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x08, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x01,
  0xC3, 0xFF, 0xE0, 0x39, 0xFF, 0xFE, 0x07, 0x7C, 0x07, 0xE0, 0xEE, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE3, 0xFF, 0x80, 0x07, 0x7F, 0xFF, 0x00, 0x77, 0xFF, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xB8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x7C, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0xF1, 0xF7, 0x00, 0x3F, 0xFF, 0x78, 0x00, 0xFF, 0xE3, 0x80,
  0x00, 0x20, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x04, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F,
  0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x87, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F,
  0xC0, 0xC0, 0x03, 0x00, 0xFE, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF1, 0xFF, 0x1F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0x7F, 0x80, 0x1E, 0x01, 0xFF, 0xC0, 0x1E, 0x00,
  0x3F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0, 0x07, 0x00, 0x07, 0xF8, 0x07, 0x80,
  0x03, 0xFC, 0x03, 0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xF0,
  0x00, 0x7F, 0x80, 0x78, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x1F, 0xE0, 0x1E,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x03, 0xFC, 0x03,
  0xC0, 0x01, 0xFE, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x78, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x0F, 0xF0,
  0x07, 0x80, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0xFF, 0x00, 0x0F, 0xFE, 0x7B, 0x80, 0x03, 0xFC, 0x3D,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x1F, 0xE0, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x01, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0x87, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0,
  0x0F, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF3, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x01, 0xF0, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x87,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0xC0, 0x00, 0x37, 0xEE, 0x00, 0x07, 0x7E, 0xE0, 0x00,
  0x77, 0xE7, 0x00, 0x06, 0x7E, 0x70, 0x00, 0xE7, 0xE3, 0x00, 0x0E, 0x7E,
  0x38, 0x00, 0xC7, 0xE3, 0x80, 0x1C, 0x7E, 0x18, 0x01, 0xC7, 0xE1, 0xC0,
  0x18, 0x7E, 0x1C, 0x03, 0x87, 0xE0, 0xC0, 0x38, 0x7E, 0x0E, 0x03, 0x07,
  0xE0, 0xE0, 0x70, 0x7E, 0x07, 0x06, 0x07, 0xE0, 0x70, 0xE0, 0x7E, 0x03,
  0x0E, 0x07, 0xE0, 0x38, 0xC0, 0x7E, 0x03, 0x9C, 0x07, 0xE0, 0x19, 0xC0,
  0x7E, 0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xEE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x60, 0x00, 0x1F, 0xDC, 0x00, 0x07, 0xF7, 0x00,
  0x01, 0xFC, 0xE0, 0x00, 0x7F, 0x38, 0x00, 0x1F, 0xCE, 0x00, 0x07, 0xF1,
  0xC0, 0x01, 0xFC, 0x70, 0x00, 0x7F, 0x0E, 0x00, 0x1F, 0xC3, 0x80, 0x07,
  0xF0, 0xE0, 0x01, 0xFC, 0x1C, 0x00, 0x7F, 0x07, 0x00, 0x1F, 0xC0, 0xE0,
  0x07, 0xF0, 0x38, 0x01, 0xFC, 0x0E, 0x00, 0x7F, 0x01, 0xC0, 0x1F, 0xC0,
  0x70, 0x07, 0xF0, 0x0E, 0x01, 0xFC, 0x03, 0x80, 0x7F, 0x00, 0xE0, 0x1F,
  0xC0, 0x1C, 0x07, 0xF0, 0x07, 0x01, 0xFC, 0x00, 0xE0, 0x7F, 0x00, 0x38,
  0x1F, 0xC0, 0x0E, 0x07, 0xF0, 0x01, 0xC1, 0xFC, 0x00, 0x70, 0x7F, 0x00,
  0x0E, 0x1F, 0xC0, 0x03, 0x87, 0xF0, 0x00, 0xE1, 0xFC, 0x00, 0x1C, 0x7F,
  0x00, 0x07, 0x1F, 0xC0, 0x01, 0xE7, 0xF0, 0x00, 0x39, 0xFC, 0x00, 0x0E,
  0x7F, 0x00, 0x01, 0xDF, 0xC0, 0x00, 0x77, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xC7,
  0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x71, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x83, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x7F,
  0x0F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE, 0x01, 0xF0, 0x03,
  0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0x7F,
  0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xE0, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xF3, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE0, 0x7E,
  0x00, 0x3E, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x05, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x07,
  0xC0, 0x0F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x3B, 0x80,
  0x07, 0xC0, 0x07, 0x70, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x1D,
  0xC0, 0x07, 0x60, 0x03, 0xBC, 0x00, 0xEC, 0x00, 0x73, 0x80, 0x1D, 0x80,
  0x0E, 0x70, 0x03, 0x38, 0x03, 0x8E, 0x00, 0x67, 0x00, 0x71, 0xC0, 0x0C,
  0xE0, 0x0E, 0x38, 0x01, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x38, 0xE0,
  0x0E, 0x30, 0x07, 0x1E, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x30, 0xE0, 0x1C,
  0x38, 0x06, 0x1C, 0x07, 0x07, 0x00, 0xC3, 0x80, 0xE0, 0xE0, 0x18, 0x70,
  0x1C, 0x1C, 0x07, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x70, 0x70, 0x1C,
  0x18, 0x0E, 0x0F, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x06, 0x03, 0x81, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x18, 0x38,
  0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0xE0, 0x38, 0x30, 0x0C,
  0x1C, 0x07, 0x86, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x38, 0x70, 0x0E, 0x18,
  0x07, 0x0C, 0x01, 0xC7, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0C, 0x70, 0x07,
  0x18, 0x01, 0x8E, 0x00, 0xE3, 0x00, 0x31, 0xC0, 0x1C, 0x60, 0x07, 0x38,
  0x03, 0xCC, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x03,
  0x9C, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1D, 0x80, 0x06, 0xE0, 0x03, 0xB0,
  0x00, 0xDC, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0x73, 0xE0, 0x00, 0x77, 0x1F, 0x00, 0x0E, 0x70, 0xFF, 0x07,
  0xC7, 0x07, 0xFF, 0xF8, 0x70, 0x1F, 0xFE, 0x07, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x18, 0x00, 0xF0, 0x7F, 0xE0, 0x3C, 0x7F, 0xFE, 0x0F, 0x3F, 0x1F,
  0xC3, 0xDC, 0x00, 0xF8, 0xFE, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xCF, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x7B, 0xF0, 0x00, 0x1E, 0xFE,
  0x00, 0x0F, 0x3D, 0xC0, 0x0F, 0x8F, 0x3E, 0x0F, 0xC3, 0xC7, 0xFF, 0xE0,
  0xF0, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x0F, 0x01, 0xFF,
  0x83, 0xC1, 0xFF, 0xF8, 0xF0, 0xFE, 0x1F, 0x3C, 0x7C, 0x00, 0xEF, 0x3E,
  0x00, 0x1F, 0xCF, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x1F,
  0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7C, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0xC7, 0xC0, 0x0E,
  0xF0, 0xFC, 0x0F, 0xBC, 0x1F, 0xFF, 0x8F, 0x01, 0xFF, 0xC3, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xCF, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0x8F, 0x80, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x87, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F,
  0x87, 0xCF, 0x1F, 0x00, 0x3B, 0xCF, 0x80, 0x07, 0xF3, 0xC0, 0x00, 0xFD,
  0xE0, 0x00, 0x1F, 0x70, 0x00, 0x07, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xF3, 0xE0, 0x01, 0xFC, 0x7C, 0x01, 0xEF, 0x0F, 0xFF, 0xF3,
  0xC1, 0xFF, 0xF8, 0xF0, 0x1F, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x18, 0x00, 0xF0,
  0x7F, 0xE0, 0x3C, 0x7F, 0xFE, 0x0F, 0x3F, 0x1F, 0xC3, 0xDC, 0x00, 0xF8,
  0xFE, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xE0,
  0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01,
  0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x40, 0x02, 0x03, 0x8F, 0xE0, 0x7F, 0x8E, 0x7F, 0xE3, 0xFF, 0x3B,
  0xCF, 0x9E, 0x7E, 0xEC, 0x0F, 0x60, 0x7B, 0xA0, 0x1D, 0x00, 0xEF, 0x00,
  0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E,
  0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80,
  0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07,
  0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC,
  0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00,
  0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E,
  0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80,
  0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07,
  0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC,
  0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x3C, 0x1F, 0xF8, 0x0F, 0x1F, 0xFF, 0x83, 0xCF, 0xC7, 0xF0,
  0xF7, 0x00, 0x3E, 0x3F, 0x80, 0x07, 0xCF, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xCF, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x83, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x3C, 0x1F, 0xF8, 0x0F, 0x1F, 0xFF, 0x83, 0xCF, 0xC7, 0xF0, 0xF7,
  0x00, 0x3E, 0x3F, 0x80, 0x03, 0xCF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3B, 0xE0, 0x00, 0x1E, 0xFC, 0x00, 0x07, 0xBF, 0x80, 0x03,
  0xCF, 0x70, 0x03, 0xE3, 0xCF, 0x83, 0xF0, 0xF1, 0xFF, 0xF8, 0x3C, 0x3F,
  0xFC, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xE0, 0xF0,
  0x7F, 0xFE, 0x3C, 0x3F, 0x87, 0xCF, 0x1F, 0x00, 0x3B, 0xCF, 0x80, 0x07,
  0xF3, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0x1F, 0x70, 0x00, 0x07, 0xDC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x1F, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xF1, 0xF0, 0x03, 0xBC, 0x3F,
  0x03, 0xEF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x38, 0x3F, 0xF8, 0x0E, 0x3F, 0xFF, 0x03, 0x9F, 0x8F,
  0xF0, 0xEF, 0x00, 0x7E, 0x3B, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC1, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x70, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xF7, 0x00, 0x1E, 0x00, 0x39,
  0xC0, 0x07, 0x80, 0x0E, 0x70, 0x01, 0xF0, 0x03, 0x9C, 0x00, 0xEC, 0x00,
  0xE7, 0x80, 0x3B, 0x00, 0x38, 0xE0, 0x0C, 0xC0, 0x1E, 0x38, 0x03, 0x30,
  0x07, 0x0E, 0x00, 0xCE, 0x01, 0xC3, 0x80, 0x73, 0x80, 0x70, 0xE0, 0x1C,
  0x60, 0x1C, 0x3C, 0x07, 0x18, 0x07, 0x07, 0x01, 0x86, 0x03, 0xC1, 0xC0,
  0x61, 0xC0, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x0E, 0x0C, 0x0E, 0x07,
  0x03, 0x83, 0x03, 0x81, 0xE0, 0xC0, 0xC0, 0xE0, 0x38, 0x30, 0x38, 0x78,
  0x0E, 0x0C, 0x0E, 0x1C, 0x03, 0x87, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x61,
  0xC0, 0x38, 0x70, 0x18, 0x70, 0x0F, 0x18, 0x07, 0x1C, 0x01, 0xC6, 0x01,
  0xCF, 0x00, 0x73, 0x80, 0x73, 0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x38,
  0x03, 0x38, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x7B, 0x00, 0x3B, 0x80, 0x0F,
  0xC0, 0x0E, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x79, 0xFF, 0x00, 0x03, 0xDF, 0xFE,
  0x00, 0x1E, 0xF0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x00,
  0x3F, 0x80, 0x3C, 0x01, 0xDC, 0x00, 0xF0, 0x0E, 0xE0, 0x03, 0xC0, 0x77,
  0x00, 0x0F, 0x8F, 0xB8, 0x00, 0x3F, 0xF9, 0xC0, 0x00, 0xFF, 0x8E, 0x00,
  0x00, 0x40, 0x00,
};

const GFXglyph JetBrainsMono_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 8, 49, 40, 16, -49 },
  { 50, 18, 20, 40, 11, -49 },
  { 95, 36, 49, 40, 2, -49 },
  { 316, 29, 67, 40, 6, -58 },
  { 559, 38, 49, 40, 1, -49 },
  { 792, 34, 51, 40, 4, -50 },
  { 1009, 4, 20, 40, 18, -49 },
  { 1019, 19, 64, 40, 14, -56 },
  { 1171, 18, 64, 40, 8, -56 },
  { 1315, 34, 34, 40, 3, -41 },
  { 1460, 30, 31, 40, 5, -38 },
  { 1577, 11, 21, 40, 13, -10 },
  { 1606, 22, 3, 40, 9, -24 },
  { 1615, 10, 10, 40, 15, -9 },
  { 1628, 28, 63, 40, 6, -56 },
  { 1849, 28, 51, 40, 6, -50 },
  { 2028, 29, 49, 40, 7, -49 },
  { 2206, 30, 50, 40, 6, -50 },
  { 2394, 27, 50, 40, 6, -49 },
  { 2563, 26, 49, 40, 7, -49 },
  { 2723, 27, 50, 40, 7, -49 },
  { 2892, 29, 50, 40, 6, -49 },
  { 3074, 29, 49, 40, 6, -49 },
  { 3252, 28, 51, 40, 6, -50 },
  { 3431, 29, 50, 40, 6, -50 },
  { 3613, 10, 39, 40, 15, -38 },
  { 3662, 12, 49, 40, 13, -38 },
  { 3736, 28, 34, 40, 6, -39 },
  { 3855, 28, 18, 40, 6, -31 },
  { 3918, 28, 34, 40, 6, -39 },
  { 4037, 23, 49, 40, 11, -49 },
  { 4178, 33, 62, 40, 4, -50 },
  { 4434, 31, 49, 40, 5, -49 },
  { 4624, 28, 49, 40, 7, -49 },
  { 4796, 27, 51, 40, 7, -50 },
  { 4969, 26, 49, 40, 7, -49 },
  { 5129, 26, 49, 40, 8, -49 },
  { 5289, 27, 49, 40, 8, -49 },
  { 5455, 27, 51, 40, 7, -50 },
  { 5628, 26, 49, 40, 7, -49 },
  { 5788, 24, 49, 40, 8, -49 },
  { 5935, 27, 50, 40, 5, -49 },
  { 6104, 29, 49, 40, 7, -49 },
  { 6282, 27, 49, 40, 8, -49 },
  { 6448, 28, 49, 40, 6, -49 },
  { 6620, 26, 49, 40, 7, -49 },
  { 6780, 26, 51, 40, 7, -50 },
  { 6946, 29, 49, 40, 7, -49 },
  { 7124, 27, 62, 40, 7, -50 },
  { 7334, 29, 49, 40, 7, -49 },
  { 7512, 29, 51, 40, 6, -50 },
  { 7697, 32, 49, 40, 4, -49 },
  { 7893, 26, 50, 40, 7, -49 },
  { 8056, 31, 49, 40, 5, -49 },
  { 8246, 35, 49, 40, 3, -49 },
  { 8461, 33, 49, 40, 4, -49 },
  { 8664, 34, 49, 40, 3, -49 },
  { 8873, 28, 49, 40, 6, -49 },
  { 9045, 15, 63, 40, 15, -56 },
  { 9164, 28, 63, 40, 6, -56 },
  { 9385, 15, 63, 40, 10, -56 },
  { 9504, 27, 26, 40, 7, -49 },
  { 9592, 32, 3, 40, 4, 2 },
  { 9604, 12, 10, 40, 13, -53 },
  { 9619, 28, 39, 40, 5, -38 },
  { 9756, 26, 50, 40, 7, -49 },
  { 9919, 27, 39, 40, 7, -38 },
  { 10051, 26, 50, 40, 7, -49 },
  { 10214, 26, 39, 40, 7, -38 },
  { 10341, 30, 49, 40, 5, -49 },
  { 10525, 26, 50, 40, 7, -38 },
  { 10688, 26, 49, 40, 7, -49 },
  { 10848, 30, 51, 40, 6, -51 },
  { 11040, 24, 63, 40, 6, -51 },
  { 11229, 28, 49, 40, 8, -49 },
  { 11401, 33, 49, 40, 3, -49 },
  { 11604, 30, 38, 40, 5, -38 },
  { 11747, 26, 38, 40, 7, -38 },
  { 11871, 26, 39, 40, 7, -38 },
  { 11998, 26, 50, 40, 7, -38 },
  { 12161, 26, 50, 40, 7, -38 },
  { 12324, 26, 38, 40, 9, -38 },
  { 12448, 28, 39, 40, 6, -38 },
  { 12585, 29, 47, 40, 5, -47 },
  { 12756, 26, 38, 40, 7, -37 },
  { 12880, 30, 37, 40, 5, -37 },
  { 13019, 34, 37, 40, 3, -37 },
  { 13177, 30, 37, 40, 5, -37 },
  { 13316, 30, 49, 40, 5, -37 },
  { 13500, 26, 37, 40, 7, -37 },
  { 13621, 27, 63, 40, 7, -56 },
  { 13834, 4, 63, 40, 18, -56 },
  { 13866, 27, 63, 40, 7, -56 },
  { 14079, 29, 13, 40, 6, -30 },
};

const GFXfont JetBrainsMono_Thin67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_THIN67PT7B_H_
