#ifndef _JETBRAINSMONO_THIN38PT7B_H_
#define _JETBRAINSMONO_THIN38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x10, 0x84, 0x21,
  0x08, 0x40, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x00, 0xC0,
  0x40, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x08, 0x01, 0x01, 0x80, 0x30, 0x18, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03,
  0x01, 0x00, 0x20, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x20, 0x04, 0x06, 0x00, 0x40, 0x60, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x0C, 0x04, 0x00, 0x80, 0xC0, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0x80, 0x80, 0x18, 0x08, 0x03, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x71,
  0x1C, 0x30, 0x86, 0x30, 0x41, 0x98, 0x20, 0xCC, 0x10, 0x66, 0x08, 0x03,
  0x04, 0x01, 0xC2, 0x00, 0x61, 0x00, 0x18, 0x80, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x09, 0xC0, 0x04, 0x70, 0x02, 0x1C, 0x01, 0x06, 0x00,
  0x83, 0x00, 0x40, 0xF0, 0x20, 0x78, 0x10, 0x26, 0x08, 0x33, 0x04, 0x18,
  0xC2, 0x18, 0x3D, 0x78, 0x0F, 0xF8, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x1B, 0xFC, 0x01, 0x98, 0x60,
  0x09, 0x81, 0x80, 0xCC, 0x0C, 0x0C, 0x60, 0x60, 0x43, 0x03, 0x06, 0x18,
  0x18, 0x60, 0xC0, 0xC2, 0x06, 0x06, 0x30, 0x18, 0x63, 0x00, 0x7F, 0x30,
  0x01, 0xE1, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x30, 0x00,
  0xC7, 0xE0, 0x0C, 0x61, 0x80, 0xC6, 0x0C, 0x04, 0x30, 0x20, 0x61, 0x81,
  0x86, 0x0C, 0x0C, 0x20, 0x60, 0x63, 0x03, 0x03, 0x30, 0x18, 0x11, 0x00,
  0xC1, 0x98, 0x03, 0xBD, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0x00,
  0x30, 0x70, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01,
  0xF0, 0x00, 0x77, 0x00, 0x1C, 0x60, 0x1B, 0x06, 0x06, 0x60, 0xE0, 0xD8,
  0x0E, 0x33, 0x00, 0xC6, 0x60, 0x0D, 0x8C, 0x00, 0xF1, 0x80, 0x1C, 0x30,
  0x03, 0x83, 0x00, 0x78, 0x60, 0x19, 0x8E, 0x06, 0x30, 0xF3, 0x83, 0x0F,
  0xE0, 0x30, 0xFF, 0xFF, 0xFF, 0xFB, 0x20, 0x00, 0x40, 0x70, 0x78, 0x38,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x07, 0x00, 0x40, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x38,
  0x30, 0x3F, 0xC2, 0x3F, 0x3F, 0x5F, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0xD0, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x70, 0x60, 0x0C,
  0x06, 0x03, 0x00, 0xE0, 0x20, 0x08, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x71, 0xCE, 0x38,
  0xC3, 0x1C, 0x61, 0x84, 0x30, 0xFF, 0xF0, 0xF7, 0xFF, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xC0,
  0xF3, 0x00, 0x6C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x38, 0x78, 0x70, 0xF1, 0xE1, 0xE1,
  0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0C, 0xE0, 0x38, 0xFF, 0xE0, 0xFF, 0x00,
  0x01, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x70, 0xC0, 0xE0, 0xC0,
  0xC0, 0xC0, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFE,
  0x0E, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFE, 0x7F, 0xFE,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C,
  0x1E, 0x78, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x04, 0xE0, 0x13, 0x00, 0x58, 0x01, 0x60, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x7F, 0xFC, 0xFF, 0xF9, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x1F, 0xC6, 0xF7, 0xCD, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xE0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xE0, 0x0C, 0xE0, 0x30, 0xF3, 0xE0, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x3C, 0x03,
  0x7F, 0x81, 0xE0, 0xE1, 0xC0, 0x18, 0xC0, 0x0E, 0x60, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0x70, 0x06, 0x1C, 0x07, 0x07, 0x9F, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x19, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x1F, 0xFC, 0x38, 0x0E, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x30, 0x06, 0x38, 0x0E, 0x1C, 0x1C, 0x07, 0x70,
  0x03, 0xC0, 0x07, 0x70, 0x1C, 0x38, 0x38, 0x0C, 0x70, 0x06, 0x60, 0x03,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x30, 0x06, 0x1E, 0x3C, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x0E, 0x03,
  0x06, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x80, 0x38,
  0xE0, 0x38, 0x3F, 0xEC, 0x07, 0xCC, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0x80, 0x3E, 0x7C, 0xF9, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38,
  0xE1, 0xC3, 0x06, 0x1C, 0x30, 0x60, 0x83, 0x00, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0xFE, 0x07, 0xFE,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x7E, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x70, 0x0C, 0x1C, 0x00, 0xC3, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0F, 0x01, 0xFD, 0xE0, 0x71, 0xBC,
  0x0C, 0x0F, 0x83, 0x00, 0xF0, 0x60, 0x1E, 0x0C, 0x03, 0xC1, 0x80, 0x78,
  0x30, 0x0F, 0x06, 0x01, 0xE0, 0xC0, 0x3C, 0x18, 0x07, 0x83, 0x00, 0xF0,
  0x30, 0x3E, 0x07, 0x0F, 0xC0, 0x7F, 0x68, 0x07, 0xCD, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x50, 0x00, 0x68, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0C, 0x60,
  0x06, 0x30, 0x02, 0x18, 0x03, 0x04, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x40,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x06, 0x0F, 0xFF, 0x87,
  0xFF, 0xC2, 0x00, 0x63, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x30, 0xFF, 0xC0, 0xFF, 0xF0, 0xC0,
  0x38, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xFF, 0xE0, 0xFF,
  0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF,
  0xF8, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0xC0, 0x73, 0x00, 0x6C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x60, 0x0C, 0xE0, 0x38, 0xF9, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0xC3,
  0x01, 0xC6, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x73, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0xFF, 0xE8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0xF0, 0xC0, 0x73, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x0C, 0xE0, 0x38, 0xF9,
  0xE0, 0x7F, 0x80, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC1,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x0C, 0xE0, 0x38, 0xF3, 0xE0, 0xFF, 0x00, 0xC0,
  0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3,
  0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x38, 0x30, 0x18, 0x18, 0x1C,
  0x0C, 0x0C, 0x07, 0xFE, 0x03, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60,
  0x38, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x70, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xF0, 0x07, 0xD0, 0x05, 0xD8, 0x0D,
  0xD8, 0x09, 0xC8, 0x09, 0xCC, 0x1B, 0xCC, 0x13, 0xC4, 0x13, 0xC6, 0x33,
  0xC2, 0x23, 0xC2, 0x63, 0xC3, 0x63, 0xC1, 0x43, 0xC1, 0xC3, 0xC1, 0x83,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3D, 0x00, 0x7B, 0x00, 0xF2,
  0x01, 0xE6, 0x03, 0xCC, 0x07, 0x88, 0x0F, 0x18, 0x1E, 0x10, 0x3C, 0x30,
  0x78, 0x60, 0xF0, 0x41, 0xE0, 0xC3, 0xC1, 0x87, 0x81, 0x8F, 0x03, 0x1E,
  0x02, 0x3C, 0x06, 0x78, 0x0C, 0xF0, 0x0D, 0xE0, 0x1B, 0xC0, 0x17, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x70, 0x0F, 0xE0, 0x3F, 0xE0, 0xC0, 0x63, 0x00,
  0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x06, 0x60, 0x0C, 0xE0, 0x30, 0xF1, 0xE0, 0x7F, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xC0, 0x63,
  0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x06, 0x60, 0x0C, 0xE0, 0x30, 0xF3, 0xE0, 0x7F, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0xFF, 0xC0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x3C, 0xFF, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0x07, 0xF0, 0x0F, 0xFE,
  0x0E, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x04, 0xC0, 0x06, 0x60,
  0x03, 0x18, 0x03, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06,
  0x60, 0x0C, 0xE0, 0x30, 0xF3, 0xE0, 0x7F, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x60,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x80, 0xE0, 0x70, 0x1C,
  0x0F, 0x02, 0x81, 0xE0, 0x50, 0x3C, 0x0A, 0x07, 0x81, 0x40, 0xF0, 0x6C,
  0x1E, 0x0D, 0x82, 0x41, 0xB0, 0x48, 0x22, 0x19, 0x84, 0x43, 0x30, 0x88,
  0x66, 0x11, 0x0C, 0xC6, 0x31, 0x98, 0xC6, 0x33, 0x18, 0xC4, 0x22, 0x08,
  0x84, 0x41, 0x10, 0xC8, 0x26, 0x19, 0x04, 0xC3, 0x60, 0xD8, 0x6C, 0x1B,
  0x0D, 0x03, 0x61, 0xA0, 0x68, 0x14, 0x05, 0x02, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0x60, 0x00, 0xCC, 0x00, 0x38, 0xC0, 0x06, 0x1C, 0x01,
  0x81, 0x80, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x60, 0x06, 0x08,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x63, 0x00, 0x18, 0x20,
  0x03, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x03, 0x60, 0x00, 0x70, 0xC0, 0x00,
  0x6C, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xFF, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x1A, 0x00, 0x36, 0x00, 0x6C, 0x01,
  0x8C, 0x03, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x70, 0xC0, 0x63, 0x80,
  0xC6, 0x00, 0xDC, 0x01, 0xB0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC1, 0x87, 0x0C, 0x1C, 0x07, 0xF0, 0x1F, 0x7C, 0x38, 0x0C, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xFF,
  0x3F, 0xFF, 0x70, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x60, 0x07, 0x70, 0x0B, 0x3C, 0x7B, 0x1F, 0xE3, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x63,
  0xF0, 0xDE, 0xF9, 0xE0, 0x33, 0x80, 0x37, 0x00, 0x6C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x06, 0xE0, 0x0D, 0xE0, 0x3B, 0x71,
  0xE6, 0x7F, 0x00, 0x0F, 0xE0, 0x7D, 0xF1, 0xC0, 0x73, 0x00, 0x6C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0,
  0x19, 0xC0, 0x71, 0xF7, 0xC0, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x87, 0xE3, 0x3C, 0xF6,
  0xE0, 0x2D, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x60, 0x0E, 0xE0, 0x2C, 0xF1, 0xD8, 0xFE, 0x30,
  0x0F, 0xE0, 0x7D, 0xF1, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x06, 0xC0, 0x19, 0xC0, 0x71,
  0xE3, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0F, 0xC6, 0x79, 0xED, 0xC0, 0x5B, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xB0, 0x07, 0x70, 0x16,
  0x70, 0xEC, 0x7F, 0x98, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x7F, 0xE0, 0xFF, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x63, 0xF0,
  0xDE, 0xF9, 0xE0, 0x33, 0x80, 0x37, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x30, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x3F, 0xE1, 0xFE, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0,
  0x30, 0xC0, 0x70, 0xC0, 0xE0, 0xC0, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xC0,
  0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0,
  0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0xDF, 0x3E, 0x79, 0xD3, 0xB8, 0x70, 0xF8, 0x30, 0x3C, 0x18,
  0x1E, 0x0C, 0x0F, 0x06, 0x07, 0x83, 0x03, 0xC1, 0x81, 0xE0, 0xC0, 0xF0,
  0x60, 0x78, 0x30, 0x3C, 0x18, 0x1E, 0x0C, 0x0F, 0x06, 0x07, 0x83, 0x03,
  0xC1, 0x81, 0xE0, 0xC0, 0xF0, 0x60, 0x78, 0x30, 0x3C, 0x18, 0x18, 0xC7,
  0xE1, 0xBD, 0xF3, 0x40, 0x67, 0x00, 0x6E, 0x00, 0xD8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x60, 0x0F, 0xE0, 0x7D, 0xE1, 0xC0, 0x63, 0x00, 0x6C, 0x00,
  0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0C, 0xC0,
  0x19, 0xC0, 0x61, 0xE3, 0xC0, 0xFE, 0x00, 0xC7, 0xE1, 0xBD, 0xF3, 0xC0,
  0x67, 0x00, 0x6E, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x0D, 0xC0, 0x1B, 0xC0, 0x76, 0xE3, 0xCC, 0xFE, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xC6, 0x79, 0xED, 0xC0, 0x5B, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0xC0, 0x1D, 0xC0, 0x59,
  0xE3, 0xB1, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0xCF, 0xE1, 0xB9, 0xE3, 0xC0, 0x67, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x78,
  0xF1, 0x80, 0x36, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3B, 0xC1, 0xE1, 0xFF,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0C, 0xC0, 0x19, 0xC0, 0x61, 0xE7, 0xC0, 0xFE, 0x00, 0xC0,
  0x01, 0xE0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x02, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x21, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x02, 0x60, 0x01,
  0xB0, 0x00, 0xD0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xC0, 0xC0, 0x78, 0x1C,
  0x0F, 0x02, 0x81, 0xE0, 0x50, 0x24, 0x0A, 0x0C, 0xC3, 0x41, 0x98, 0x6C,
  0x33, 0x09, 0x86, 0x61, 0x10, 0x84, 0x22, 0x10, 0x8C, 0x46, 0x19, 0x8C,
  0xC3, 0x31, 0x98, 0x64, 0x33, 0x0C, 0x82, 0x40, 0xB0, 0x48, 0x16, 0x0F,
  0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0xE0, 0x03,
  0xB0, 0x03, 0x8C, 0x01, 0x83, 0x01, 0x81, 0x81, 0xC0, 0x60, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x36, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x07,
  0x0C, 0x01, 0x8C, 0x00, 0x6C, 0x00, 0x38, 0xC0, 0x01, 0xF0, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xE0, 0x38, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0xFC, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x3C, 0x01, 0xBF, 0x80, 0xD0, 0xE0, 0x78, 0x30, 0x3C, 0x0C, 0x16, 0x03,
  0xFB, 0x00, 0xF8,
};

const GFXglyph JetBrainsMono_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 10, 12, 23, 6, -28 },
  { 34, 20, 28, 23, 1, -28 },
  { 104, 17, 38, 23, 3, -33 },
  { 185, 21, 28, 23, 1, -28 },
  { 259, 19, 28, 23, 2, -28 },
  { 326, 3, 12, 23, 10, -28 },
  { 331, 10, 37, 23, 8, -32 },
  { 378, 11, 37, 23, 4, -32 },
  { 429, 19, 19, 23, 2, -23 },
  { 475, 17, 17, 23, 3, -21 },
  { 512, 6, 12, 23, 7, -6 },
  { 521, 12, 1, 23, 5, -13 },
  { 523, 5, 5, 23, 9, -5 },
  { 527, 15, 36, 23, 4, -32 },
  { 595, 15, 28, 23, 4, -28 },
  { 648, 16, 28, 23, 4, -28 },
  { 704, 17, 28, 23, 3, -28 },
  { 764, 16, 28, 23, 3, -28 },
  { 820, 14, 28, 23, 4, -28 },
  { 869, 15, 28, 23, 4, -28 },
  { 922, 17, 28, 23, 3, -28 },
  { 982, 17, 28, 23, 3, -28 },
  { 1042, 16, 28, 23, 3, -28 },
  { 1098, 17, 28, 23, 3, -28 },
  { 1158, 5, 21, 23, 9, -21 },
  { 1172, 7, 27, 23, 7, -21 },
  { 1196, 16, 19, 23, 3, -22 },
  { 1234, 15, 11, 23, 4, -18 },
  { 1255, 16, 19, 23, 3, -22 },
  { 1293, 13, 28, 23, 6, -28 },
  { 1339, 19, 35, 23, 2, -28 },
  { 1423, 17, 28, 23, 3, -28 },
  { 1483, 16, 28, 23, 4, -28 },
  { 1539, 15, 28, 23, 4, -28 },
  { 1592, 15, 28, 23, 4, -28 },
  { 1645, 14, 28, 23, 5, -28 },
  { 1694, 16, 28, 23, 4, -28 },
  { 1750, 15, 28, 23, 4, -28 },
  { 1803, 15, 28, 23, 4, -28 },
  { 1856, 13, 28, 23, 5, -28 },
  { 1902, 15, 28, 23, 3, -28 },
  { 1955, 17, 28, 23, 4, -28 },
  { 2015, 15, 28, 23, 5, -28 },
  { 2068, 16, 28, 23, 3, -28 },
  { 2124, 15, 28, 23, 4, -28 },
  { 2177, 15, 28, 23, 4, -28 },
  { 2230, 16, 28, 23, 4, -28 },
  { 2286, 15, 35, 23, 4, -28 },
  { 2352, 16, 28, 23, 4, -28 },
  { 2408, 17, 28, 23, 3, -28 },
  { 2468, 19, 28, 23, 2, -28 },
  { 2535, 15, 28, 23, 4, -28 },
  { 2588, 17, 28, 23, 3, -28 },
  { 2648, 19, 28, 23, 2, -28 },
  { 2715, 19, 28, 23, 2, -28 },
  { 2782, 19, 28, 23, 2, -28 },
  { 2849, 16, 28, 23, 3, -28 },
  { 2905, 9, 36, 23, 8, -32 },
  { 2946, 15, 36, 23, 4, -32 },
  { 3014, 8, 36, 23, 6, -32 },
  { 3050, 15, 15, 23, 4, -28 },
  { 3079, 19, 2, 23, 2, 1 },
  { 3084, 6, 5, 23, 8, -30 },
  { 3088, 16, 21, 23, 3, -21 },
  { 3130, 15, 28, 23, 4, -28 },
  { 3183, 15, 21, 23, 4, -21 },
  { 3223, 15, 28, 23, 4, -28 },
  { 3276, 15, 21, 23, 4, -21 },
  { 3316, 17, 28, 23, 3, -28 },
  { 3376, 15, 28, 23, 4, -21 },
  { 3429, 15, 28, 23, 4, -28 },
  { 3482, 16, 29, 23, 4, -29 },
  { 3540, 13, 36, 23, 4, -29 },
  { 3599, 16, 28, 23, 4, -28 },
  { 3655, 19, 28, 23, 2, -28 },
  { 3722, 17, 21, 23, 3, -21 },
  { 3767, 15, 21, 23, 4, -21 },
  { 3807, 15, 21, 23, 4, -21 },
  { 3847, 15, 28, 23, 4, -21 },
  { 3900, 15, 28, 23, 4, -21 },
  { 3953, 15, 21, 23, 5, -21 },
  { 3993, 15, 21, 23, 4, -21 },
  { 4033, 16, 27, 23, 3, -27 },
  { 4087, 15, 21, 23, 4, -21 },
  { 4127, 17, 21, 23, 3, -21 },
  { 4172, 19, 21, 23, 2, -21 },
  { 4222, 17, 21, 23, 3, -21 },
  { 4267, 17, 28, 23, 3, -21 },
  { 4327, 15, 21, 23, 4, -21 },
  { 4367, 15, 36, 23, 4, -32 },
  { 4435, 2, 36, 23, 10, -32 },
  { 4444, 15, 36, 23, 4, -32 },
  { 4512, 17, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_Thin38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_THIN38PT7B_H_
