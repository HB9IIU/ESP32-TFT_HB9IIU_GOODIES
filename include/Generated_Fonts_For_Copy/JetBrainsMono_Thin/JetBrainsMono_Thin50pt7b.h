#ifndef _JETBRAINSMONO_THIN50PT7B_H_
#define _JETBRAINSMONO_THIN50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x1D, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x0E, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0xC1, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xC0, 0x60, 0x06, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00,
  0xE0, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00,
  0x18, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x1C, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3E,
  0xDF, 0x01, 0xC3, 0x0E, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x38, 0xC0, 0xC0,
  0xE7, 0x03, 0x01, 0x9C, 0x0C, 0x06, 0x70, 0x30, 0x19, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0C, 0xF8, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x03, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xF8, 0x0C,
  0x07, 0xE0, 0x30, 0x1D, 0x80, 0xC0, 0x77, 0x03, 0x01, 0x9C, 0x0C, 0x0E,
  0x38, 0x30, 0x70, 0x78, 0xC7, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x31, 0xFE,
  0x00, 0x06, 0x3C, 0xF0, 0x00, 0xE7, 0x03, 0x80, 0x0C, 0x60, 0x18, 0x01,
  0x86, 0x01, 0x80, 0x30, 0x60, 0x18, 0x03, 0x06, 0x01, 0x80, 0x60, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x01, 0x83,
  0x00, 0x60, 0x18, 0x70, 0x07, 0x03, 0x86, 0x00, 0x38, 0x70, 0xC0, 0x01,
  0xFE, 0x18, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x87, 0xF8,
  0x00, 0x30, 0xFF, 0xC0, 0x03, 0x1C, 0x0E, 0x00, 0x61, 0x80, 0x60, 0x0C,
  0x18, 0x06, 0x01, 0xC1, 0x80, 0x60, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x70, 0x18, 0x06, 0x06, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x06, 0x18,
  0x01, 0x80, 0x63, 0x80, 0x1C, 0x0E, 0x30, 0x00, 0xC0, 0xC6, 0x00, 0x0F,
  0xFC, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xF1, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x66, 0x03, 0x80, 0x77, 0x00,
  0xE0, 0x73, 0x80, 0x70, 0x31, 0xC0, 0x1C, 0x38, 0xE0, 0x07, 0x18, 0x70,
  0x01, 0x9C, 0x38, 0x00, 0xEC, 0x1C, 0x00, 0x3E, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x07, 0xC1, 0xC0, 0x03, 0xF0, 0x60, 0x03, 0x9C,
  0x38, 0x03, 0x86, 0x0E, 0x07, 0x83, 0x83, 0xFF, 0x80, 0xE0, 0xFF, 0x80,
  0x38, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x66, 0x66,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x0C, 0x00, 0x9E, 0x03, 0x01, 0xEF, 0xF0, 0xC3, 0xFC,
  0xFF, 0x33, 0xFC, 0x07, 0xED, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x78, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x78,
  0x01, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x60, 0x3C, 0x0F, 0x03, 0xC1, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0xE7,
  0x80, 0x1C, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xEE, 0x00, 0x0F,
  0x38, 0x00, 0x78, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x38,
  0x02, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x7C, 0x1F, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x07, 0x18,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x0E,
  0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x37, 0x00, 0x06, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE6, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0F, 0xC0, 0x63, 0xFF,
  0x06, 0x70, 0xF8, 0x6C, 0x03, 0xC7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x07, 0x60, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x80, 0x1C,
  0x3C, 0x03, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x1F, 0x80, 0x1D, 0xFF, 0x80, 0x7E, 0x1F, 0x83,
  0xC0, 0x0E, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE6, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x67, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xE0, 0x1E, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x19, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x38, 0x00,
  0x30, 0x70, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0xF0, 0x03, 0xCF, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF3, 0xC0, 0x07, 0x03, 0x80, 0x78,
  0x07, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x39, 0x80, 0x00,
  0xE6, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xE0,
  0x1E, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x38, 0x38, 0x00, 0x70,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x76, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xE3,
  0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x0F, 0xFF, 0x60, 0x0F, 0xF3, 0x80, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0x0F, 0x07, 0xE3,
  0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xC1,
  0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xE3, 0xE0, 0x1F,
  0xFB, 0xE0, 0x3C, 0x1B, 0xE0, 0x38, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70,
  0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70,
  0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70,
  0x03, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x07, 0xE0, 0x30, 0x07, 0xE0, 0x38,
  0x0F, 0xE0, 0x3C, 0x1B, 0xE0, 0x1F, 0xFB, 0xE0, 0x07, 0xE3, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC3, 0x80, 0x01, 0x83,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x07, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0x9C, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x07, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xC0, 0x1F, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80,
  0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x03, 0xF1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC3, 0xE0, 0x78,
  0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x06,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x70, 0x00, 0x19, 0x80, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE1, 0xC0, 0x0F, 0x07, 0x80, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0E, 0x00, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00,
  0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x78, 0xE0, 0x1F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xC3, 0xE0, 0x78, 0x03, 0x83, 0x80, 0x0E, 0x38,
  0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01,
  0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E,
  0x00, 0x03, 0x70, 0x00, 0x19, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0xE1, 0xC0, 0x0F, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x10, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xE0, 0x07, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x10, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xD8, 0x01, 0xBD, 0x80, 0x1B, 0xDC, 0x01, 0xBC,
  0xC0, 0x33, 0xCC, 0x03, 0x3C, 0x60, 0x63, 0xC6, 0x06, 0x3C, 0x60, 0x63,
  0xC3, 0x0C, 0x3C, 0x30, 0xC3, 0xC3, 0x0C, 0x3C, 0x19, 0x83, 0xC1, 0x98,
  0x3C, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x60, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7E, 0xC0, 0x07, 0xEC, 0x00, 0x7E, 0xE0, 0x07, 0xE6,
  0x00, 0x7E, 0x60, 0x07, 0xE3, 0x00, 0x7E, 0x30, 0x07, 0xE3, 0x80, 0x7E,
  0x18, 0x07, 0xE1, 0x80, 0x7E, 0x0C, 0x07, 0xE0, 0xC0, 0x7E, 0x0E, 0x07,
  0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x30, 0x7E, 0x03, 0x07, 0xE0, 0x38,
  0x7E, 0x01, 0x87, 0xE0, 0x18, 0x7E, 0x00, 0xC7, 0xE0, 0x0C, 0x7E, 0x00,
  0xE7, 0xE0, 0x06, 0x7E, 0x00, 0x67, 0xE0, 0x07, 0x7E, 0x00, 0x37, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x3C, 0x30, 0x00,
  0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80,
  0x1C, 0x1C, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0x78, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x03,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xC3,
  0xE0, 0x78, 0x07, 0x83, 0x00, 0x1C, 0x38, 0x00, 0x71, 0x80, 0x01, 0x9C,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x39,
  0x80, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x00,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x37, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01,
  0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7E, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x19, 0xC0, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00,
  0x01, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xE0, 0x1E,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80,
  0x1C, 0x1E, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C,
  0x00, 0x30, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01,
  0xC1, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x1F,
  0x80, 0x78, 0x07, 0xE0, 0x1E, 0x01, 0xD8, 0x06, 0x80, 0x66, 0x01, 0xB0,
  0x19, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x03,
  0x30, 0x39, 0xC0, 0xCC, 0x0E, 0x70, 0x33, 0x03, 0x8C, 0x0C, 0x60, 0xC3,
  0x02, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60,
  0xC3, 0x86, 0x18, 0x30, 0xE1, 0x86, 0x1C, 0x38, 0x60, 0x87, 0x06, 0x10,
  0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x31, 0x81, 0xCC, 0x0C, 0x60, 0x72, 0x01, 0x18, 0x1C, 0x80, 0x6E,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80,
  0x6C, 0x03, 0x60, 0x1B, 0x00, 0xF0, 0x06, 0xC0, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x30,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC3, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xD8, 0x00, 0x19, 0xC0, 0x03, 0x9C, 0x00, 0x30, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0x60, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00,
  0x0E, 0x70, 0x00, 0x6E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xF3, 0xF0, 0x3C, 0x01, 0xC1, 0x80, 0x06, 0x1C,
  0x00, 0x38, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0x87, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xEE, 0x00,
  0x0F, 0x78, 0x00, 0xF9, 0xE0, 0x1D, 0xC7, 0xFF, 0xCE, 0x1F, 0xF8, 0x70,
  0x04, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x1F, 0xC0, 0xE7, 0xFF, 0x0E, 0xF0, 0xF8, 0xEC, 0x01, 0xCF,
  0x80, 0x0C, 0xF0, 0x00, 0xEF, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6F, 0x00, 0x06, 0xF0,
  0x00, 0xEF, 0x80, 0x1C, 0xEC, 0x03, 0xCE, 0x7F, 0xF8, 0xE3, 0xFE, 0x00,
  0x02, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0x1F, 0x83, 0xC0, 0x1C,
  0x38, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x00, 0x0E, 0x38, 0x01, 0xE1, 0xE0, 0x3C, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x3F, 0x87, 0x0F, 0xFE, 0x71, 0xE0, 0xF7, 0x38, 0x03, 0x77,
  0x00, 0x1F, 0x70, 0x00, 0xF6, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x0F, 0x70,
  0x00, 0xF3, 0x80, 0x1F, 0x3C, 0x03, 0x71, 0xFF, 0xE7, 0x07, 0xFC, 0x70,
  0x04, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x3C,
  0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF8, 0x70, 0xFF, 0xC7, 0x1E, 0x0F, 0x73, 0x80, 0x37,
  0x70, 0x01, 0xF7, 0x00, 0x0F, 0x60, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x76, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x1F, 0x38, 0x03, 0x71,
  0xE0, 0xF7, 0x0F, 0xFC, 0x70, 0x3F, 0x87, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1F, 0xC0,
  0xE3, 0xFF, 0x0E, 0xF0, 0xF8, 0xEC, 0x03, 0xCF, 0x80, 0x1C, 0xF0, 0x00,
  0xEF, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x01, 0xCC, 0x00,
  0x1C, 0x60, 0x01, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0xE0, 0xC0, 0x0E, 0x06,
  0x00, 0x70, 0x30, 0x07, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x80, 0x60, 0x38,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x30,
  0x07, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x39, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0xC7, 0x81, 0xE3, 0x7F, 0x9F, 0xCD, 0x8E, 0x43, 0xB8, 0x1E, 0x07,
  0xE0, 0x78, 0x1F, 0x80, 0xC0, 0x7C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30,
  0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xE1, 0xFC, 0x0E, 0x3F, 0xF0, 0xEF,
  0x0F, 0x8E, 0xC0, 0x3C, 0xF8, 0x01, 0xCF, 0x00, 0x0E, 0xF0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x0F, 0x83,
  0xC0, 0x3C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60,
  0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x40, 0x00, 0xE1, 0xFC, 0x0E, 0x7F, 0xF0, 0xEF, 0x0F,
  0x8E, 0xC0, 0x1C, 0xF8, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0x6E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0xF0, 0x00, 0x6F, 0x00, 0x0E, 0xF8, 0x01, 0xCE, 0xC0, 0x38, 0xE7, 0xFF,
  0x0E, 0x3F, 0xE0, 0xE0, 0x20, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x70, 0xFF, 0xE7, 0x1E, 0x0F, 0x73, 0x80, 0x37,
  0x70, 0x01, 0xF7, 0x00, 0x0F, 0x60, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0xF7,
  0x00, 0x0F, 0x38, 0x01, 0xF1, 0xC0, 0x37, 0x1F, 0xFE, 0x70, 0x7F, 0xC7,
  0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xE1,
  0xFC, 0x0E, 0x7F, 0xF0, 0xEF, 0x0F, 0x8E, 0xC0, 0x3C, 0xF8, 0x01, 0xEF,
  0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xF8, 0x3E, 0x07, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0x66, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x70, 0x00, 0x67,
  0x80, 0x1E, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38,
  0x01, 0xC1, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x70,
  0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x0C,
  0x0C, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x0C, 0x01, 0xD8, 0x03, 0x00, 0x66,
  0x01, 0xE0, 0x19, 0x80, 0x78, 0x06, 0x70, 0x1E, 0x03, 0x9C, 0x06, 0x80,
  0xE3, 0x01, 0x20, 0x30, 0xC0, 0xCC, 0x0C, 0x30, 0x33, 0x03, 0x0C, 0x0C,
  0xC0, 0xC3, 0x83, 0x30, 0x70, 0xE0, 0x84, 0x1C, 0x18, 0x61, 0x86, 0x06,
  0x18, 0x61, 0x81, 0x86, 0x18, 0x60, 0x61, 0x86, 0x18, 0x1C, 0x61, 0x8E,
  0x07, 0x30, 0x33, 0x80, 0xCC, 0x0C, 0xC0, 0x33, 0x03, 0x30, 0x0C, 0xC0,
  0xCC, 0x03, 0x30, 0x33, 0x00, 0xE8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x83,
  0x00, 0x06, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xCC, 0x00, 0x07,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xC0, 0x0C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00,
  0x01, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07,
  0x06, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03,
  0x80, 0x70, 0x06, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0xE0, 0x03, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80,
  0x00, 0xCE, 0x00, 0x03, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x1D,
  0xFF, 0x00, 0x77, 0x0E, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x38, 0x1F, 0x80,
  0x70, 0x6E, 0x01, 0xE3, 0xB8, 0x01, 0xFC, 0xE0, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 6, 37, 30, 12, -37 },
  { 29, 14, 16, 30, 8, -37 },
  { 57, 26, 37, 30, 2, -37 },
  { 178, 22, 51, 30, 4, -44 },
  { 319, 28, 37, 30, 1, -37 },
  { 449, 25, 38, 30, 3, -37 },
  { 568, 4, 16, 30, 13, -37 },
  { 576, 14, 48, 30, 10, -42 },
  { 660, 14, 48, 30, 6, -42 },
  { 744, 26, 26, 30, 2, -31 },
  { 829, 22, 23, 30, 4, -28 },
  { 893, 9, 16, 30, 9, -8 },
  { 911, 16, 3, 30, 7, -18 },
  { 917, 8, 8, 30, 11, -7 },
  { 925, 20, 48, 30, 5, -42 },
  { 1045, 20, 38, 30, 5, -37 },
  { 1140, 22, 37, 30, 5, -37 },
  { 1242, 23, 37, 30, 4, -37 },
  { 1349, 21, 38, 30, 4, -37 },
  { 1449, 19, 36, 30, 5, -36 },
  { 1535, 20, 38, 30, 5, -37 },
  { 1630, 22, 38, 30, 4, -37 },
  { 1735, 22, 37, 30, 4, -37 },
  { 1837, 22, 38, 30, 4, -37 },
  { 1942, 22, 37, 30, 4, -37 },
  { 2044, 8, 29, 30, 11, -28 },
  { 2073, 10, 36, 30, 9, -28 },
  { 2118, 22, 25, 30, 4, -29 },
  { 2187, 20, 13, 30, 5, -23 },
  { 2220, 22, 25, 30, 4, -29 },
  { 2289, 17, 37, 30, 8, -37 },
  { 2368, 24, 46, 30, 3, -37 },
  { 2506, 24, 37, 30, 3, -37 },
  { 2617, 21, 37, 30, 5, -37 },
  { 2715, 21, 38, 30, 5, -37 },
  { 2815, 20, 37, 30, 5, -37 },
  { 2908, 20, 37, 30, 6, -37 },
  { 3001, 20, 37, 30, 6, -37 },
  { 3094, 21, 38, 30, 5, -37 },
  { 3194, 20, 37, 30, 5, -37 },
  { 3287, 18, 37, 30, 6, -37 },
  { 3371, 21, 38, 30, 3, -37 },
  { 3471, 22, 37, 30, 5, -37 },
  { 3573, 20, 37, 30, 6, -37 },
  { 3666, 20, 37, 30, 5, -37 },
  { 3759, 20, 37, 30, 5, -37 },
  { 3852, 20, 38, 30, 5, -37 },
  { 3947, 22, 37, 30, 5, -37 },
  { 4049, 21, 46, 30, 5, -37 },
  { 4170, 22, 37, 30, 5, -37 },
  { 4272, 22, 38, 30, 4, -37 },
  { 4377, 24, 37, 30, 3, -37 },
  { 4488, 20, 38, 30, 5, -37 },
  { 4583, 24, 37, 30, 3, -37 },
  { 4694, 26, 37, 30, 2, -37 },
  { 4815, 24, 37, 30, 3, -37 },
  { 4926, 26, 37, 30, 2, -37 },
  { 5047, 20, 37, 30, 5, -37 },
  { 5140, 11, 48, 30, 11, -42 },
  { 5206, 20, 48, 30, 5, -42 },
  { 5326, 11, 48, 30, 8, -42 },
  { 5392, 20, 20, 30, 5, -37 },
  { 5442, 24, 3, 30, 3, 1 },
  { 5451, 8, 7, 30, 10, -39 },
  { 5458, 21, 29, 30, 4, -28 },
  { 5535, 20, 38, 30, 5, -37 },
  { 5630, 20, 29, 30, 5, -28 },
  { 5703, 20, 38, 30, 5, -37 },
  { 5798, 20, 29, 30, 5, -28 },
  { 5871, 23, 37, 30, 3, -37 },
  { 5978, 20, 37, 30, 5, -28 },
  { 6071, 20, 37, 30, 5, -37 },
  { 6164, 22, 38, 30, 5, -38 },
  { 6269, 18, 47, 30, 5, -38 },
  { 6375, 21, 37, 30, 6, -37 },
  { 6473, 25, 37, 30, 2, -37 },
  { 6589, 22, 28, 30, 4, -28 },
  { 6666, 20, 28, 30, 5, -28 },
  { 6736, 20, 29, 30, 5, -28 },
  { 6809, 20, 37, 30, 5, -28 },
  { 6902, 20, 37, 30, 5, -28 },
  { 6995, 20, 28, 30, 6, -28 },
  { 7065, 20, 29, 30, 5, -28 },
  { 7138, 22, 35, 30, 3, -35 },
  { 7235, 20, 29, 30, 5, -28 },
  { 7308, 22, 28, 30, 4, -28 },
  { 7385, 26, 28, 30, 2, -28 },
  { 7476, 22, 28, 30, 4, -28 },
  { 7553, 22, 37, 30, 4, -28 },
  { 7655, 20, 28, 30, 5, -28 },
  { 7725, 20, 48, 30, 5, -42 },
  { 7845, 2, 48, 30, 14, -42 },
  { 7857, 20, 48, 30, 5, -42 },
  { 7977, 22, 9, 30, 4, -22 },
};

const GFXfont JetBrainsMono_Thin50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_THIN50PT7B_H_
