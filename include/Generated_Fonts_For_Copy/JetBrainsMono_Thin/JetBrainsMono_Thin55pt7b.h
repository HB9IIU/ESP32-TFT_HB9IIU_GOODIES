#ifndef _JETBRAINSMONO_THIN55PT7B_H_
#define _JETBRAINSMONO_THIN55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x82, 0x08, 0x20, 0x00,
  0x00, 0x00, 0x07, 0x3E, 0xFF, 0xFF, 0xFE, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF6, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x03, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7C, 0x63, 0xC1, 0xE0, 0xC3,
  0xC3, 0x81, 0x83, 0xCE, 0x03, 0x03, 0x9C, 0x06, 0x07, 0x38, 0x0C, 0x07,
  0x70, 0x18, 0x0E, 0xE0, 0x30, 0x1D, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x07,
  0x01, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1F,
  0x18, 0x00, 0x1F, 0xB0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0x7C, 0x00, 0x06, 0x3C, 0x00, 0x0C, 0x1C, 0x00, 0x18,
  0x1C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x01, 0x80,
  0xE0, 0x03, 0x00, 0xF0, 0x06, 0x01, 0xF0, 0x0C, 0x07, 0xE0, 0x18, 0x0F,
  0xC0, 0x30, 0x1D, 0xC0, 0x60, 0x7B, 0xC0, 0xC0, 0xE3, 0xC1, 0x83, 0x83,
  0xE3, 0x3E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x3F,
  0xF0, 0x00, 0x38, 0xE0, 0xF0, 0x00, 0x63, 0x80, 0xE0, 0x01, 0x87, 0x00,
  0xC0, 0x07, 0x0C, 0x01, 0xC0, 0x1C, 0x18, 0x03, 0x80, 0x30, 0x30, 0x07,
  0x00, 0xE0, 0x60, 0x0E, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x01, 0x80, 0x38,
  0x18, 0x03, 0x00, 0x70, 0x70, 0x06, 0x00, 0xE1, 0xC0, 0x0E, 0x01, 0x83,
  0x00, 0x0E, 0x07, 0x0E, 0x00, 0x1F, 0x3C, 0x38, 0x00, 0x1F, 0xF0, 0x60,
  0x00, 0x0F, 0xC1, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xF0,
  0x00, 0x06, 0x1F, 0xF8, 0x00, 0x1C, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x30,
  0x00, 0xC1, 0x80, 0x70, 0x03, 0x07, 0x00, 0x60, 0x0E, 0x0E, 0x00, 0xC0,
  0x38, 0x1C, 0x01, 0x80, 0x60, 0x38, 0x03, 0x01, 0xC0, 0x70, 0x06, 0x07,
  0x00, 0xE0, 0x0C, 0x0C, 0x01, 0xC0, 0x18, 0x30, 0x03, 0x80, 0x30, 0xE0,
  0x03, 0x00, 0xE1, 0x80, 0x07, 0x01, 0x86, 0x00, 0x0F, 0x07, 0x1C, 0x00,
  0x0F, 0xFC, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38,
  0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0xB8, 0x0E, 0x00, 0x67,
  0x00, 0xE0, 0x1C, 0xC0, 0x1E, 0x03, 0x18, 0x01, 0xC0, 0xE3, 0x00, 0x1C,
  0x38, 0x60, 0x01, 0xC7, 0x0C, 0x00, 0x3D, 0xC1, 0x80, 0x03, 0xB8, 0x30,
  0x00, 0x3E, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x18, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xF0, 0x70, 0x00, 0xE7, 0x0E, 0x00, 0x3C, 0xE0, 0xE0,
  0x0F, 0x0E, 0x1F, 0x07, 0xC0, 0xE1, 0xFF, 0xF0, 0x0E, 0x0F, 0xF8, 0x00,
  0xE0, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x01, 0x9F, 0x01, 0xC0, 0x7D, 0xFF, 0x0E,
  0x1F, 0xF1, 0xFE, 0x33, 0xFC, 0x03, 0xFD, 0x7F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC3,
  0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x1F, 0x1F, 0xCF, 0xEF, 0xFB, 0xF9, 0xFC, 0x7C, 0x08, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xE0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x08, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0xC0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x8E, 0x00, 0x1F, 0x0E,
  0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x40, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1E, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9E, 0x00,
  0x1E, 0x3C, 0x00, 0xF0, 0x78, 0x0F, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x3F, 0xE0,
  0x39, 0xFF, 0xF0, 0x77, 0x83, 0xF0, 0xEC, 0x01, 0xF1, 0xF0, 0x00, 0xE3,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x30, 0x00,
  0x0E, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0xC0, 0x07, 0x03, 0xE0, 0x3C, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x7F, 0x80, 0x33, 0xFF, 0xC0, 0xFE, 0x0F, 0xC1, 0xF0, 0x07,
  0xC7, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0xC0,
  0x07, 0x83, 0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xF8, 0x0F,
  0x81, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x67,
  0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x0E,
  0x00, 0xF0, 0x0F, 0x03, 0x80, 0x0F, 0x9E, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3D, 0xE0, 0x01, 0xE0, 0xF0, 0x07, 0x00, 0xF0, 0x1C, 0x00,
  0x70, 0x70, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x80, 0x03, 0xC7,
  0x80, 0x0F, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF8,
  0x0F, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00,
  0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0xC0, 0x01, 0xE3,
  0x80, 0x03, 0xC7, 0xC0, 0x1F, 0x07, 0xF1, 0xFE, 0x03, 0xFF, 0xB8, 0x01,
  0xFC, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x3F, 0x9F, 0xCF, 0xEF, 0xFB, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xDF, 0xF7, 0xF3, 0xF8, 0xF8, 0x10,
  0x07, 0x03, 0xF8, 0x7F, 0x1F, 0xF3, 0xFE, 0x3F, 0x87, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x3F, 0xE7,
  0xC0, 0x1F, 0xFD, 0xF0, 0x07, 0x81, 0xFC, 0x03, 0x80, 0x3F, 0x00, 0xE0,
  0x07, 0xC0, 0x30, 0x01, 0xF0, 0x1C, 0x00, 0x7C, 0x07, 0x00, 0x1F, 0x01,
  0xC0, 0x07, 0xC0, 0x70, 0x01, 0xF0, 0x1C, 0x00, 0x7C, 0x07, 0x00, 0x1F,
  0x01, 0xC0, 0x07, 0xC0, 0x70, 0x01, 0xF0, 0x1C, 0x00, 0x7C, 0x07, 0x00,
  0x1F, 0x00, 0xC0, 0x07, 0xC0, 0x38, 0x01, 0xF0, 0x0E, 0x00, 0xFC, 0x03,
  0xC0, 0x7F, 0x00, 0x7F, 0xF7, 0xC0, 0x0F, 0xFD, 0xF8, 0x00, 0xFC, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x06, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xC0, 0x01,
  0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0xFC, 0x38, 0x00, 0x78, 0xE0, 0x00,
  0xF3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0F,
  0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0x80, 0x07, 0x8E,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8,
  0x00, 0x1E, 0xE0, 0x01, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78,
  0x38, 0x00, 0xF1, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xE0, 0x3E,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x38, 0x0F, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x70, 0x00,
  0x7B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x7F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCC, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78, 0x38, 0x00, 0xF1,
  0xC0, 0x01, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xE0, 0x3E, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77,
  0x00, 0x03, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x7C, 0x07, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xB0, 0x00, 0x7F, 0x60, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0xC0, 0x06, 0xFD,
  0x80, 0x0D, 0xFB, 0x80, 0x3B, 0xF3, 0x00, 0x67, 0xE6, 0x00, 0xCF, 0xCE,
  0x03, 0x9F, 0x8C, 0x06, 0x3F, 0x18, 0x0C, 0x7E, 0x18, 0x30, 0xFC, 0x30,
  0x61, 0xF8, 0x70, 0xC3, 0xF0, 0x63, 0x07, 0xE0, 0xC6, 0x0F, 0xC1, 0xDC,
  0x1F, 0x81, 0xB0, 0x3F, 0x03, 0x60, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xF6, 0x00, 0x1F, 0xB0, 0x00, 0xFD, 0xC0,
  0x07, 0xE6, 0x00, 0x3F, 0x38, 0x01, 0xF8, 0xC0, 0x0F, 0xC6, 0x00, 0x7E,
  0x38, 0x03, 0xF0, 0xC0, 0x1F, 0x87, 0x00, 0xFC, 0x18, 0x07, 0xE0, 0xC0,
  0x3F, 0x07, 0x01, 0xF8, 0x18, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0,
  0x18, 0x1F, 0x80, 0xE0, 0xFC, 0x03, 0x07, 0xE0, 0x1C, 0x3F, 0x00, 0xE1,
  0xF8, 0x03, 0x0F, 0xC0, 0x1C, 0x7E, 0x00, 0x63, 0xF0, 0x03, 0x9F, 0x80,
  0x1C, 0xFC, 0x00, 0x67, 0xE0, 0x03, 0xBF, 0x00, 0x0D, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0D, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83,
  0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0xE7,
  0x00, 0x07, 0x1C, 0x00, 0x70, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0x80, 0x1F,
  0xC7, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x00,
  0x1F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x38, 0x00,
  0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x9C,
  0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x03, 0x81, 0xE0, 0x3C, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0x80, 0x1F, 0x87, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3,
  0x80, 0x03, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xF8, 0x0F, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x80,
  0x01, 0xC7, 0x80, 0x07, 0x07, 0xC0, 0x3C, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xDC, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0xC0, 0x0E, 0x0F, 0x01, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x18, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x3F, 0x00, 0x3C, 0x01, 0xD8, 0x01, 0xE0, 0x0C, 0xC0,
  0x1B, 0x00, 0x66, 0x00, 0xD8, 0x03, 0x30, 0x06, 0xC0, 0x19, 0xC0, 0x36,
  0x01, 0xCE, 0x01, 0xB0, 0x0E, 0x70, 0x0C, 0xC0, 0x73, 0x80, 0x66, 0x03,
  0x8C, 0x06, 0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x01, 0x8C, 0x06, 0x18,
  0x0C, 0x60, 0x30, 0xE0, 0x63, 0x01, 0x87, 0x03, 0x1C, 0x1C, 0x38, 0x18,
  0x60, 0xE1, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1,
  0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x70, 0xC1, 0xC3, 0x03,
  0x86, 0x06, 0x38, 0x1C, 0x60, 0x31, 0xC0, 0xE3, 0x01, 0x8E, 0x07, 0x18,
  0x0C, 0x60, 0x18, 0xC0, 0x63, 0x00, 0xC6, 0x03, 0x18, 0x06, 0x30, 0x18,
  0xC0, 0x39, 0x00, 0x66, 0x01, 0xD8, 0x03, 0x30, 0x0E, 0xC0, 0x1B, 0x80,
  0x76, 0x00, 0xDC, 0x03, 0xB0, 0x06, 0xE0, 0x0D, 0x80, 0x36, 0x00, 0x6C,
  0x01, 0xB0, 0x03, 0x40, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06,
  0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xE3, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xFE, 0x07, 0xC0, 0x3C, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00, 0x01,
  0x9C, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x3F, 0x3E, 0x03,
  0xDC, 0x7F, 0xFE, 0x70, 0xFF, 0xE1, 0xC0, 0x18, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x38,
  0xFF, 0xC1, 0xCF, 0xFF, 0x8E, 0xE0, 0x1E, 0x7C, 0x00, 0x73, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x1D, 0xF0, 0x00, 0xEF, 0xC0, 0x0E, 0x77, 0x01,
  0xF3, 0x9F, 0xFE, 0x1C, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0x78, 0x38, 0x00, 0xF1, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0F,
  0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x0F, 0x81, 0xC1, 0xFF, 0x8E, 0x3F, 0xFE, 0x73, 0xC0, 0x3B, 0x9C,
  0x00, 0x7D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x01, 0xF3,
  0x80, 0x0F, 0x9F, 0x01, 0xDC, 0x3F, 0xFC, 0xE0, 0xFF, 0x87, 0x00, 0x40,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7C, 0x03, 0xC3,
  0x80, 0x0E, 0x38, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C,
  0x70, 0x01, 0xC1, 0xE0, 0x3E, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF1, 0xC7,
  0xFF, 0xCE, 0x78, 0x07, 0x73, 0x80, 0x0F, 0xB8, 0x00, 0x3D, 0xC0, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1D, 0x80, 0x01, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0xF9,
  0xE0, 0x1D, 0xC7, 0xFF, 0xCE, 0x0F, 0xFC, 0x70, 0x1F, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x38, 0xFF, 0xC1, 0xCF,
  0xFF, 0x8E, 0xE0, 0x1E, 0x7C, 0x00, 0x73, 0xC0, 0x01, 0xDE, 0x00, 0x0E,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38,
  0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80,
  0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x03, 0xC0, 0x70, 0x73, 0xF8, 0xFF, 0x3B,
  0xFE, 0x7F, 0x9F, 0x07, 0x40, 0xEF, 0x01, 0xA0, 0x77, 0x00, 0xE0, 0x1F,
  0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01,
  0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0,
  0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E,
  0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00,
  0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0,
  0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F,
  0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0E, 0x00, 0x7C, 0x07, 0x1F, 0xF8, 0x39,
  0xFF, 0xF1, 0xDC, 0x03, 0xCF, 0x80, 0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x01,
  0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7C, 0x07, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0x70, 0x01, 0xC1, 0xE0, 0x3C, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x07, 0x1F, 0xF8, 0x39, 0xFF, 0xF1,
  0xDC, 0x03, 0xCF, 0x80, 0x0E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xBE, 0x00, 0x1D, 0xF8, 0x01, 0xCE, 0xE0, 0x3C, 0x73, 0xFF, 0xC3, 0x8F,
  0xFC, 0x1C, 0x02, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF1, 0xC7, 0xFF, 0xCE,
  0x78, 0x07, 0x73, 0x80, 0x0F, 0xB8, 0x00, 0x3D, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x03,
  0xDC, 0x00, 0x3E, 0x70, 0x03, 0xF3, 0xE0, 0x3B, 0x87, 0xFF, 0x9C, 0x1F,
  0xF0, 0xE0, 0x18, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x07, 0x1F, 0xFC, 0x39, 0xFF, 0xF1,
  0xDC, 0x03, 0xCF, 0x80, 0x0F, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xF0,
  0x03, 0xC3, 0x80, 0x03, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0xE0,
  0x07, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06, 0x70, 0x00,
  0x73, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0x60, 0x30, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x7C, 0x01, 0xC0, 0x1F, 0x80, 0x28,
  0x03, 0xF0, 0x0D, 0x80, 0x76, 0x01, 0xB0, 0x0C, 0xC0, 0x36, 0x01, 0x9C,
  0x06, 0xC0, 0x33, 0x80, 0xD8, 0x0E, 0x70, 0x31, 0x81, 0xCE, 0x06, 0x30,
  0x38, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0xC3, 0x83, 0x18, 0x18, 0x70,
  0xE1, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x18, 0x60, 0xC3,
  0x03, 0x0C, 0x18, 0x60, 0x71, 0x83, 0x8C, 0x0E, 0x60, 0x33, 0x81, 0xCC,
  0x06, 0x70, 0x39, 0x80, 0xCE, 0x03, 0x30, 0x19, 0x80, 0x66, 0x03, 0xB0,
  0x0D, 0xC0, 0x76, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x06, 0xFF, 0x80, 0x0F, 0x83, 0x80, 0x1F,
  0x03, 0x80, 0x3C, 0x03, 0x80, 0x78, 0x03, 0x80, 0xF0, 0x03, 0x83, 0xE0,
  0x03, 0xFE, 0xC0, 0x03, 0xF9, 0x80, 0x01, 0xC0,
};

const GFXglyph JetBrainsMono_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 6, 40, 33, 14, -40 },
  { 31, 15, 16, 33, 9, -40 },
  { 61, 29, 40, 33, 2, -40 },
  { 206, 23, 56, 33, 5, -48 },
  { 367, 31, 40, 33, 1, -40 },
  { 522, 27, 42, 33, 4, -41 },
  { 664, 3, 16, 33, 15, -40 },
  { 670, 16, 53, 33, 11, -46 },
  { 776, 16, 53, 33, 6, -46 },
  { 882, 29, 28, 33, 2, -34 },
  { 984, 25, 26, 33, 4, -31 },
  { 1066, 10, 17, 33, 10, -8 },
  { 1088, 17, 2, 33, 8, -19 },
  { 1093, 9, 9, 33, 12, -8 },
  { 1104, 23, 52, 33, 5, -46 },
  { 1254, 23, 42, 33, 5, -41 },
  { 1375, 24, 40, 33, 5, -40 },
  { 1495, 24, 41, 33, 5, -41 },
  { 1618, 22, 41, 33, 5, -40 },
  { 1731, 22, 40, 33, 5, -40 },
  { 1841, 23, 41, 33, 5, -40 },
  { 1959, 23, 41, 33, 5, -40 },
  { 2077, 24, 40, 33, 5, -40 },
  { 2197, 23, 42, 33, 5, -41 },
  { 2318, 23, 41, 33, 5, -41 },
  { 2436, 9, 32, 33, 12, -31 },
  { 2472, 11, 40, 33, 10, -31 },
  { 2527, 23, 28, 33, 5, -32 },
  { 2608, 23, 15, 33, 5, -26 },
  { 2652, 23, 28, 33, 5, -32 },
  { 2733, 19, 40, 33, 9, -40 },
  { 2828, 26, 51, 33, 4, -41 },
  { 2994, 25, 40, 33, 4, -40 },
  { 3119, 22, 40, 33, 6, -40 },
  { 3229, 22, 42, 33, 6, -41 },
  { 3345, 21, 40, 33, 6, -40 },
  { 3450, 21, 40, 33, 7, -40 },
  { 3555, 23, 40, 33, 6, -40 },
  { 3670, 22, 42, 33, 6, -41 },
  { 3786, 21, 40, 33, 6, -40 },
  { 3891, 19, 40, 33, 7, -40 },
  { 3986, 22, 41, 33, 4, -40 },
  { 4099, 24, 40, 33, 6, -40 },
  { 4219, 22, 40, 33, 7, -40 },
  { 4329, 23, 40, 33, 5, -40 },
  { 4444, 21, 40, 33, 6, -40 },
  { 4549, 21, 42, 33, 6, -41 },
  { 4660, 23, 40, 33, 6, -40 },
  { 4775, 22, 51, 33, 6, -41 },
  { 4916, 23, 40, 33, 6, -40 },
  { 5031, 23, 42, 33, 5, -41 },
  { 5152, 27, 40, 33, 3, -40 },
  { 5287, 21, 41, 33, 6, -40 },
  { 5395, 25, 40, 33, 4, -40 },
  { 5520, 29, 40, 33, 2, -40 },
  { 5665, 27, 40, 33, 3, -40 },
  { 5800, 27, 40, 33, 3, -40 },
  { 5935, 23, 40, 33, 5, -40 },
  { 6050, 12, 52, 33, 12, -46 },
  { 6128, 23, 52, 33, 5, -46 },
  { 6278, 12, 52, 33, 9, -46 },
  { 6356, 23, 21, 33, 5, -40 },
  { 6417, 27, 3, 33, 3, 1 },
  { 6428, 9, 8, 33, 11, -43 },
  { 6437, 22, 32, 33, 5, -31 },
  { 6525, 21, 41, 33, 6, -40 },
  { 6633, 22, 32, 33, 6, -31 },
  { 6721, 21, 41, 33, 6, -40 },
  { 6829, 21, 32, 33, 6, -31 },
  { 6913, 25, 40, 33, 4, -40 },
  { 7038, 21, 41, 33, 6, -31 },
  { 7146, 21, 40, 33, 6, -40 },
  { 7251, 24, 42, 33, 5, -42 },
  { 7377, 20, 52, 33, 5, -42 },
  { 7507, 23, 40, 33, 6, -40 },
  { 7622, 27, 40, 33, 3, -40 },
  { 7757, 25, 31, 33, 4, -31 },
  { 7854, 21, 31, 33, 6, -31 },
  { 7936, 21, 32, 33, 6, -31 },
  { 8020, 21, 41, 33, 6, -31 },
  { 8128, 21, 41, 33, 6, -31 },
  { 8236, 21, 31, 33, 7, -31 },
  { 8318, 23, 32, 33, 5, -31 },
  { 8410, 24, 39, 33, 4, -39 },
  { 8527, 21, 31, 33, 6, -30 },
  { 8609, 25, 30, 33, 4, -30 },
  { 8703, 27, 30, 33, 3, -30 },
  { 8805, 25, 30, 33, 4, -30 },
  { 8899, 25, 40, 33, 4, -30 },
  { 9024, 21, 30, 33, 6, -30 },
  { 9103, 23, 52, 33, 5, -46 },
  { 9253, 3, 52, 33, 15, -46 },
  { 9273, 23, 52, 33, 5, -46 },
  { 9423, 23, 10, 33, 5, -24 },
};

const GFXfont JetBrainsMono_Thin55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_THIN55PT7B_H_
