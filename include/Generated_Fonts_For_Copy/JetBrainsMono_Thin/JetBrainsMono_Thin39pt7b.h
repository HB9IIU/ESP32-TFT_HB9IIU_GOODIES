#ifndef _JETBRAINSMONO_THIN39PT7B_H_
#define _JETBRAINSMONO_THIN39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x64, 0x44, 0x44, 0x00,
  0x00, 0xEF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x02, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x02, 0x00,
  0x20, 0x10, 0x3F, 0xFF, 0xF8, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x20, 0x10, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x20, 0x10, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x20, 0x10, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x39, 0x9C,
  0x30, 0xC7, 0x18, 0x61, 0x98, 0x30, 0xCC, 0x18, 0x36, 0x0C, 0x1B, 0x06,
  0x01, 0xC3, 0x00, 0x61, 0x80, 0x38, 0xC0, 0x0E, 0x60, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x06, 0x70, 0x03, 0x1C, 0x01, 0x86, 0x00, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x78, 0x18, 0x3C, 0x0C, 0x1B, 0x06, 0x0D, 0xC3,
  0x0C, 0x71, 0x8E, 0x1E, 0xFE, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x04, 0xFE, 0x00, 0x66,
  0x18, 0x03, 0x10, 0x30, 0x0C, 0xC0, 0xC0, 0x63, 0x03, 0x03, 0x0C, 0x0C,
  0x08, 0x30, 0x30, 0x60, 0xC0, 0xC3, 0x03, 0x03, 0x08, 0x06, 0x0C, 0x60,
  0x1C, 0x63, 0x00, 0x3F, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x43, 0xC0, 0x03, 0x1F, 0xC0, 0x18, 0xC3, 0x00, 0xC6,
  0x06, 0x03, 0x18, 0x18, 0x18, 0x60, 0x60, 0xC1, 0x81, 0x82, 0x06, 0x06,
  0x18, 0x18, 0x18, 0xC0, 0x60, 0x62, 0x00, 0xC1, 0x98, 0x03, 0xDC, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x70, 0xE0, 0x1C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x18,
  0xC0, 0x06, 0x1C, 0x06, 0xC1, 0xC0, 0xD8, 0x18, 0x32, 0x01, 0x8C, 0x40,
  0x19, 0x88, 0x03, 0xE1, 0x00, 0x3C, 0x20, 0x03, 0x06, 0x00, 0x70, 0xC0,
  0x1F, 0x18, 0x07, 0x63, 0x81, 0xC6, 0x3C, 0xF0, 0x63, 0xF8, 0x0E, 0xFF,
  0xFF, 0xFB, 0x6D, 0x80, 0x00, 0x20, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x40, 0x80, 0x1E, 0x01,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x3E, 0x0F, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x2F, 0x06, 0x1F, 0x7E, 0x47,
  0xE1, 0xF5, 0xF0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x19,
  0x80, 0x03, 0x1C, 0x00, 0x70, 0xC0, 0x0E, 0x0E, 0x00, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0x80, 0x10, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x87,
  0x0C, 0x18, 0x60, 0xC1, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xEF,
  0xFE, 0x78, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0x1F, 0xF8, 0x38, 0x3C, 0x70, 0x0C, 0xE0, 0x06,
  0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC3, 0x83, 0xC3, 0xC3, 0xC3, 0x83, 0xC1, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0x30, 0x07, 0x18, 0x07, 0x0C, 0x06, 0x06,
  0x02, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x03, 0xFF, 0x03, 0xC0, 0xE0, 0xC0, 0x1C, 0x60, 0x03, 0x18,
  0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x0C, 0xE0, 0x38, 0xF3, 0xE0, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x67,
  0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x7F, 0xFE, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x41, 0xC0,
  0x4F, 0xF8, 0x58, 0x3C, 0x50, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3E, 0x78, 0x0F, 0xF0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x7F, 0x03, 0x7F, 0xC1, 0xC0, 0x71, 0xC0, 0x1C, 0xC0, 0x06, 0x60, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x06, 0x30, 0x07, 0x1C, 0x07, 0x07, 0x9F, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0xF8, 0x38, 0x1C, 0x60, 0x0E, 0x60, 0x06, 0xC0, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x1C,
  0x1C, 0x30, 0x07, 0xE0, 0x07, 0xC0, 0x0E, 0x70, 0x38, 0x38, 0x70, 0x0C,
  0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x06, 0x70, 0x0E, 0x3E, 0x7C, 0x1F, 0xF0, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0x03, 0x86, 0x00, 0xC7, 0x00, 0x33, 0x00, 0x09, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x3B, 0x80, 0x18, 0xC0, 0x1C, 0x38, 0x3C, 0x0F, 0xF6, 0x01, 0xE6,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xBF, 0xF9, 0xE0, 0x1C, 0x3E, 0x3F, 0x3F, 0x3E, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x1F, 0xE0,
  0xFC, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xF0, 0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0xCE,
  0x03, 0xFF, 0x81, 0xC1, 0xE0, 0x60, 0x38, 0x18, 0x0E, 0x06, 0x03, 0x81,
  0x80, 0xE0, 0x60, 0x38, 0x18, 0x0E, 0x06, 0x03, 0x81, 0x80, 0xE0, 0x60,
  0x38, 0x18, 0x0E, 0x06, 0x03, 0x81, 0xC1, 0xF0, 0x3F, 0xBC, 0x03, 0xC3,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x16, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x23, 0x00,
  0x18, 0xC0, 0x06, 0x10, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C,
  0x08, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x04, 0x01,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xFF,
  0xF0, 0xC0, 0x78, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xC0, 0x7C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x38,
  0x1C, 0x70, 0x0E, 0x60, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x3E, 0x78, 0x0F, 0xF0, 0xFF, 0xE1, 0x81, 0xE3, 0x00, 0x66, 0x00,
  0x6C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x73, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF,
  0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x0C, 0x3E, 0x78, 0x0F, 0xF0, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3E, 0x78, 0x0F,
  0xF0, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C,
  0x18, 0x0C, 0x0C, 0x06, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x60, 0x38, 0x30, 0x0C, 0x18, 0x07, 0x0C, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xA0, 0x0F,
  0xB0, 0x0B, 0xB0, 0x1B, 0x90, 0x1B, 0x98, 0x13, 0x98, 0x33, 0x88, 0x33,
  0x8C, 0x23, 0x84, 0x63, 0x86, 0x63, 0xC6, 0x43, 0xC2, 0xC3, 0xC3, 0x83,
  0xC3, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0xC0, 0x3D,
  0x80, 0x79, 0x00, 0xF3, 0x01, 0xE6, 0x03, 0xC6, 0x07, 0x8C, 0x0F, 0x08,
  0x1E, 0x18, 0x3C, 0x30, 0x78, 0x20, 0xF0, 0x61, 0xE0, 0x43, 0xC0, 0xC7,
  0x81, 0x8F, 0x01, 0x1E, 0x03, 0x3C, 0x06, 0x78, 0x06, 0xF0, 0x0D, 0xE0,
  0x0B, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x70, 0x07, 0xC0, 0x3F,
  0xE0, 0xE0, 0x63, 0x80, 0x66, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x18, 0xC0, 0x71,
  0xF3, 0xC0, 0xFF, 0x00, 0xFF, 0xF8, 0x60, 0x1E, 0x30, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0xE6, 0x03, 0xE3, 0xFF, 0xE1,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x38, 0x18, 0x70, 0x0C,
  0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x30, 0x1C, 0x3E, 0x78,
  0x0F, 0xF0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0xFF, 0xF8, 0x60, 0x3E, 0x30, 0x03, 0x98, 0x00,
  0xEC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x00, 0xD8, 0x00, 0x70, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x86, 0x00,
  0xE3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0xB8, 0x01, 0x8E,
  0x01, 0xC3, 0xE7, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xB0, 0x03, 0x60, 0x0C,
  0x60, 0x38, 0xF9, 0xE0, 0x7F, 0x80, 0xC0, 0x00, 0xF0, 0x00, 0x6E, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x80, 0xE0, 0x3C,
  0x0E, 0x03, 0xC0, 0xE0, 0x2C, 0x0B, 0x02, 0xC0, 0xB0, 0x6C, 0x0B, 0x06,
  0xC0, 0x90, 0x64, 0x19, 0x06, 0x41, 0x90, 0x66, 0x19, 0x06, 0x61, 0x18,
  0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x8C, 0x63, 0x08, 0xC2, 0x30,
  0x8C, 0x23, 0x08, 0xC3, 0x20, 0xCC, 0x32, 0x0C, 0x83, 0x20, 0xC8, 0x32,
  0x0C, 0x83, 0x60, 0x58, 0x36, 0x05, 0x81, 0x40, 0x58, 0x14, 0x05, 0x81,
  0xC0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x60, 0x00, 0xE6, 0x00, 0x18,
  0xC0, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00,
  0x63, 0x00, 0x18, 0x30, 0x03, 0x02, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x19, 0x80, 0x03, 0x70,
  0x00, 0x30, 0xC0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x01, 0x84, 0x00, 0x31, 0x80, 0x03, 0x20, 0x00,
  0x6C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xF0, 0x03, 0x80,
  0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30,
  0x18, 0x30, 0x18, 0x18, 0x30, 0x18, 0x30, 0x1C, 0x70, 0x0C, 0x60, 0x0E,
  0xE0, 0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0x01, 0xE0, 0x0F, 0xF8, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x03,
  0x60, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x0F, 0xFF,
  0x3F, 0xFF, 0x70, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x07, 0x70, 0x0F, 0x3E, 0x7B, 0x1F, 0xF3, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xF0, 0x67,
  0xF8, 0xD8, 0x1D, 0xE0, 0x1B, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xA0, 0x3B, 0x79,
  0xE6, 0x3F, 0x80, 0x07, 0xC0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C, 0x60,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x02, 0xC0,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x3E, 0xF8, 0x0F, 0xF0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC1, 0xF1,
  0x8F, 0xF3, 0x38, 0x36, 0xC0, 0x1D, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xE0, 0x3C,
  0xF1, 0xD8, 0x7F, 0x30, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0x63, 0x80, 0x66,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0xE7, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x3F, 0xCC, 0xE0, 0xDB, 0x00, 0x76, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x60, 0x0E, 0xE0, 0x3C, 0xF1, 0xD8, 0xFF, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0xFF, 0xC1, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0xF0, 0x67, 0xFC, 0xD8, 0x1D, 0xE0, 0x1B,
  0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x3F, 0xF0, 0xFF, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x06,
  0xC0, 0x06, 0x60, 0x06, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x03,
  0x83, 0x01, 0x81, 0x81, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x30, 0x30, 0x18,
  0x0C, 0x0C, 0x07, 0x06, 0x01, 0x83, 0x00, 0x61, 0x80, 0x38, 0xC0, 0x0C,
  0x60, 0x03, 0x30, 0x01, 0xD8, 0x00, 0x70, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x0E, 0x0E, 0x6F, 0xDF, 0xB8, 0x68, 0xF8, 0x38, 0x3C, 0x0C,
  0x1E, 0x06, 0x0F, 0x03, 0x07, 0x81, 0x83, 0xC0, 0xC1, 0xE0, 0x60, 0xF0,
  0x30, 0x78, 0x18, 0x3C, 0x0C, 0x1E, 0x06, 0x0F, 0x03, 0x07, 0x81, 0x83,
  0xC0, 0xC1, 0xE0, 0x60, 0xF0, 0x30, 0x78, 0x18, 0x3C, 0x0C, 0x1E, 0x06,
  0x0C, 0x03, 0xC1, 0x9F, 0xF3, 0x60, 0x77, 0x80, 0x6E, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xE0,
  0x63, 0x80, 0x66, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x31, 0x80, 0xE3, 0xE7, 0x81, 0xFE,
  0x00, 0x03, 0xC1, 0x9F, 0xF3, 0x60, 0x77, 0x80, 0x6E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x80, 0xED, 0xE7, 0x98, 0xFE, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xCC,
  0xE0, 0xDB, 0x00, 0x76, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0xF3, 0xC7, 0x61,
  0xFC, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x03, 0xC1, 0x9F, 0xE3, 0x60, 0xE7, 0x00, 0x6E, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0xF8, 0x70, 0x1C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60,
  0x06, 0x7C, 0x3C, 0x1F, 0xF8, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60,
  0x06, 0xC0, 0x18, 0xC0, 0x71, 0xF7, 0xC0, 0xFF, 0x00, 0xC0, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18,
  0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x83, 0x00, 0x41,
  0x80, 0x30, 0xC0, 0x18, 0xC0, 0x04, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00,
  0x58, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xC0, 0x60, 0x78, 0x1C, 0x0F, 0x03,
  0x81, 0xA0, 0x50, 0x36, 0x0B, 0x06, 0xC1, 0x60, 0x98, 0x64, 0x33, 0x0C,
  0x86, 0x61, 0x10, 0xC4, 0x23, 0x18, 0xC4, 0x63, 0x19, 0x84, 0x43, 0x30,
  0x98, 0x66, 0x13, 0x0C, 0x83, 0x60, 0x90, 0x6C, 0x1E, 0x0D, 0x83, 0xC0,
  0xA0, 0x78, 0x14, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0xE0, 0x03, 0x98, 0x03,
  0x8E, 0x01, 0x83, 0x01, 0x80, 0xC0, 0xC0, 0x70, 0xC0, 0x18, 0xC0, 0x06,
  0x60, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x33, 0x00,
  0x31, 0x80, 0x38, 0x60, 0x18, 0x18, 0x18, 0x0C, 0x1C, 0x03, 0x0C, 0x00,
  0xCC, 0x00, 0x6C, 0x00, 0x18, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x71, 0x80, 0x30, 0x60, 0x18, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xB3, 0x80, 0xF0, 0x60,
  0x78, 0x18, 0x3C, 0x06, 0x1E, 0x01, 0xFB, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 4, 28, 23, 10, -28 },
  { 15, 10, 11, 23, 7, -28 },
  { 29, 21, 28, 23, 1, -28 },
  { 103, 17, 39, 23, 3, -34 },
  { 186, 22, 29, 23, 1, -29 },
  { 266, 19, 29, 23, 3, -29 },
  { 335, 3, 11, 23, 10, -28 },
  { 340, 11, 38, 23, 8, -33 },
  { 393, 11, 38, 23, 4, -33 },
  { 446, 20, 20, 23, 2, -24 },
  { 496, 17, 18, 23, 3, -22 },
  { 535, 7, 12, 23, 7, -6 },
  { 546, 13, 2, 23, 5, -14 },
  { 550, 6, 5, 23, 9, -5 },
  { 554, 16, 36, 23, 4, -32 },
  { 626, 16, 29, 23, 4, -29 },
  { 684, 17, 28, 23, 4, -28 },
  { 744, 18, 29, 23, 3, -29 },
  { 810, 15, 28, 23, 4, -28 },
  { 863, 15, 28, 23, 4, -28 },
  { 916, 16, 28, 23, 4, -28 },
  { 972, 17, 28, 23, 3, -28 },
  { 1032, 17, 28, 23, 3, -28 },
  { 1092, 16, 29, 23, 4, -29 },
  { 1150, 17, 29, 23, 3, -29 },
  { 1212, 6, 22, 23, 9, -22 },
  { 1229, 8, 28, 23, 7, -22 },
  { 1257, 16, 20, 23, 4, -23 },
  { 1297, 16, 10, 23, 4, -18 },
  { 1317, 16, 20, 23, 4, -23 },
  { 1357, 13, 28, 23, 7, -28 },
  { 1403, 18, 36, 23, 3, -29 },
  { 1484, 18, 28, 23, 3, -28 },
  { 1547, 16, 28, 23, 4, -28 },
  { 1603, 16, 29, 23, 4, -29 },
  { 1661, 15, 28, 23, 4, -28 },
  { 1714, 15, 28, 23, 5, -28 },
  { 1767, 16, 28, 23, 4, -28 },
  { 1823, 16, 29, 23, 4, -29 },
  { 1881, 15, 28, 23, 4, -28 },
  { 1934, 14, 29, 23, 5, -29 },
  { 1985, 16, 28, 23, 3, -28 },
  { 2041, 17, 29, 23, 4, -29 },
  { 2103, 15, 28, 23, 5, -28 },
  { 2156, 16, 28, 23, 4, -28 },
  { 2212, 15, 28, 23, 4, -28 },
  { 2265, 15, 29, 23, 4, -29 },
  { 2320, 17, 28, 23, 4, -28 },
  { 2380, 16, 36, 23, 4, -29 },
  { 2452, 17, 28, 23, 4, -28 },
  { 2512, 17, 29, 23, 3, -29 },
  { 2574, 19, 28, 23, 2, -28 },
  { 2641, 15, 28, 23, 4, -28 },
  { 2694, 18, 28, 23, 3, -28 },
  { 2757, 20, 28, 23, 2, -28 },
  { 2827, 19, 28, 23, 2, -28 },
  { 2894, 19, 28, 23, 2, -28 },
  { 2961, 16, 28, 23, 4, -28 },
  { 3017, 8, 36, 23, 9, -32 },
  { 3053, 16, 36, 23, 4, -32 },
  { 3125, 9, 36, 23, 6, -32 },
  { 3166, 16, 15, 23, 4, -28 },
  { 3196, 19, 2, 23, 2, 1 },
  { 3201, 6, 6, 23, 8, -31 },
  { 3206, 16, 22, 23, 3, -22 },
  { 3250, 15, 28, 23, 4, -28 },
  { 3303, 16, 22, 23, 4, -22 },
  { 3347, 15, 28, 23, 4, -28 },
  { 3400, 15, 22, 23, 4, -22 },
  { 3442, 17, 28, 23, 3, -28 },
  { 3502, 15, 29, 23, 4, -22 },
  { 3557, 15, 28, 23, 4, -28 },
  { 3610, 17, 30, 23, 4, -30 },
  { 3674, 14, 37, 23, 4, -30 },
  { 3739, 17, 28, 23, 4, -28 },
  { 3799, 19, 28, 23, 2, -28 },
  { 3866, 17, 22, 23, 3, -22 },
  { 3913, 15, 22, 23, 4, -22 },
  { 3955, 15, 22, 23, 4, -22 },
  { 3997, 15, 29, 23, 4, -22 },
  { 4052, 15, 29, 23, 4, -22 },
  { 4107, 15, 22, 23, 5, -22 },
  { 4149, 16, 22, 23, 4, -22 },
  { 4193, 17, 28, 23, 3, -28 },
  { 4253, 15, 21, 23, 4, -21 },
  { 4293, 17, 21, 23, 3, -21 },
  { 4338, 19, 21, 23, 2, -21 },
  { 4388, 17, 21, 23, 3, -21 },
  { 4433, 17, 28, 23, 3, -21 },
  { 4493, 15, 21, 23, 4, -21 },
  { 4533, 16, 36, 23, 4, -32 },
  { 4605, 2, 36, 23, 11, -32 },
  { 4614, 16, 36, 23, 4, -32 },
  { 4686, 17, 7, 23, 3, -17 },
};

const GFXfont JetBrainsMono_Thin39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_THIN39PT7B_H_
