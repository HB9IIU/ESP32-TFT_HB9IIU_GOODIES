#ifndef _JETBRAINSMONO_THIN32PT7B_H_
#define _JETBRAINSMONO_THIN32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x64, 0x44, 0x44, 0x44, 0x44, 0x00, 0x00, 0xEF,
  0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0x06, 0x83, 0x41, 0x80,
  0x03, 0x02, 0x01, 0x83, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x60, 0x40, 0x30,
  0x21, 0xFF, 0xFE, 0xFF, 0xFF, 0x04, 0x0C, 0x02, 0x04, 0x03, 0x02, 0x01,
  0x81, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x41, 0xFF, 0xFE, 0x18, 0x10,
  0x08, 0x18, 0x04, 0x0C, 0x02, 0x04, 0x03, 0x02, 0x01, 0x81, 0x00, 0x81,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x78, 0x0F, 0xF1, 0xC8,
  0xCC, 0x43, 0x42, 0x1E, 0x10, 0xF0, 0x81, 0x84, 0x06, 0x20, 0x31, 0x00,
  0xE8, 0x03, 0xE0, 0x03, 0xC0, 0x13, 0x00, 0x8C, 0x04, 0x30, 0x20, 0x81,
  0x06, 0x08, 0x30, 0x41, 0xC2, 0x1B, 0x10, 0xDE, 0x9C, 0x3F, 0xC0, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x08, 0x00, 0x5F, 0x80, 0x24, 0x30, 0x13,
  0x04, 0x0C, 0xC1, 0x06, 0x30, 0x41, 0x0C, 0x10, 0x83, 0x04, 0x60, 0xC3,
  0x10, 0x18, 0xC8, 0x03, 0xE6, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x61,
  0x00, 0x33, 0xF0, 0x09, 0x86, 0x04, 0x60, 0x83, 0x10, 0x20, 0x84, 0x08,
  0x41, 0x02, 0x30, 0x40, 0x98, 0x18, 0x64, 0x03, 0x32, 0x00, 0x7C, 0x03,
  0x80, 0x0F, 0xE0, 0x18, 0x70, 0x30, 0x30, 0x30, 0x10, 0x20, 0x18, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x66,
  0x03, 0xC3, 0x06, 0xC1, 0x84, 0xC0, 0xCC, 0xC0, 0x48, 0xC0, 0x78, 0xC0,
  0x30, 0xC0, 0x38, 0xC0, 0x68, 0xC0, 0xEC, 0x71, 0xC6, 0x3F, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0x83, 0xC3, 0x07, 0x03, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x3C,
  0x06, 0x80, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x03, 0x83, 0x87, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x02, 0x04,
  0x07, 0xC2, 0x1E, 0x7D, 0x3E, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x50, 0x00,
  0x6C, 0x00, 0x63, 0x00, 0x70, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x08, 0x08,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x39, 0xCC, 0x67, 0x31, 0x88, 0xC6,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0x00, 0xFF,
  0x1C, 0x1C, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x8E, 0x3C, 0x71, 0xE1, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x18, 0xE3, 0x83, 0xF8,
  0x07, 0x00, 0x34, 0x03, 0x90, 0x1C, 0x40, 0xC1, 0x02, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x0F, 0xFF, 0xC0, 0x07, 0x00, 0xFF, 0x87, 0x07, 0x30, 0x06,
  0xC0, 0x1A, 0x00, 0x28, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3F, 0xFF, 0x7F,
  0xF0, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x07, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x26, 0x03, 0x18, 0x70, 0x7F,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x7F, 0xF2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x4F, 0xE2, 0xC3, 0x98, 0x0C, 0xC0, 0x34, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x06, 0x80, 0x36,
  0x03, 0x18, 0x30, 0x7F, 0x00, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x3E, 0x1F, 0x38, 0xC0,
  0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x07,
  0x80, 0x36, 0x03, 0x1C, 0x30, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0xA0, 0x06, 0x80, 0x1A, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0xFF, 0x0C, 0x1C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x68,
  0x03, 0x60, 0x11, 0x81, 0x86, 0x30, 0x1F, 0x00, 0xF8, 0x1C, 0x71, 0x80,
  0xC8, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01, 0xB0, 0x0D,
  0xC1, 0xC3, 0xF8, 0x07, 0x00, 0xFF, 0x1C, 0x1C, 0xC0, 0x2C, 0x01, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x06, 0xC0, 0x37, 0x03,
  0x1F, 0xF8, 0x3C, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x77, 0xFE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0x39, 0xF7, 0xDF, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0x43, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x18, 0x00, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x06, 0x0F, 0x81,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x1F, 0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00,
  0x68, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x23, 0x83, 0xF7, 0x0E, 0x1E,
  0x18, 0x1C, 0x20, 0x38, 0x40, 0x70, 0x80, 0xE1, 0x01, 0xC2, 0x03, 0x84,
  0x07, 0x0C, 0x0E, 0x18, 0x3C, 0x18, 0xF8, 0x1F, 0x70, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x6C, 0x00, 0x88, 0x01,
  0x10, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x40, 0x20, 0xC0, 0xC1, 0x81, 0x81,
  0x02, 0x02, 0x04, 0x06, 0x1F, 0xFC, 0x30, 0x08, 0x40, 0x19, 0x80, 0x33,
  0x00, 0x64, 0x00, 0x48, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0x84, 0x06, 0x20,
  0x19, 0x00, 0x68, 0x03, 0x40, 0x1A, 0x00, 0xD0, 0x06, 0x80, 0x24, 0x07,
  0x3F, 0xF1, 0xFF, 0x88, 0x06, 0x40, 0x1A, 0x00, 0x50, 0x02, 0x80, 0x1C,
  0x00, 0xA0, 0x05, 0x00, 0x68, 0x06, 0x41, 0xE3, 0xFE, 0x00, 0x07, 0x80,
  0xFF, 0x0C, 0x0C, 0xC0, 0x34, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x34, 0x01, 0xB0, 0x18, 0xE1, 0xC3,
  0xF8, 0xFF, 0x08, 0x1C, 0x80, 0xE8, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x06, 0x80, 0xC8, 0x78, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xEF, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xFD, 0xFF, 0xE8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x07, 0x80, 0xFF, 0x0C, 0x0C, 0xC0, 0x34, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x61, 0xFF,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x34, 0x01, 0xB0,
  0x18, 0xE1, 0xC3, 0xF8, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0E, 0x00, 0x70, 0x06, 0x80, 0x36, 0x03, 0x1C, 0x38, 0x7F,
  0x00, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x00, 0xC8, 0x06, 0x40, 0x62, 0x03,
  0x10, 0x30, 0x81, 0x84, 0x18, 0x3F, 0xC1, 0xFE, 0x08, 0x30, 0x40, 0xC2,
  0x06, 0x10, 0x18, 0x80, 0xC4, 0x03, 0x20, 0x19, 0x00, 0x68, 0x03, 0x40,
  0x0E, 0x00, 0x60, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0xFF, 0xE0, 0xE0, 0x1D, 0x01, 0x68, 0x0B, 0x60, 0xD9,
  0x04, 0xC8, 0x27, 0x23, 0x39, 0x11, 0xCC, 0x8E, 0x2C, 0x71, 0x43, 0x8E,
  0x1C, 0x30, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x20, 0xC0, 0x3C, 0x03, 0xE0, 0x3A,
  0x03, 0xB0, 0x39, 0x03, 0x90, 0x39, 0x83, 0x88, 0x38, 0xC3, 0x84, 0x38,
  0x43, 0x86, 0x38, 0x23, 0x83, 0x38, 0x13, 0x81, 0x38, 0x1B, 0x80, 0xB8,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x07, 0x00, 0xFE, 0x0C, 0x1C, 0xC0,
  0x64, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x34, 0x01, 0x30, 0x18, 0xC1, 0x83, 0xF8, 0xFF, 0xC4, 0x03,
  0x20, 0x0D, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xA0, 0x1D, 0xFF, 0x8F, 0xF0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07,
  0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x64, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x34, 0x01, 0x30, 0x18, 0xE1,
  0x83, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0xFF, 0xC4, 0x07, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x14, 0x01, 0xA0, 0x19, 0xFF, 0x88, 0x30, 0x41, 0x82, 0x06,
  0x10, 0x30, 0x80, 0xC4, 0x06, 0x20, 0x19, 0x00, 0xC8, 0x03, 0x40, 0x1A,
  0x00, 0x60, 0x07, 0x80, 0xFF, 0x1C, 0x0C, 0xC0, 0x34, 0x01, 0xE0, 0x0F,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x01,
  0xB0, 0x0D, 0xC1, 0xC3, 0xF8, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x26, 0x03, 0x1C,
  0x30, 0x7F, 0x00, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00,
  0xC4, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x10, 0x18, 0x30, 0x20, 0x60, 0x40,
  0xC1, 0x80, 0x83, 0x01, 0x84, 0x03, 0x18, 0x02, 0x30, 0x04, 0x40, 0x0C,
  0x80, 0x1B, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0xC1, 0xA0, 0xE0, 0xD0, 0x50, 0x68, 0x28, 0x24, 0x14, 0x12, 0x0B, 0x09,
  0x85, 0x84, 0xC2, 0x42, 0x63, 0x23, 0x31, 0x11, 0x88, 0x88, 0xC4, 0x44,
  0x42, 0x22, 0x21, 0x11, 0x90, 0xC8, 0x48, 0x6C, 0x24, 0x34, 0x16, 0x1A,
  0x0B, 0x05, 0x05, 0x82, 0x82, 0x81, 0x41, 0xC0, 0xA0, 0x60, 0x70, 0x30,
  0xC0, 0x06, 0x60, 0x0C, 0x30, 0x08, 0x30, 0x18, 0x18, 0x10, 0x08, 0x30,
  0x0C, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0xC0, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x20, 0x18, 0x30, 0x18, 0x10,
  0x30, 0x18, 0x20, 0x0C, 0x60, 0x0C, 0x40, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0x40, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x10,
  0x08, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xE0, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0xFF, 0x80, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0xFF, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xFF, 0x80, 0x07, 0x00, 0x38,
  0x01, 0x60, 0x1B, 0x00, 0x8C, 0x0C, 0x60, 0x61, 0x86, 0x0C, 0x30, 0x23,
  0x01, 0x98, 0x0D, 0x80, 0x30, 0xFF, 0xFE, 0xE0, 0xC1, 0x07, 0x0F, 0x81,
  0xFF, 0x1C, 0x0C, 0xC0, 0x24, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x1F,
  0xFB, 0xC0, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x07,
  0x70, 0xD9, 0xFC, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0xF0, 0xBB, 0xCE, 0x06, 0xC0, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x6B,
  0x0C, 0x9F, 0x80, 0x0F, 0x81, 0xFF, 0x1C, 0x0C, 0xC0, 0x24, 0x01, 0xE0,
  0x0F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01,
  0xE0, 0x0D, 0x00, 0x6C, 0x06, 0x38, 0x60, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x87, 0xCC, 0xF7, 0x6C, 0x07, 0x60, 0x3A,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x06, 0x80, 0x36, 0x03, 0x98, 0x2C, 0x7E, 0x60, 0x0F,
  0x81, 0xFF, 0x18, 0x0C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x6C,
  0x06, 0x38, 0x60, 0xFE, 0x00, 0x01, 0xFE, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x0F, 0x19, 0xEE, 0xD8, 0x0E, 0xC0, 0x74, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x34, 0x01, 0xB0, 0x1C,
  0xC1, 0xE7, 0xFB, 0x07, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x7F, 0x83, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0xF0, 0xBB, 0xCE, 0x06, 0xC0, 0x68, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0xCF,
  0xF9, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x0E, 0x00, 0xD0, 0x0C, 0x80, 0x64, 0x06, 0x20, 0x61, 0x03, 0x08, 0x30,
  0x7F, 0x03, 0xF8, 0x10, 0x60, 0x81, 0x84, 0x0C, 0x20, 0x31, 0x00, 0xC8,
  0x06, 0x40, 0x1A, 0x00, 0x60, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x70, 0x00, 0x7F,
  0x80, 0xBC, 0x73, 0xBA, 0xEC, 0x70, 0xA0, 0x83, 0x82, 0x0E, 0x08, 0x38,
  0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E,
  0x08, 0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x30, 0x8F, 0x0B, 0xBC,
  0xE0, 0x6C, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x0F, 0x81, 0xFF, 0x1C, 0x0C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x00,
  0x4C, 0x06, 0x30, 0x60, 0xFE, 0x00, 0x8F, 0x0B, 0xBC, 0xE0, 0x6C, 0x02,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x2C, 0x06, 0xB0, 0xC9, 0xF8, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x99, 0xEE, 0xD8, 0x0E, 0xC0,
  0x74, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x00, 0x6C, 0x07, 0x30, 0x58, 0xFC, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xCF, 0x86, 0xFF,
  0x38, 0x19, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x98, 0x0C, 0x80, 0x3C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x07, 0x00, 0x28, 0x03, 0x70, 0x31, 0xFF, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0E, 0x00,
  0x1F, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xA0,
  0x0D, 0x80, 0x4C, 0x06, 0x38, 0x60, 0xFE, 0x00, 0xC0, 0x06, 0x80, 0x09,
  0x80, 0x31, 0x00, 0x62, 0x00, 0x86, 0x03, 0x04, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x10, 0x60, 0x30, 0x80, 0x63, 0x00, 0x46, 0x00, 0xC8, 0x01, 0xB0,
  0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x81, 0x03, 0x81, 0x82, 0x83, 0x82,
  0xC2, 0x82, 0xC2, 0x86, 0xC2, 0x86, 0x42, 0xC6, 0x46, 0x44, 0x44, 0x44,
  0x64, 0x44, 0x64, 0x4C, 0x64, 0x6C, 0x2C, 0x2C, 0x2C, 0x28, 0x28, 0x28,
  0x38, 0x28, 0x38, 0x28, 0x38, 0x38, 0x60, 0x04, 0x40, 0x18, 0xC0, 0x60,
  0xC0, 0x80, 0x83, 0x01, 0x8C, 0x01, 0x90, 0x01, 0x60, 0x03, 0x80, 0x07,
  0x00, 0x0B, 0x00, 0x32, 0x00, 0xC6, 0x01, 0x06, 0x06, 0x04, 0x18, 0x0C,
  0x60, 0x0D, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x09, 0x80, 0x31, 0x00, 0x63,
  0x00, 0x86, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x08, 0x30, 0x18, 0x40, 0x31,
  0x80, 0x33, 0x00, 0x64, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x1F, 0x80, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x1C, 0x00, 0x3F, 0x07, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x7C, 0x03, 0x00, 0x00, 0x78, 0x0E, 0x70, 0x61, 0x83, 0x06, 0x18,
  0x1F, 0xC0, 0x38,
};

const GFXglyph JetBrainsMono_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 4, 23, 19, 8, -23 },
  { 13, 9, 9, 19, 5, -23 },
  { 24, 17, 23, 19, 1, -23 },
  { 73, 13, 32, 19, 3, -28 },
  { 125, 18, 24, 19, 1, -24 },
  { 179, 16, 24, 19, 2, -24 },
  { 227, 2, 9, 19, 9, -23 },
  { 230, 9, 31, 19, 7, -27 },
  { 265, 9, 31, 19, 4, -27 },
  { 300, 17, 17, 19, 1, -20 },
  { 337, 15, 15, 19, 2, -18 },
  { 366, 5, 10, 19, 6, -5 },
  { 373, 11, 1, 19, 4, -11 },
  { 375, 5, 4, 19, 7, -4 },
  { 378, 13, 31, 19, 3, -27 },
  { 429, 13, 24, 19, 3, -24 },
  { 468, 14, 23, 19, 3, -23 },
  { 509, 14, 24, 19, 3, -24 },
  { 551, 13, 23, 19, 3, -23 },
  { 589, 13, 23, 19, 3, -23 },
  { 627, 13, 23, 19, 3, -23 },
  { 665, 13, 23, 19, 3, -23 },
  { 703, 14, 23, 19, 3, -23 },
  { 744, 13, 24, 19, 3, -24 },
  { 783, 13, 24, 19, 3, -24 },
  { 822, 5, 18, 19, 7, -18 },
  { 834, 6, 23, 19, 6, -18 },
  { 852, 13, 16, 19, 3, -19 },
  { 878, 13, 9, 19, 3, -15 },
  { 893, 13, 16, 19, 3, -19 },
  { 919, 11, 23, 19, 5, -23 },
  { 951, 15, 30, 19, 2, -24 },
  { 1008, 15, 23, 19, 2, -23 },
  { 1052, 13, 23, 19, 4, -23 },
  { 1090, 13, 24, 19, 3, -24 },
  { 1129, 12, 23, 19, 4, -23 },
  { 1164, 12, 23, 19, 4, -23 },
  { 1199, 13, 23, 19, 4, -23 },
  { 1237, 13, 24, 19, 3, -24 },
  { 1276, 12, 23, 19, 4, -23 },
  { 1311, 11, 23, 19, 4, -23 },
  { 1343, 13, 23, 19, 2, -23 },
  { 1381, 13, 23, 19, 4, -23 },
  { 1419, 13, 23, 19, 4, -23 },
  { 1457, 13, 23, 19, 3, -23 },
  { 1495, 12, 23, 19, 4, -23 },
  { 1530, 13, 24, 19, 3, -24 },
  { 1569, 13, 23, 19, 4, -23 },
  { 1607, 13, 30, 19, 3, -24 },
  { 1656, 13, 23, 19, 4, -23 },
  { 1694, 13, 24, 19, 3, -24 },
  { 1733, 15, 23, 19, 2, -23 },
  { 1777, 13, 23, 19, 3, -23 },
  { 1815, 15, 23, 19, 2, -23 },
  { 1859, 17, 23, 19, 1, -23 },
  { 1908, 16, 23, 19, 2, -23 },
  { 1954, 16, 23, 19, 2, -23 },
  { 2000, 13, 23, 19, 3, -23 },
  { 2038, 7, 31, 19, 7, -27 },
  { 2066, 13, 31, 19, 3, -27 },
  { 2117, 7, 31, 19, 5, -27 },
  { 2145, 13, 12, 19, 3, -23 },
  { 2165, 15, 1, 19, 2, 1 },
  { 2167, 6, 4, 19, 6, -25 },
  { 2170, 13, 18, 19, 3, -18 },
  { 2200, 12, 23, 19, 4, -23 },
  { 2235, 13, 18, 19, 3, -18 },
  { 2265, 13, 23, 19, 3, -23 },
  { 2303, 13, 18, 19, 3, -18 },
  { 2333, 15, 23, 19, 2, -23 },
  { 2377, 13, 24, 19, 3, -18 },
  { 2416, 12, 23, 19, 4, -23 },
  { 2451, 14, 24, 19, 3, -24 },
  { 2493, 11, 30, 19, 3, -24 },
  { 2535, 13, 23, 19, 4, -23 },
  { 2573, 15, 23, 19, 2, -23 },
  { 2617, 14, 18, 19, 3, -18 },
  { 2649, 12, 18, 19, 4, -18 },
  { 2676, 13, 18, 19, 3, -18 },
  { 2706, 12, 24, 19, 4, -18 },
  { 2742, 13, 24, 19, 3, -18 },
  { 2781, 13, 18, 19, 4, -18 },
  { 2811, 13, 18, 19, 3, -18 },
  { 2841, 14, 23, 19, 2, -23 },
  { 2882, 13, 18, 19, 3, -18 },
  { 2912, 15, 18, 19, 2, -18 },
  { 2946, 16, 18, 19, 2, -18 },
  { 2982, 15, 18, 19, 2, -18 },
  { 3016, 15, 24, 19, 2, -18 },
  { 3061, 13, 18, 19, 3, -18 },
  { 3091, 13, 31, 19, 3, -27 },
  { 3142, 1, 31, 19, 9, -27 },
  { 3146, 13, 31, 19, 3, -27 },
  { 3197, 13, 6, 19, 3, -14 },
};

const GFXfont JetBrainsMono_Thin32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_THIN32PT7B_H_
