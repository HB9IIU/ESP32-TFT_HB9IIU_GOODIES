#ifndef _JETBRAINSMONO_THIN29PT7B_H_
#define _JETBRAINSMONO_THIN29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDA, 0x49, 0x24, 0x90, 0x03, 0xFE, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC2, 0xC2, 0xC2, 0xC2, 0xC2, 0x02, 0x0C, 0x0C, 0x10, 0x18, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x83, 0x1F, 0xFF, 0x86, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0xC0, 0xC1, 0x81, 0x82, 0x02, 0x04, 0x3F, 0xFF, 0x08, 0x30,
  0x10, 0x60, 0x60, 0x80, 0x81, 0x01, 0x02, 0x02, 0x0C, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x01, 0xFC, 0x19, 0x31, 0x88, 0xCC, 0x42, 0x62,
  0x1B, 0x10, 0x18, 0x80, 0x44, 0x03, 0xA0, 0x0F, 0x00, 0x0F, 0x00, 0x4C,
  0x02, 0x30, 0x10, 0x80, 0x87, 0x04, 0x34, 0x21, 0xA1, 0x0D, 0x88, 0x46,
  0x4E, 0x1F, 0xC0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7C, 0x03,
  0xC6, 0x06, 0x82, 0x04, 0x82, 0x08, 0x82, 0x18, 0x82, 0x10, 0x82, 0x20,
  0xC6, 0x40, 0x7C, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x18, 0x02, 0x7C,
  0x04, 0xC2, 0x08, 0x82, 0x18, 0x82, 0x10, 0x82, 0x20, 0x82, 0x60, 0xC2,
  0x40, 0x46, 0x80, 0x3C, 0x1F, 0x80, 0xC3, 0x02, 0x06, 0x08, 0x08, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xF0, 0x04, 0x40, 0x71,
  0x82, 0x83, 0x1A, 0x06, 0x48, 0x0B, 0x20, 0x18, 0x80, 0x62, 0x01, 0xCC,
  0x09, 0x18, 0xE2, 0x3E, 0x0C, 0xFF, 0xFE, 0x80, 0x03, 0x0E, 0x18, 0x30,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0E, 0x07, 0xE0,
  0x30, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x06, 0x06, 0x1C,
  0x38, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1C,
  0x20, 0xDE, 0x4F, 0x07, 0xF8, 0x01, 0x80, 0x05, 0x00, 0x19, 0x00, 0x63,
  0x00, 0xC3, 0x03, 0x07, 0x04, 0x04, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x77, 0x66, 0xCC, 0xC8, 0x80, 0xFF, 0x80,
  0xEF, 0xFE, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x87, 0x0C, 0xC0, 0x6C,
  0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0xE3, 0x8E, 0x38,
  0x43, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x67,
  0x0C, 0x3F, 0x80, 0x06, 0x01, 0xA0, 0x32, 0x0E, 0x20, 0x82, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x1F,
  0xC1, 0x83, 0x18, 0x0C, 0x80, 0x3C, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x0F, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0x01,
  0xB0, 0x63, 0xF8, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x04, 0x80, 0xB0, 0x1C, 0x03, 0x00, 0x60, 0x0F,
  0xFF, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0xFF, 0xEC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDB, 0xCE, 0x06, 0xC0,
  0x6C, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x02, 0x80, 0x2C, 0x02, 0x40,
  0x66, 0x0C, 0x3F, 0x80, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x37, 0x81, 0x7F, 0x1C, 0x0C, 0xC0, 0x24,
  0x01, 0xA0, 0x0F, 0x00, 0x68, 0x03, 0x40, 0x1B, 0x00, 0x98, 0x0C, 0x70,
  0xC1, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x80, 0x2C, 0x03, 0x60,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x00, 0x3F, 0x86, 0x0C, 0x40, 0x6C, 0x02, 0xC0, 0x3C, 0x02, 0x40,
  0x26, 0x06, 0x30, 0x81, 0xF0, 0x1F, 0x03, 0x18, 0x60, 0x6C, 0x02, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x66, 0x0E, 0x3F, 0x80, 0x1F, 0xC1,
  0x83, 0x18, 0x0C, 0x80, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x68, 0x03, 0x40,
  0x1B, 0x01, 0x8C, 0x1C, 0x3F, 0xC0, 0x66, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0xEF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xEF, 0xFE, 0x77, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x39, 0x8C, 0xC6, 0x31, 0x08, 0x00, 0x00, 0x10, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x70, 0x0C, 0x00, 0x80, 0x00, 0xFE, 0x01, 0xC0, 0x18, 0x02, 0x00, 0x80,
  0x30, 0x08, 0x02, 0x01, 0x80, 0xC3, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0xE0, 0xC0, 0xC6,
  0x01, 0x90, 0x02, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x7B, 0x83, 0x1E,
  0x18, 0x38, 0x60, 0xE1, 0x83, 0x86, 0x0E, 0x18, 0x38, 0x60, 0xE1, 0x83,
  0x86, 0x0E, 0x0C, 0x78, 0x3F, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x38, 0x01, 0x40, 0x0B,
  0x00, 0xC8, 0x06, 0x40, 0x22, 0x01, 0x18, 0x18, 0x40, 0xC2, 0x04, 0x18,
  0x20, 0xC3, 0x02, 0x10, 0x10, 0xFF, 0xCC, 0x06, 0x60, 0x12, 0x00, 0x90,
  0x07, 0x80, 0x1C, 0x00, 0x80, 0xFF, 0x8C, 0x0C, 0xC0, 0x6C, 0x02, 0xC0,
  0x2C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0x6F, 0xFC, 0xFF, 0x8C, 0x06, 0xC0,
  0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x1C, 0xFF,
  0x80, 0x3F, 0x86, 0x0C, 0x40, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x03, 0xC0, 0x3C, 0x02, 0x40, 0x67, 0x0C, 0x1F, 0x80, 0xFF, 0x18, 0x33,
  0x03, 0x60, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0x61,
  0xCF, 0xF0, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x86, 0x0C, 0x40, 0x6C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0x40, 0x67, 0x0C,
  0x1F, 0x80, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0xFF, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xFE,
  0x07, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03,
  0xC0, 0x3C, 0x03, 0x60, 0x67, 0x0C, 0x1F, 0x80, 0xC0, 0x36, 0x01, 0xB0,
  0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x06, 0x18, 0x30, 0xC3, 0x07, 0xF8,
  0x3F, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0x66,
  0x03, 0x30, 0x09, 0x80, 0x6C, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xF0, 0xC0, 0x7C, 0x07, 0xA0, 0x7A, 0x0B, 0xB0, 0xB9, 0x0B,
  0x91, 0x39, 0x93, 0x8B, 0x38, 0xA3, 0x86, 0x38, 0x63, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0xC0,
  0x3C, 0x07, 0x80, 0xF8, 0x1D, 0x03, 0xA0, 0x72, 0x0E, 0x41, 0xCC, 0x38,
  0x87, 0x10, 0xE3, 0x1C, 0x23, 0x86, 0x70, 0x4E, 0x09, 0xC1, 0xB8, 0x17,
  0x03, 0xE0, 0x3C, 0x06, 0x3F, 0x8C, 0x19, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x05, 0x01, 0xB0, 0x61, 0xF8, 0xFF, 0xC6, 0x07,
  0x30, 0x0D, 0x80, 0x2C, 0x01, 0x60, 0x0F, 0x00, 0x58, 0x02, 0xC0, 0x36,
  0x03, 0x3F, 0xF1, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x3F, 0x86, 0x0C, 0x40,
  0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0,
  0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0x40,
  0x67, 0x0C, 0x1F, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0x8C, 0x0E, 0xC0, 0x2C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x06, 0xFF, 0xCC, 0x20, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0,
  0xCC, 0x06, 0xC0, 0x6C, 0x03, 0xC0, 0x30, 0x1F, 0xC1, 0x83, 0x18, 0x0C,
  0xC0, 0x26, 0x01, 0xB0, 0x01, 0x80, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x70, 0x03, 0x40, 0x1A, 0x00,
  0xD8, 0x04, 0x60, 0xE1, 0xFC, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0D, 0x01, 0xB8, 0x61, 0xF8,
  0xC0, 0x0E, 0x00, 0x50, 0x06, 0xC0, 0x26, 0x01, 0x10, 0x18, 0x80, 0xC6,
  0x04, 0x30, 0x20, 0x83, 0x04, 0x18, 0x30, 0x81, 0x84, 0x04, 0x60, 0x22,
  0x01, 0x90, 0x05, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x00, 0xC1,
  0x83, 0x83, 0x07, 0x0E, 0x0A, 0x14, 0x34, 0x28, 0x68, 0x50, 0xD0, 0x91,
  0x21, 0x22, 0x62, 0x44, 0xCC, 0x89, 0x91, 0x11, 0x22, 0x22, 0x44, 0xC4,
  0x8D, 0x89, 0x0A, 0x12, 0x14, 0x3C, 0x28, 0x70, 0x50, 0xE0, 0xA0, 0xC1,
  0x41, 0x83, 0x80, 0xC0, 0x19, 0x80, 0x46, 0x03, 0x0C, 0x08, 0x10, 0x60,
  0x61, 0x00, 0x8C, 0x03, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40,
  0x0C, 0x80, 0x23, 0x01, 0x84, 0x04, 0x18, 0x30, 0x20, 0x80, 0xC6, 0x01,
  0x30, 0x06, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x08, 0x80, 0x31, 0x80, 0x41,
  0x01, 0x83, 0x02, 0x02, 0x0C, 0x06, 0x10, 0x04, 0x60, 0x0C, 0x80, 0x0B,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0xFF, 0xF0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0xF8, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFE, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF8, 0x06, 0x00, 0xE0,
  0x0B, 0x01, 0x90, 0x19, 0x83, 0x18, 0x30, 0x82, 0x0C, 0x60, 0x44, 0x06,
  0xC0, 0x30, 0xFF, 0xFC, 0xC3, 0x08, 0x70, 0x0F, 0xC3, 0x86, 0x20, 0x36,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x11, 0xFF, 0x70, 0x14, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x16, 0x03, 0x70, 0x51, 0xF9, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xBF, 0x3C, 0x36, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xF8, 0x6D, 0xF8,
  0x1F, 0x87, 0x0C, 0x40, 0x6C, 0x02, 0xC0, 0x2C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x02, 0xC0, 0x24, 0x06, 0x70, 0xC1, 0xF8,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x3E, 0x5C, 0x2A, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0D, 0x01, 0xB0, 0x53, 0xF2, 0x1F, 0x8E, 0x19, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80,
  0xDC, 0x30, 0xFC, 0x03, 0xF8, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x1F, 0xFF, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x1F, 0x2E, 0x15, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x36, 0x06, 0x77, 0x47, 0x88, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x63, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xBF, 0x3C, 0x37, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02,
  0x07, 0x00, 0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xFC,
  0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0xCF, 0xE0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xCC,
  0x18, 0xC1, 0x0C, 0x30, 0xFE, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0xC0, 0x8C,
  0x0C, 0xC0, 0x6C, 0x02, 0xC0, 0x30, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0xFC, 0xF7,
  0x38, 0xF0, 0xC3, 0x84, 0x1C, 0x20, 0xE1, 0x07, 0x08, 0x38, 0x41, 0xC2,
  0x0E, 0x10, 0x70, 0x83, 0x84, 0x1C, 0x20, 0xE1, 0x07, 0x08, 0x38, 0x41,
  0xDF, 0x9E, 0x1B, 0x81, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x1F, 0x8E,
  0x19, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x02, 0x80, 0xD8, 0x30, 0xFC, 0xDF, 0x9E, 0x1B, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xFC, 0x36, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x1F, 0x2E, 0x15, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x06, 0x80, 0xD8, 0x29, 0xF9, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x9F, 0x14, 0x3B, 0x01, 0x40, 0x38,
  0x07, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x3F, 0x86, 0x0E, 0xC0, 0x2C, 0x03, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0xF0, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x3C,
  0x02, 0x60, 0x63, 0xFC, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x0F, 0xFF,
  0x82, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x07,
  0xE0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x06, 0x80, 0xDC, 0x30, 0xFC, 0xC0,
  0x0A, 0x00, 0xD8, 0x04, 0xC0, 0x22, 0x03, 0x18, 0x10, 0xC0, 0x82, 0x0C,
  0x18, 0x40, 0x46, 0x02, 0x30, 0x19, 0x00, 0x58, 0x02, 0x80, 0x1C, 0x00,
  0x60, 0xC1, 0x86, 0x83, 0x0D, 0x06, 0x1A, 0x14, 0x26, 0x28, 0x4C, 0x58,
  0x88, 0x93, 0x11, 0x26, 0x24, 0x4C, 0x48, 0x90, 0xD1, 0xA1, 0xA1, 0x41,
  0x42, 0x83, 0x87, 0x06, 0x0C, 0x0C, 0x18, 0x60, 0x1B, 0x01, 0x8C, 0x08,
  0x30, 0xC0, 0x8C, 0x06, 0x40, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x2C, 0x03,
  0x20, 0x30, 0x81, 0x06, 0x18, 0x11, 0x80, 0x58, 0x03, 0xC0, 0x1A, 0x00,
  0xD8, 0x04, 0x40, 0x63, 0x03, 0x18, 0x10, 0x41, 0x83, 0x08, 0x08, 0x40,
  0x46, 0x03, 0x20, 0x0B, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x0C, 0x01,
  0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x07, 0xFF, 0x01, 0xF0, 0x38, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x0F, 0x80, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x3F,
  0x06, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF0, 0x00, 0x38, 0x0B, 0x60, 0x50,
  0x83, 0x86, 0x3C, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 21, 17, 7, -21 },
  { 9, 8, 9, 17, 5, -21 },
  { 18, 15, 21, 17, 1, -21 },
  { 58, 13, 29, 17, 2, -25 },
  { 106, 16, 21, 17, 1, -21 },
  { 148, 14, 21, 17, 2, -21 },
  { 185, 2, 9, 17, 8, -21 },
  { 188, 8, 27, 17, 6, -24 },
  { 215, 8, 27, 17, 3, -24 },
  { 242, 15, 15, 17, 1, -18 },
  { 271, 13, 13, 17, 2, -16 },
  { 293, 4, 9, 17, 6, -4 },
  { 298, 9, 1, 17, 4, -10 },
  { 300, 4, 4, 17, 7, -4 },
  { 302, 12, 27, 17, 3, -24 },
  { 343, 12, 21, 17, 3, -21 },
  { 375, 12, 21, 17, 3, -21 },
  { 407, 13, 21, 17, 2, -21 },
  { 442, 11, 21, 17, 3, -21 },
  { 471, 11, 21, 17, 3, -21 },
  { 500, 12, 21, 17, 3, -21 },
  { 532, 13, 21, 17, 2, -21 },
  { 567, 13, 21, 17, 2, -21 },
  { 602, 12, 21, 17, 3, -21 },
  { 634, 13, 21, 17, 2, -21 },
  { 669, 4, 16, 17, 7, -16 },
  { 677, 5, 21, 17, 6, -16 },
  { 691, 12, 15, 17, 3, -17 },
  { 714, 12, 8, 17, 3, -14 },
  { 726, 12, 15, 17, 3, -17 },
  { 749, 10, 21, 17, 5, -21 },
  { 776, 14, 26, 17, 2, -21 },
  { 822, 13, 21, 17, 2, -21 },
  { 857, 12, 21, 17, 3, -21 },
  { 889, 12, 21, 17, 3, -21 },
  { 921, 11, 21, 17, 3, -21 },
  { 950, 12, 21, 17, 3, -21 },
  { 982, 12, 21, 17, 3, -21 },
  { 1014, 12, 21, 17, 3, -21 },
  { 1046, 11, 21, 17, 3, -21 },
  { 1075, 11, 21, 17, 3, -21 },
  { 1104, 12, 21, 17, 2, -21 },
  { 1136, 13, 21, 17, 3, -21 },
  { 1171, 12, 21, 17, 3, -21 },
  { 1203, 12, 21, 17, 3, -21 },
  { 1235, 11, 21, 17, 3, -21 },
  { 1264, 11, 21, 17, 3, -21 },
  { 1293, 13, 21, 17, 3, -21 },
  { 1328, 12, 26, 17, 3, -21 },
  { 1367, 12, 21, 17, 3, -21 },
  { 1399, 13, 21, 17, 2, -21 },
  { 1434, 14, 21, 17, 2, -21 },
  { 1471, 11, 21, 17, 3, -21 },
  { 1500, 13, 21, 17, 2, -21 },
  { 1535, 15, 21, 17, 1, -21 },
  { 1575, 14, 21, 17, 2, -21 },
  { 1612, 15, 21, 17, 1, -21 },
  { 1652, 12, 21, 17, 3, -21 },
  { 1684, 7, 27, 17, 6, -24 },
  { 1708, 12, 27, 17, 3, -24 },
  { 1749, 7, 27, 17, 4, -24 },
  { 1773, 12, 11, 17, 3, -21 },
  { 1790, 14, 1, 17, 2, 1 },
  { 1792, 5, 4, 17, 6, -23 },
  { 1795, 12, 16, 17, 2, -16 },
  { 1819, 11, 21, 17, 3, -21 },
  { 1848, 12, 16, 17, 3, -16 },
  { 1872, 11, 21, 17, 3, -21 },
  { 1901, 11, 16, 17, 3, -16 },
  { 1923, 13, 21, 17, 2, -21 },
  { 1958, 11, 21, 17, 3, -16 },
  { 1987, 11, 21, 17, 3, -21 },
  { 2016, 13, 22, 17, 3, -22 },
  { 2052, 10, 27, 17, 3, -22 },
  { 2086, 12, 21, 17, 3, -21 },
  { 2118, 15, 21, 17, 1, -21 },
  { 2158, 13, 16, 17, 2, -16 },
  { 2184, 11, 16, 17, 3, -16 },
  { 2206, 11, 16, 17, 3, -16 },
  { 2228, 11, 21, 17, 3, -16 },
  { 2257, 11, 21, 17, 3, -16 },
  { 2286, 11, 16, 17, 4, -16 },
  { 2308, 12, 16, 17, 3, -16 },
  { 2332, 13, 20, 17, 2, -20 },
  { 2365, 11, 16, 17, 3, -16 },
  { 2387, 13, 16, 17, 2, -16 },
  { 2413, 15, 16, 17, 1, -16 },
  { 2443, 13, 16, 17, 2, -16 },
  { 2469, 13, 21, 17, 2, -16 },
  { 2504, 11, 16, 17, 3, -16 },
  { 2526, 12, 27, 17, 3, -24 },
  { 2567, 1, 27, 17, 8, -24 },
  { 2571, 12, 27, 17, 3, -24 },
  { 2612, 13, 5, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Thin29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_THIN29PT7B_H_
