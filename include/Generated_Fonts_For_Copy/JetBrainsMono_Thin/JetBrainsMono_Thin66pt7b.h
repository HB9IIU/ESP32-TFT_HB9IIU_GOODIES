#ifndef _JETBRAINSMONO_THIN66PT7B_H_
#define _JETBRAINSMONO_THIN66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E,
  0x7E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x67, 0xF0, 0x1F, 0x06,
  0x0F, 0x81, 0xE0, 0x60, 0x78, 0x3C, 0x06, 0x03, 0xC3, 0x80, 0x60, 0x1C,
  0x78, 0x06, 0x01, 0xE7, 0x00, 0x60, 0x0E, 0x70, 0x06, 0x00, 0xE7, 0x00,
  0x60, 0x0E, 0x70, 0x06, 0x00, 0xE7, 0x00, 0x60, 0x00, 0x78, 0x06, 0x00,
  0x07, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x3E,
  0x06, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x0F, 0x86, 0x00, 0x00, 0x7E, 0x60,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x06, 0xFE, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x06,
  0x0F, 0x80, 0x00, 0x60, 0x7C, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x1E,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0xF0, 0x00,
  0x60, 0x07, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00,
  0x7E, 0x00, 0x60, 0x0F, 0xF0, 0x06, 0x00, 0xFF, 0x00, 0x60, 0x0E, 0x78,
  0x06, 0x01, 0xE7, 0x80, 0x60, 0x1C, 0x3E, 0x06, 0x03, 0xC1, 0xF0, 0x60,
  0xF8, 0x0F, 0xF6, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xC3, 0xFF, 0x80, 0x00, 0x1C, 0x3E, 0x3E, 0x00,
  0x01, 0xC3, 0xC0, 0x78, 0x00, 0x0E, 0x1C, 0x01, 0xC0, 0x00, 0xE1, 0xE0,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x00, 0x3E,
  0x1E, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x01, 0xC1,
  0xFF, 0xE0, 0x00, 0x1C, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x03,
  0x80, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0x07, 0x0E,
  0x00, 0x03, 0x80, 0x70, 0xE0, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x00, 0x7F,
  0xF8, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0x9E, 0x03, 0xC0, 0x03, 0x8E, 0x00, 0xF0,
  0x01, 0xC7, 0x00, 0x3C, 0x01, 0xC7, 0x80, 0x0E, 0x01, 0xE3, 0xC0, 0x07,
  0x80, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0xF0, 0x00, 0x78, 0x70, 0x78, 0x00,
  0x1C, 0x78, 0x3C, 0x00, 0x0F, 0x38, 0x1E, 0x00, 0x03, 0xFC, 0x0F, 0x00,
  0x00, 0xFC, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x07, 0x70, 0x1C,
  0x00, 0x07, 0xBC, 0x0F, 0x00, 0x07, 0x8F, 0x07, 0xC0, 0x07, 0x83, 0xC1,
  0xF0, 0x0F, 0x80, 0xE0, 0x7E, 0x1F, 0x80, 0x38, 0x1F, 0xFF, 0x80, 0x1E,
  0x07, 0xFF, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x01, 0xC0, 0x01, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x1B, 0xF0, 0x07, 0x00, 0x3E, 0xFF, 0x01, 0xC0, 0x7F, 0xDF, 0xF8,
  0x70, 0x7F, 0xE1, 0xFF, 0x8C, 0x7F, 0xC0, 0x0F, 0xFB, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFE, 0x7F, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF,
  0x01, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x08,
  0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x0F,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xD0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0x80, 0x08, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0xFE, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x3E,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x3C,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x0F, 0x80, 0x1C, 0x3F, 0xFC, 0x07, 0x1F, 0xFF, 0x81, 0xCF, 0x87,
  0xF8, 0x77, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE1, 0xFE, 0x00, 0x0E, 0x7F,
  0xF8, 0x01, 0xDF, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0x03, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x7B, 0x80, 0x7F, 0xFF, 0x70, 0x01, 0xFF, 0xC7, 0x00, 0x03,
  0xF0, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xCF,
  0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xC7, 0xFB,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x03, 0x00, 0x0F, 0x81, 0xFE,
  0x3F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE1, 0xFE, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xF7, 0xF0, 0x03,
  0xE0, 0x77, 0xF0, 0x07, 0x80, 0x17, 0xF0, 0x07, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x0E,
  0x00, 0x07, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0x0E,
  0x00, 0x07, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0x0E,
  0x00, 0x07, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0x0E,
  0x00, 0x07, 0xF0, 0x0F, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0xF0, 0x07, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0x03,
  0xC0, 0x37, 0xF0, 0x03, 0xFF, 0xF7, 0xF0, 0x01, 0xFF, 0xE7, 0xF0, 0x00,
  0x7F, 0x87, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x3F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE1, 0xE0,
  0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0x01, 0xF0, 0x01, 0xF0, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xE3, 0xC0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xE0, 0x7F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x81, 0xF0, 0x03, 0xE0, 0x1F, 0xC3, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x38, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0x7E, 0xC0, 0x00, 0x77, 0xEE, 0x00, 0x07, 0x7E,
  0xE0, 0x00, 0x6F, 0xE6, 0x00, 0x0E, 0xFE, 0x70, 0x00, 0xCF, 0xE7, 0x00,
  0x1C, 0xFE, 0x38, 0x01, 0xCF, 0xE3, 0x80, 0x18, 0xFE, 0x18, 0x03, 0x8F,
  0xE1, 0xC0, 0x38, 0xFE, 0x1C, 0x03, 0x0F, 0xE0, 0xC0, 0x70, 0xFE, 0x0E,
  0x07, 0x0F, 0xE0, 0xE0, 0x60, 0xFE, 0x06, 0x0E, 0x0F, 0xE0, 0x70, 0xC0,
  0xFE, 0x03, 0x0C, 0x0F, 0xE0, 0x39, 0xC0, 0xFE, 0x03, 0x98, 0x0F, 0xE0,
  0x1B, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xF0,
  0x0F, 0xE0, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0xE0, 0x00, 0x3F, 0x70, 0x00,
  0x1F, 0xB8, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0xE7, 0x00, 0x03, 0xF1, 0xC0,
  0x01, 0xF8, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x0E,
  0x00, 0x1F, 0x83, 0x80, 0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF0,
  0x38, 0x01, 0xF8, 0x1C, 0x00, 0xFC, 0x07, 0x00, 0x7E, 0x03, 0x80, 0x3F,
  0x01, 0xC0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x0E, 0x03,
  0xF0, 0x07, 0x01, 0xF8, 0x03, 0x80, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x70,
  0x3F, 0x00, 0x1C, 0x1F, 0x80, 0x0E, 0x0F, 0xC0, 0x07, 0x07, 0xE0, 0x01,
  0xC3, 0xF0, 0x00, 0xE1, 0xF8, 0x00, 0x78, 0xFC, 0x00, 0x1C, 0x7E, 0x00,
  0x0E, 0x3F, 0x00, 0x03, 0x9F, 0x80, 0x01, 0xCF, 0xC0, 0x00, 0xE7, 0xE0,
  0x00, 0x3B, 0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x03,
  0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0xF0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xF0, 0x03,
  0xE0, 0x7F, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0xEF, 0x00, 0x33,
  0x00, 0x39, 0xC0, 0x0C, 0xC0, 0x0E, 0x70, 0x03, 0x30, 0x03, 0x9C, 0x01,
  0xCC, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x07, 0x38, 0x07, 0x1C, 0x01, 0x8E, 0x01, 0xC7, 0x80, 0x61, 0x80, 0x70,
  0xE0, 0x18, 0x60, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0C, 0x1C,
  0x0E, 0x0E, 0x03, 0x03, 0x03, 0x83, 0xC0, 0xC0, 0xC0, 0xE0, 0x70, 0x70,
  0x30, 0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1,
  0x80, 0xE0, 0xE0, 0x70, 0x60, 0x38, 0x38, 0x1C, 0x18, 0x06, 0x0C, 0x07,
  0x06, 0x01, 0x87, 0x01, 0xE3, 0x80, 0x61, 0xC0, 0x38, 0xE0, 0x18, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x71,
  0xC0, 0x38, 0xC0, 0x1C, 0x70, 0x0E, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x00,
  0xCE, 0x00, 0xF7, 0x00, 0x33, 0x80, 0x1D, 0x80, 0x0E, 0xE0, 0x07, 0x60,
  0x03, 0xB8, 0x01, 0xD8, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x1D,
  0x80, 0x06, 0xE0, 0x07, 0xE0, 0x01, 0xB0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x73, 0xE0, 0x00,
  0x0E, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xE3, 0xE0, 0x03, 0xDC, 0x3F, 0x83, 0xF3,
  0x83, 0xFF, 0xFC, 0x70, 0x1F, 0xFE, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xFE, 0x00, 0xF0, 0xFF, 0xF0, 0x3C, 0xFF, 0xFE, 0x0F, 0x78, 0x07, 0xC3,
  0xF8, 0x00, 0x78, 0xFC, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xCF, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x7C, 0xF7, 0x00,
  0x3E, 0x3D, 0xF0, 0x3F, 0x0F, 0x1F, 0xFF, 0x83, 0xC3, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0x03, 0xF8, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x70, 0x3F, 0xFC, 0x38,
  0x7F, 0xFF, 0x1C, 0x7E, 0x03, 0xCE, 0x3C, 0x00, 0x77, 0x3C, 0x00, 0x1F,
  0xBC, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xE7, 0x80, 0x03,
  0xF1, 0xE0, 0x03, 0xB8, 0x7E, 0x07, 0x9C, 0x1F, 0xFF, 0x8E, 0x07, 0xFF,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3E, 0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xE1, 0xC3, 0xFF, 0xF8, 0xE3, 0xF0, 0x1E, 0x71, 0xE0, 0x03,
  0xB9, 0xE0, 0x00, 0xFD, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0xDC, 0x7C, 0x01, 0xEE, 0x1F, 0xEF,
  0xE7, 0x07, 0xFF, 0xE3, 0x80, 0xFF, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x0F, 0x0F, 0xFF, 0x07,
  0x9F, 0xFF, 0xC3, 0xDE, 0x01, 0xF1, 0xEC, 0x00, 0x7C, 0xFC, 0x00, 0x0F,
  0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x01, 0xF0, 0x0F, 0x87, 0x3F, 0xE1, 0xFF, 0x3B, 0xFF,
  0x9F, 0xFD, 0xD8, 0x3C, 0xC1, 0xEE, 0x80, 0xF4, 0x07, 0xF8, 0x03, 0xC0,
  0x3F, 0xC0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x00, 0x3F,
  0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03,
  0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E,
  0x00, 0x7E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x78, 0x7F, 0xF8,
  0x3C, 0xFF, 0xFE, 0x1E, 0xF0, 0x0F, 0x8F, 0x60, 0x03, 0xE7, 0xE0, 0x00,
  0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3E, 0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x3F, 0xFC,
  0x0F, 0x3F, 0xFF, 0x83, 0xDE, 0x01, 0xF0, 0xFE, 0x00, 0x1E, 0x3F, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x73, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xF0,
  0x00, 0x3C, 0xFC, 0x00, 0x1F, 0x3D, 0xC0, 0x0F, 0x8F, 0x7C, 0x0F, 0xC3,
  0xC7, 0xFF, 0xE0, 0xF0, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xE1, 0xC3, 0xFF, 0xF8, 0xE3, 0xF0, 0x1E, 0x71, 0xE0,
  0x03, 0xB9, 0xE0, 0x00, 0xFD, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x8F, 0x00, 0x1D, 0xC3, 0xF0, 0x7C, 0xE0,
  0xFF, 0xFC, 0x70, 0x3F, 0xF8, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x3C,
  0x3F, 0xFC, 0x0F, 0x3F, 0xFF, 0xC3, 0xDE, 0x01, 0xF8, 0xF6, 0x00, 0x1F,
  0x3F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x38, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x07, 0xF0,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xDC, 0x00,
  0x78, 0x00, 0xEE, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x3E, 0x00, 0x73, 0x80,
  0x1B, 0x80, 0x39, 0xE0, 0x0C, 0xC0, 0x1C, 0x70, 0x06, 0x60, 0x0E, 0x38,
  0x07, 0x30, 0x07, 0x1C, 0x03, 0x98, 0x03, 0x8E, 0x01, 0x8E, 0x03, 0x87,
  0x00, 0xC7, 0x01, 0xC3, 0xC0, 0x61, 0x80, 0xE0, 0xE0, 0x30, 0xC0, 0x70,
  0x70, 0x38, 0x60, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x0C, 0x1C, 0x1C,
  0x0E, 0x06, 0x0E, 0x0E, 0x07, 0x83, 0x03, 0x07, 0x01, 0xC3, 0x81, 0x83,
  0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x38,
  0xE0, 0x1C, 0x30, 0x0C, 0x70, 0x0F, 0x38, 0x06, 0x38, 0x03, 0x9C, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0xE6, 0x00, 0xE7, 0x00, 0x73, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x1B, 0x80, 0x0F, 0xC0, 0x0D, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x03,
  0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x73, 0xFF, 0x00, 0x07, 0x7D, 0xF8,
  0x00, 0x7F, 0x03, 0xC0, 0x07, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0xF0, 0x07,
  0xE0, 0x07, 0x00, 0x7E, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xE1, 0xEE, 0x00,
  0x1F, 0xFE, 0xE0, 0x00, 0x7F, 0xCE, 0x00, 0x01, 0xE0,
};

const GFXglyph JetBrainsMono_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 8, 48, 40, 16, -48 },
  { 49, 18, 20, 40, 11, -48 },
  { 94, 35, 48, 40, 2, -48 },
  { 304, 28, 66, 40, 6, -57 },
  { 535, 37, 49, 40, 1, -49 },
  { 762, 33, 50, 40, 4, -49 },
  { 969, 4, 20, 40, 18, -48 },
  { 979, 18, 63, 40, 14, -55 },
  { 1121, 18, 63, 40, 8, -55 },
  { 1263, 34, 33, 40, 3, -40 },
  { 1404, 30, 30, 40, 5, -37 },
  { 1517, 10, 21, 40, 13, -10 },
  { 1544, 21, 3, 40, 9, -23 },
  { 1552, 10, 10, 40, 15, -9 },
  { 1565, 27, 62, 40, 6, -55 },
  { 1775, 27, 50, 40, 6, -49 },
  { 1944, 28, 48, 40, 7, -48 },
  { 2112, 29, 49, 40, 6, -49 },
  { 2290, 26, 49, 40, 6, -48 },
  { 2450, 25, 48, 40, 7, -48 },
  { 2600, 26, 49, 40, 7, -48 },
  { 2760, 28, 49, 40, 6, -48 },
  { 2932, 29, 48, 40, 6, -48 },
  { 3106, 28, 50, 40, 6, -49 },
  { 3281, 28, 49, 40, 6, -49 },
  { 3453, 10, 38, 40, 15, -37 },
  { 3501, 12, 48, 40, 13, -37 },
  { 3573, 28, 33, 40, 6, -38 },
  { 3689, 27, 18, 40, 6, -31 },
  { 3750, 28, 33, 40, 6, -38 },
  { 3866, 22, 48, 40, 11, -48 },
  { 3998, 32, 61, 40, 4, -49 },
  { 4242, 31, 48, 40, 4, -48 },
  { 4428, 27, 48, 40, 7, -48 },
  { 4590, 27, 50, 40, 7, -49 },
  { 4759, 26, 48, 40, 7, -48 },
  { 4915, 26, 48, 40, 8, -48 },
  { 5071, 27, 48, 40, 8, -48 },
  { 5233, 27, 50, 40, 7, -49 },
  { 5402, 25, 48, 40, 7, -48 },
  { 5552, 24, 48, 40, 8, -48 },
  { 5696, 27, 49, 40, 5, -48 },
  { 5862, 29, 48, 40, 7, -48 },
  { 6036, 27, 48, 40, 8, -48 },
  { 6198, 28, 48, 40, 6, -48 },
  { 6366, 25, 48, 40, 7, -48 },
  { 6516, 26, 50, 40, 7, -49 },
  { 6679, 28, 48, 40, 7, -48 },
  { 6847, 27, 61, 40, 7, -49 },
  { 7053, 28, 48, 40, 7, -48 },
  { 7221, 28, 50, 40, 6, -49 },
  { 7396, 32, 48, 40, 4, -48 },
  { 7588, 25, 49, 40, 7, -48 },
  { 7742, 31, 48, 40, 4, -48 },
  { 7928, 34, 48, 40, 3, -48 },
  { 8132, 33, 48, 40, 3, -48 },
  { 8330, 33, 48, 40, 3, -48 },
  { 8528, 28, 48, 40, 6, -48 },
  { 8696, 14, 62, 40, 15, -55 },
  { 8805, 27, 62, 40, 6, -55 },
  { 9015, 15, 62, 40, 10, -55 },
  { 9132, 26, 26, 40, 7, -48 },
  { 9217, 32, 3, 40, 4, 2 },
  { 9229, 11, 9, 40, 13, -52 },
  { 9242, 27, 38, 40, 5, -37 },
  { 9371, 26, 49, 40, 7, -48 },
  { 9531, 26, 38, 40, 7, -37 },
  { 9655, 25, 49, 40, 7, -48 },
  { 9809, 26, 38, 40, 7, -37 },
  { 9933, 30, 48, 40, 5, -48 },
  { 10113, 25, 49, 40, 7, -37 },
  { 10267, 25, 48, 40, 7, -48 },
  { 10417, 29, 50, 40, 6, -50 },
  { 10599, 24, 62, 40, 6, -50 },
  { 10785, 28, 48, 40, 7, -48 },
  { 10953, 33, 48, 40, 3, -48 },
  { 11151, 29, 37, 40, 5, -37 },
  { 11286, 25, 37, 40, 7, -37 },
  { 11402, 26, 38, 40, 7, -37 },
  { 11526, 26, 49, 40, 7, -37 },
  { 11686, 25, 49, 40, 7, -37 },
  { 11840, 26, 37, 40, 8, -37 },
  { 11961, 27, 38, 40, 6, -37 },
  { 12090, 28, 47, 40, 5, -47 },
  { 12255, 25, 37, 40, 7, -36 },
  { 12371, 30, 36, 40, 5, -36 },
  { 12506, 33, 36, 40, 3, -36 },
  { 12655, 30, 36, 40, 5, -36 },
  { 12790, 30, 48, 40, 5, -36 },
  { 12970, 26, 36, 40, 7, -36 },
  { 13087, 26, 62, 40, 7, -55 },
  { 13289, 3, 62, 40, 18, -55 },
  { 13313, 26, 62, 40, 7, -55 },
  { 13515, 28, 12, 40, 6, -29 },
};

const GFXfont JetBrainsMono_Thin66pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin66pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _JETBRAINSMONO_THIN66PT7B_H_
