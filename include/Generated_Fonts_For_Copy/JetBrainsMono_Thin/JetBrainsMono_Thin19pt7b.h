#ifndef _JETBRAINSMONO_THIN19PT7B_H_
#define _JETBRAINSMONO_THIN19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0xF0, 0x8C, 0x63, 0x18, 0xC4, 0x10, 0x84, 0x41,
  0x10, 0x44, 0xFF, 0xC8, 0x42, 0x20, 0x88, 0x22, 0x3F, 0xE4, 0x21, 0x08,
  0x44, 0x11, 0x00, 0x10, 0x10, 0x10, 0x3C, 0xD2, 0x92, 0x91, 0x90, 0x50,
  0x30, 0x1C, 0x12, 0x11, 0x91, 0x91, 0x92, 0x7C, 0x10, 0x10, 0x10, 0x38,
  0x29, 0x09, 0x12, 0x22, 0x44, 0x90, 0xF4, 0x00, 0x80, 0x20, 0x09, 0xC2,
  0x44, 0x48, 0x91, 0x14, 0x23, 0x83, 0x80, 0x1C, 0x08, 0x84, 0x11, 0x00,
  0x20, 0x08, 0x07, 0x03, 0x22, 0x8C, 0xA1, 0x48, 0x32, 0x0C, 0xC5, 0x9E,
  0x30, 0xFC, 0x09, 0x98, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08,
  0x20, 0xC0, 0xC0, 0x81, 0x02, 0x08, 0x20, 0x83, 0x0C, 0x30, 0xC2, 0x08,
  0x20, 0x84, 0x33, 0x00, 0x08, 0x02, 0x00, 0x82, 0x21, 0xEB, 0x87, 0x01,
  0x40, 0x58, 0x22, 0x18, 0x40, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x6B, 0x49, 0x00, 0xFC, 0x5F, 0x80, 0x03, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x80, 0x7C, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x99, 0x99,
  0x81, 0x81, 0x81, 0x82, 0xC2, 0x7C, 0x18, 0x28, 0xC8, 0x88, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x7C, 0x82, 0x81, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFF, 0xFE, 0x04,
  0x10, 0x41, 0x03, 0x01, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x2F, 0x80, 0x04,
  0x08, 0x20, 0x81, 0x04, 0x10, 0xA1, 0x83, 0x07, 0xF8, 0x10, 0x20, 0x40,
  0xFE, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x01, 0x01, 0x01, 0x82,
  0x82, 0x7C, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x82, 0x81, 0x81,
  0x81, 0x81, 0xC2, 0x7C, 0xFF, 0x81, 0x82, 0x82, 0x02, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x3C, 0x42, 0x82, 0x81, 0x82, 0x46,
  0x38, 0x2C, 0xC2, 0x83, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0xC2, 0x82, 0x81,
  0x81, 0x81, 0x82, 0x6E, 0x14, 0x04, 0x08, 0x08, 0x10, 0x20, 0x5D, 0x80,
  0x00, 0x5F, 0x80, 0x5F, 0x80, 0x00, 0x6B, 0x49, 0x00, 0x01, 0x06, 0x18,
  0x60, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x06, 0x18, 0x20, 0xC0, 0xF0, 0x18, 0x10, 0x30,
  0x40, 0x83, 0x18, 0x20, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x1E, 0x30, 0x90,
  0x30, 0x18, 0x0C, 0x7E, 0x23, 0x11, 0x88, 0xC4, 0x62, 0x31, 0x18, 0x7C,
  0x01, 0x00, 0x80, 0x3E, 0x00, 0x08, 0x06, 0x05, 0x02, 0x81, 0x20, 0x90,
  0x88, 0x44, 0x21, 0x1F, 0x90, 0x48, 0x24, 0x0C, 0x04, 0xFC, 0x86, 0x82,
  0x82, 0x82, 0x82, 0xFC, 0x86, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x3C,
  0x42, 0x82, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x81, 0x42,
  0x7C, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x7F, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x42, 0x82, 0x81, 0x80, 0x80,
  0x80, 0x9F, 0x81, 0x81, 0x81, 0x81, 0x42, 0x7C, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC0, 0x0F, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x43, 0x3E,
  0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0xF8, 0x88, 0x84, 0x84, 0x86, 0x82,
  0x83, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x83, 0xC3, 0xC5, 0xA5, 0xA5, 0xA9, 0x99, 0x91,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x87, 0x0D, 0x1A, 0x32, 0x64,
  0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x70, 0x40, 0x3C, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x2F, 0x80, 0xFC, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x42,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x42, 0x7C,
  0x04, 0x06, 0x03, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x88,
  0x84, 0x84, 0x82, 0x82, 0x81, 0x3C, 0xC2, 0x82, 0x81, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x01, 0x81, 0x81, 0x82, 0x7C, 0xFF, 0x84, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x2F, 0x80,
  0x80, 0xA0, 0x50, 0x48, 0x24, 0x11, 0x08, 0x88, 0x44, 0x12, 0x09, 0x05,
  0x02, 0x80, 0xC0, 0x40, 0x88, 0x63, 0x18, 0xCA, 0x32, 0x94, 0xA5, 0x29,
  0x49, 0x4A, 0x52, 0x94, 0xA6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0xC0, 0xA0,
  0x88, 0x44, 0x41, 0x20, 0xA0, 0x20, 0x18, 0x14, 0x09, 0x08, 0x88, 0x24,
  0x0C, 0x04, 0x80, 0xA0, 0x50, 0x44, 0x22, 0x20, 0x90, 0x50, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xFE, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x03, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x18, 0x28, 0x24,
  0x44, 0x42, 0x82, 0x83, 0xFF, 0x80, 0x88, 0x80, 0x18, 0xCE, 0x08, 0x10,
  0x2F, 0xE0, 0xC1, 0x83, 0x05, 0xF8, 0x81, 0x02, 0x04, 0xCE, 0x70, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x37, 0x80, 0x38, 0x46, 0x82, 0x83, 0x80,
  0x80, 0x80, 0x81, 0x82, 0x42, 0x7C, 0x02, 0x04, 0x09, 0xD4, 0x70, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x2F, 0xC0, 0x38, 0x8E, 0x0C, 0x18, 0x3F,
  0xE0, 0x40, 0x83, 0x85, 0xF0, 0x07, 0x84, 0x02, 0x01, 0x00, 0x87, 0xFC,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x38, 0x8E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xC2, 0xFC, 0x08, 0x10, 0x2F, 0xC0, 0x81, 0x02,
  0x04, 0xCE, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x10,
  0x18, 0x10, 0x00, 0xF0, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x04, 0x1C, 0x10, 0x0F, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x05, 0xF0, 0x80, 0x80, 0x80, 0x81, 0x82, 0x86,
  0x84, 0x88, 0xF8, 0x88, 0x84, 0x84, 0x82, 0x81, 0xF0, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7C,
  0x33, 0x66, 0xE2, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x62,
  0x20, 0x19, 0xCE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x85, 0xF0, 0x19, 0xCE, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x86, 0xF4, 0x08, 0x10, 0x00, 0x38, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x85, 0xF8, 0x10, 0x20, 0x40, 0x18,
  0xA6, 0xC3, 0x81, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x38, 0x46,
  0x83, 0x80, 0xC0, 0x7C, 0x02, 0x01, 0x81, 0x82, 0x7E, 0x10, 0x08, 0x3F,
  0xE2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0xF0,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0xF8, 0xC0, 0xA0, 0x90,
  0x44, 0x22, 0x21, 0x10, 0x48, 0x28, 0x0C, 0x04, 0x00, 0x88, 0xC6, 0x63,
  0x2A, 0x95, 0x4A, 0xA9, 0x4C, 0xA6, 0x63, 0x11, 0x80, 0x41, 0x91, 0x04,
  0x82, 0x80, 0x80, 0x60, 0x48, 0x44, 0x61, 0x60, 0x40, 0xC0, 0xA0, 0x88,
  0x44, 0x42, 0x20, 0x90, 0x50, 0x18, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x00,
  0xFE, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0xFC, 0x07, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xF0, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x1F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xE0,
  0xF1, 0x91, 0x8E,
};

const GFXglyph JetBrainsMono_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 14, 11, 5, -14 },
  { 5, 5, 6, 11, 3, -14 },
  { 9, 10, 14, 11, 1, -14 },
  { 27, 8, 20, 11, 2, -17 },
  { 47, 11, 14, 11, 0, -14 },
  { 67, 10, 14, 11, 1, -14 },
  { 85, 1, 6, 11, 5, -14 },
  { 86, 5, 18, 11, 4, -16 },
  { 98, 6, 18, 11, 2, -16 },
  { 112, 10, 10, 11, 1, -12 },
  { 125, 9, 9, 11, 1, -11 },
  { 136, 3, 6, 11, 4, -3 },
  { 139, 6, 1, 11, 3, -7 },
  { 140, 3, 3, 11, 4, -3 },
  { 142, 8, 18, 11, 2, -16 },
  { 160, 8, 14, 11, 2, -14 },
  { 174, 8, 14, 11, 2, -14 },
  { 188, 8, 14, 11, 2, -14 },
  { 202, 7, 14, 11, 2, -14 },
  { 215, 7, 14, 11, 2, -14 },
  { 228, 8, 14, 11, 2, -14 },
  { 242, 8, 14, 11, 2, -14 },
  { 256, 8, 14, 11, 2, -14 },
  { 270, 8, 14, 11, 2, -14 },
  { 284, 8, 14, 11, 2, -14 },
  { 298, 3, 11, 11, 4, -11 },
  { 303, 3, 14, 11, 4, -11 },
  { 309, 8, 9, 11, 2, -11 },
  { 318, 8, 5, 11, 2, -9 },
  { 323, 8, 9, 11, 2, -11 },
  { 332, 7, 14, 11, 3, -14 },
  { 345, 9, 17, 11, 1, -14 },
  { 365, 9, 14, 11, 1, -14 },
  { 381, 8, 14, 11, 2, -14 },
  { 395, 8, 14, 11, 2, -14 },
  { 409, 7, 14, 11, 2, -14 },
  { 422, 8, 14, 11, 2, -14 },
  { 436, 8, 14, 11, 2, -14 },
  { 450, 8, 14, 11, 2, -14 },
  { 464, 7, 14, 11, 2, -14 },
  { 477, 7, 14, 11, 2, -14 },
  { 490, 8, 14, 11, 1, -14 },
  { 504, 8, 14, 11, 2, -14 },
  { 518, 8, 14, 11, 2, -14 },
  { 532, 8, 14, 11, 2, -14 },
  { 546, 7, 14, 11, 2, -14 },
  { 559, 7, 14, 11, 2, -14 },
  { 572, 8, 14, 11, 2, -14 },
  { 586, 8, 17, 11, 2, -14 },
  { 603, 8, 14, 11, 2, -14 },
  { 617, 8, 14, 11, 2, -14 },
  { 631, 9, 14, 11, 1, -14 },
  { 647, 7, 14, 11, 2, -14 },
  { 660, 9, 14, 11, 1, -14 },
  { 676, 10, 14, 11, 1, -14 },
  { 694, 9, 14, 11, 1, -14 },
  { 710, 9, 14, 11, 1, -14 },
  { 726, 8, 14, 11, 2, -14 },
  { 740, 4, 18, 11, 4, -16 },
  { 749, 8, 18, 11, 2, -16 },
  { 767, 4, 18, 11, 3, -16 },
  { 776, 8, 8, 11, 2, -14 },
  { 784, 9, 1, 11, 1, 0 },
  { 786, 3, 3, 11, 4, -15 },
  { 788, 7, 11, 11, 2, -11 },
  { 798, 7, 14, 11, 2, -14 },
  { 811, 8, 11, 11, 2, -11 },
  { 822, 7, 14, 11, 2, -14 },
  { 835, 7, 11, 11, 2, -11 },
  { 845, 9, 14, 11, 1, -14 },
  { 861, 7, 14, 11, 2, -11 },
  { 874, 7, 14, 11, 2, -14 },
  { 887, 8, 15, 11, 2, -15 },
  { 902, 7, 18, 11, 2, -15 },
  { 918, 8, 14, 11, 2, -14 },
  { 932, 9, 14, 11, 1, -14 },
  { 948, 9, 11, 11, 1, -11 },
  { 961, 7, 11, 11, 2, -11 },
  { 971, 7, 11, 11, 2, -11 },
  { 981, 7, 14, 11, 2, -11 },
  { 994, 7, 14, 11, 2, -11 },
  { 1007, 8, 11, 11, 2, -11 },
  { 1018, 8, 11, 11, 2, -11 },
  { 1029, 9, 13, 11, 1, -13 },
  { 1044, 7, 10, 11, 2, -10 },
  { 1053, 9, 10, 11, 1, -10 },
  { 1065, 9, 10, 11, 1, -10 },
  { 1077, 9, 10, 11, 1, -10 },
  { 1089, 9, 13, 11, 1, -10 },
  { 1104, 7, 10, 11, 2, -10 },
  { 1113, 8, 18, 11, 2, -16 },
  { 1131, 1, 18, 11, 5, -16 },
  { 1134, 8, 18, 11, 2, -16 },
  { 1152, 8, 3, 11, 2, -8 },
};

const GFXfont JetBrainsMono_Thin19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_THIN19PT7B_H_
