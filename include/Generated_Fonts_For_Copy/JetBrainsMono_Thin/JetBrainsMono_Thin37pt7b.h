#ifndef _JETBRAINSMONO_THIN37PT7B_H_
#define _JETBRAINSMONO_THIN37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00,
  0x07, 0xFF, 0x70, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x34, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80,
  0x80, 0x18, 0x18, 0x01, 0x01, 0x80, 0x10, 0x18, 0x03, 0x01, 0x80, 0x30,
  0x10, 0x3F, 0xFF, 0xF0, 0x20, 0x30, 0x02, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x02, 0x00, 0x60, 0x20, 0x04, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0x40, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0, 0x08, 0x0C, 0x01, 0x80, 0xC0,
  0x18, 0x08, 0x01, 0x80, 0x80, 0x18, 0x18, 0x01, 0x01, 0x80, 0x30, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x0F,
  0xF0, 0x1E, 0xBC, 0x30, 0x8E, 0x60, 0x86, 0x60, 0x86, 0x60, 0x83, 0x60,
  0x83, 0x60, 0x80, 0x60, 0x80, 0x30, 0x80, 0x38, 0x80, 0x1C, 0x80, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xB8, 0x00, 0x8C, 0x00, 0x86, 0x00, 0x87, 0x00,
  0x83, 0x00, 0x83, 0xC0, 0x83, 0xC0, 0x83, 0xC0, 0x83, 0x60, 0x86, 0x70,
  0x8E, 0x3C, 0xBC, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x3F, 0x00, 0x37, 0x38, 0x02, 0x41, 0x80, 0x6C, 0x08,
  0x0C, 0xC0, 0xC0, 0x8C, 0x0C, 0x18, 0xC0, 0xC3, 0x0C, 0x0C, 0x60, 0xC0,
  0xC4, 0x04, 0x18, 0xC0, 0x73, 0x98, 0x03, 0xF1, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x7C, 0x01, 0x8C, 0xE0, 0x31, 0x83,
  0x02, 0x10, 0x30, 0x61, 0x03, 0x0C, 0x10, 0x30, 0x81, 0x03, 0x18, 0x10,
  0x33, 0x01, 0x03, 0x60, 0x18, 0x34, 0x00, 0xCE, 0xC0, 0x07, 0xC0, 0x07,
  0xF0, 0x01, 0xC7, 0x00, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xE7, 0x00, 0x18, 0x60, 0x32, 0x06,
  0x0C, 0xC0, 0x61, 0x98, 0x06, 0x63, 0x00, 0xCC, 0x60, 0x0F, 0x0C, 0x00,
  0xE1, 0x80, 0x1C, 0x30, 0x07, 0x83, 0x00, 0xD8, 0x60, 0x31, 0x87, 0x1C,
  0x18, 0x7F, 0x03, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0xF0, 0xF0, 0x70,
  0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xF0, 0x1C, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x30, 0x17, 0x86, 0x1F, 0x7E,
  0xCF, 0x81, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x13, 0x00, 0x06,
  0x60, 0x01, 0x86, 0x00, 0x70, 0xE0, 0x0C, 0x0E, 0x03, 0x00, 0xE0, 0x60,
  0x08, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x1C, 0x73, 0x8E, 0x38, 0xC7, 0x18, 0x61, 0x8C, 0x30, 0xFF, 0xFF, 0xFF,
  0x79, 0xFF, 0xFF, 0x78, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x38, 0x0C, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC1, 0xC3, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x70, 0x06, 0x38, 0x0C,
  0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x1D, 0x80, 0x39, 0x80,
  0x61, 0x80, 0xC1, 0x80, 0x81, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0,
  0x1E, 0x1E, 0x0C, 0x03, 0x8C, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xD8, 0x01, 0xB0, 0x06, 0x30, 0x1C, 0x7C, 0xF0, 0x3F, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x03, 0x18, 0x0C, 0xC0, 0x36,
  0x00, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xFD, 0xFF, 0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x87, 0x83, 0x3F, 0xC6, 0xC1, 0xCE, 0x01, 0xDC,
  0x01, 0xB0, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x58, 0x01, 0xB0, 0x03, 0x60, 0x06, 0x60, 0x18, 0x79, 0xE0,
  0x7F, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x37, 0xF0, 0x3E, 0x7C, 0x70, 0x0C, 0x60, 0x06, 0x60, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06,
  0x60, 0x06, 0x30, 0x0C, 0x1E, 0x78, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0F, 0xF0, 0x1E, 0x38, 0x30, 0x0C, 0x70, 0x06, 0x60, 0x06,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x1C,
  0x0E, 0x30, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0x30, 0x38, 0x1C, 0x30, 0x0E,
  0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x06, 0x70, 0x0E, 0x3E, 0x3C, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78,
  0x30, 0x0C, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x30, 0x0E,
  0x1E, 0x74, 0x0F, 0xEC, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x31, 0xEF, 0xFF, 0x78, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x79, 0xFF, 0xFF, 0x78, 0x18, 0x7D, 0xFB, 0xF3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3,
  0x0E, 0x18, 0x30, 0x61, 0x83, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x0F, 0xE0,
  0x78, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0xFC, 0x03,
  0xC3, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x3C, 0x0F, 0xFF, 0x03, 0x07,
  0xC1, 0x80, 0xF0, 0x60, 0x3C, 0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0,
  0x60, 0x3C, 0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x60, 0x3C, 0x0C,
  0x1F, 0x03, 0xFF, 0xC0, 0x3C, 0xD8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x00,
  0x1E, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x24,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x40, 0x04, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x82, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x0F, 0xFF, 0x04, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x60,
  0xFF, 0xC1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0,
  0x01, 0x60, 0x02, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x01, 0xCF, 0xFF,
  0x1F, 0xFE, 0x30, 0x0E, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x19, 0xFF,
  0xE3, 0xFF, 0x00, 0x1F, 0xE0, 0x78, 0xF1, 0xC0, 0x63, 0x00, 0x6C, 0x00,
  0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x30, 0x06,
  0x70, 0x18, 0x79, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30,
  0x06, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06,
  0xC0, 0x73, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x1F, 0xE0, 0x78, 0xF1, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x30, 0x06, 0x70, 0x18, 0x79,
  0xF0, 0x7F, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x70, 0x06,
  0x60, 0x18, 0x79, 0xE0, 0x7F, 0x80, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0xE0, 0x07, 0xF0, 0x0F, 0xD0, 0x0F, 0xD0, 0x0B, 0xD8,
  0x1B, 0xC8, 0x1B, 0xCC, 0x13, 0xCC, 0x33, 0xC4, 0x23, 0xC6, 0x23, 0xC6,
  0x63, 0xC2, 0x43, 0xC3, 0x43, 0xC1, 0xC3, 0xC1, 0x83, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xD0, 0x0F, 0x60, 0x3C, 0x80, 0xF3, 0x03, 0xCC,
  0x0F, 0x10, 0x3C, 0x60, 0xF1, 0x83, 0xC3, 0x0F, 0x0C, 0x3C, 0x10, 0xF0,
  0x63, 0xC1, 0x8F, 0x03, 0x3C, 0x0C, 0xF0, 0x13, 0xC0, 0x6F, 0x01, 0xBC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0x1F, 0xE0, 0xF1,
  0xC6, 0x01, 0x98, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x03, 0x60, 0x18, 0xF3, 0xC1, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0xC0, 0x1C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x1C, 0xFF,
  0xF8, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x79, 0xE1, 0x80, 0x63, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x30, 0x06,
  0x60, 0x18, 0x79, 0xE0, 0x7F, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xFF, 0xF0, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x07, 0x0F, 0xF0, 0x1E, 0x3C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x06, 0x70, 0x0E, 0x3E, 0x3C, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xD8, 0x07, 0x70, 0x18, 0xF3, 0xC1, 0xFE, 0x00, 0xC0, 0x01, 0xE0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x18, 0x60,
  0x0C, 0x30, 0x04, 0x18, 0x06, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x18, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x0C,
  0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x09, 0x80, 0x06, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x34, 0x07, 0x03, 0x60,
  0x70, 0x26, 0x07, 0x02, 0x60, 0xD0, 0x66, 0x0D, 0x06, 0x60, 0x90, 0x66,
  0x09, 0x06, 0x20, 0x98, 0x62, 0x09, 0x86, 0x30, 0x98, 0x43, 0x18, 0x84,
  0x31, 0x88, 0x43, 0x10, 0x8C, 0x31, 0x08, 0xC3, 0x10, 0xCC, 0x11, 0x0C,
  0xC1, 0x10, 0xCC, 0x1B, 0x04, 0x81, 0xB0, 0x48, 0x1A, 0x04, 0x81, 0xA0,
  0x58, 0x1A, 0x05, 0x81, 0xA0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x78, 0x0C,
  0x03, 0x00, 0x60, 0x01, 0xD8, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18,
  0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x00, 0xCC,
  0x00, 0x13, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x04, 0xC0, 0x03, 0x30, 0x01, 0x86, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C,
  0x06, 0x06, 0x01, 0x81, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x36, 0x00, 0xCC, 0x01,
  0x8C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x30, 0x60, 0x61, 0xC0, 0x63, 0x00,
  0xC6, 0x00, 0xD8, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x60,
  0xE0, 0xC0, 0xE0, 0x01, 0xC0, 0x1F, 0xE0, 0x70, 0x71, 0x80, 0x66, 0x00,
  0x6C, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x7F, 0xFB,
  0x80, 0x36, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0D, 0x80, 0x39, 0xE3, 0xB1, 0xFE, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x38, 0x33, 0xFC, 0xD8, 0x3B, 0x80,
  0x6E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xF0, 0x1B, 0x71, 0xCC, 0xFE, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0xE0,
  0xE3, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0xE0,
  0x02, 0xC0, 0x0C, 0xC0, 0x19, 0xC0, 0x61, 0xE7, 0x81, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x70, 0xC7,
  0xFB, 0x30, 0x3D, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xD8, 0x07, 0x60, 0x1C, 0xE1, 0xB1, 0xFC, 0xC0, 0x07,
  0x80, 0x7F, 0x83, 0x03, 0x98, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x8F, 0x1C, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x7F, 0xB3, 0x03, 0xD8,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x1C,
  0xE1, 0xB1, 0xFC, 0xC0, 0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0xE3, 0xFF, 0x0F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x38, 0x33, 0xFC, 0xD8, 0x3B, 0x80,
  0x6E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01, 0xC7, 0xFC, 0x3F, 0x80,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0x80, 0xFF, 0x80, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x0E, 0x1C, 0xFF, 0x3E, 0xE3,
  0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0x03, 0x83, 0x3F, 0xCD, 0x83, 0xB8, 0x06, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0C, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x98, 0x06, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x8F,
  0x3C, 0x1F, 0xE0, 0x03, 0x83, 0x3F, 0xCD, 0x83, 0xB8, 0x06, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x01,
  0xB7, 0x1C, 0xCF, 0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x7F, 0xB3, 0x03, 0xD8, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x76,
  0x01, 0xCE, 0x1B, 0x1F, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x83, 0x7F, 0x8F, 0x03, 0x38, 0x06,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x38, 0x0C,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x01, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0x60, 0x02, 0x70, 0x06, 0x3C, 0x1C, 0x1F, 0xF8,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0xFE, 0x00, 0xFE, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x1D, 0xC0, 0x63,
  0xCF, 0x07, 0xF8, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20,
  0x06, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x18, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xC0, 0xC0, 0xF0, 0x30, 0x3C,
  0x0E, 0x0D, 0x06, 0x83, 0x41, 0xA0, 0xD8, 0x48, 0x26, 0x12, 0x19, 0x84,
  0xC6, 0x63, 0x31, 0x88, 0xC4, 0x62, 0x31, 0x18, 0xC8, 0x44, 0x32, 0x1B,
  0x0D, 0x86, 0xC3, 0x61, 0xB0, 0x58, 0x2C, 0x14, 0x0A, 0x07, 0x02, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0xE0, 0x07, 0x70, 0x06, 0x30, 0x0C, 0x18, 0x18,
  0x0C, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18,
  0x30, 0x0C, 0x70, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x06, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0x67, 0x03, 0xC1, 0x83, 0xC1, 0xC3, 0xC0, 0xE7, 0xC0, 0x3E,
};

const GFXglyph JetBrainsMono_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 27, 22, 9, -27 },
  { 15, 10, 11, 22, 6, -27 },
  { 29, 20, 27, 22, 1, -27 },
  { 97, 16, 37, 22, 3, -32 },
  { 171, 20, 27, 22, 1, -27 },
  { 239, 19, 27, 22, 2, -27 },
  { 304, 2, 11, 22, 10, -27 },
  { 307, 10, 35, 22, 8, -31 },
  { 351, 11, 35, 22, 4, -31 },
  { 400, 19, 19, 22, 2, -23 },
  { 446, 16, 17, 22, 3, -21 },
  { 480, 6, 12, 22, 7, -6 },
  { 489, 12, 2, 22, 5, -13 },
  { 492, 6, 5, 22, 8, -5 },
  { 496, 15, 35, 22, 4, -31 },
  { 562, 16, 27, 22, 3, -27 },
  { 616, 16, 27, 22, 4, -27 },
  { 670, 17, 27, 22, 3, -27 },
  { 728, 15, 27, 22, 3, -27 },
  { 779, 14, 27, 22, 4, -27 },
  { 827, 15, 27, 22, 4, -27 },
  { 878, 16, 27, 22, 3, -27 },
  { 932, 16, 27, 22, 3, -27 },
  { 986, 16, 27, 22, 3, -27 },
  { 1040, 16, 27, 22, 3, -27 },
  { 1094, 6, 21, 22, 8, -21 },
  { 1110, 7, 27, 22, 7, -21 },
  { 1134, 16, 18, 22, 3, -21 },
  { 1170, 15, 10, 22, 4, -17 },
  { 1189, 16, 18, 22, 3, -21 },
  { 1225, 13, 27, 22, 6, -27 },
  { 1269, 18, 34, 22, 2, -27 },
  { 1346, 17, 27, 22, 3, -27 },
  { 1404, 15, 27, 22, 4, -27 },
  { 1455, 15, 27, 22, 4, -27 },
  { 1506, 14, 27, 22, 4, -27 },
  { 1554, 15, 27, 22, 4, -27 },
  { 1605, 15, 27, 22, 4, -27 },
  { 1656, 15, 27, 22, 4, -27 },
  { 1707, 14, 27, 22, 4, -27 },
  { 1755, 14, 27, 22, 4, -27 },
  { 1803, 15, 27, 22, 3, -27 },
  { 1854, 16, 27, 22, 4, -27 },
  { 1908, 15, 27, 22, 4, -27 },
  { 1959, 16, 27, 22, 3, -27 },
  { 2013, 14, 27, 22, 4, -27 },
  { 2061, 14, 27, 22, 4, -27 },
  { 2109, 16, 27, 22, 4, -27 },
  { 2163, 15, 34, 22, 4, -27 },
  { 2227, 16, 27, 22, 4, -27 },
  { 2281, 16, 27, 22, 3, -27 },
  { 2335, 18, 27, 22, 2, -27 },
  { 2396, 14, 27, 22, 4, -27 },
  { 2444, 17, 27, 22, 3, -27 },
  { 2502, 20, 27, 22, 1, -27 },
  { 2570, 18, 27, 22, 2, -27 },
  { 2631, 18, 27, 22, 2, -27 },
  { 2692, 16, 27, 22, 3, -27 },
  { 2746, 8, 35, 22, 8, -31 },
  { 2781, 15, 35, 22, 4, -31 },
  { 2847, 8, 35, 22, 6, -31 },
  { 2882, 15, 14, 22, 4, -27 },
  { 2909, 18, 2, 22, 2, 1 },
  { 2914, 7, 5, 22, 7, -29 },
  { 2919, 15, 21, 22, 3, -21 },
  { 2959, 14, 27, 22, 4, -27 },
  { 3007, 15, 21, 22, 4, -21 },
  { 3047, 14, 27, 22, 4, -27 },
  { 3095, 14, 21, 22, 4, -21 },
  { 3132, 16, 27, 22, 3, -27 },
  { 3186, 14, 28, 22, 4, -21 },
  { 3235, 14, 27, 22, 4, -27 },
  { 3283, 16, 28, 22, 4, -28 },
  { 3339, 13, 35, 22, 4, -28 },
  { 3396, 16, 27, 22, 4, -27 },
  { 3450, 18, 27, 22, 2, -27 },
  { 3511, 16, 21, 22, 3, -21 },
  { 3553, 14, 21, 22, 4, -21 },
  { 3590, 14, 21, 22, 4, -21 },
  { 3627, 14, 28, 22, 4, -21 },
  { 3676, 14, 28, 22, 4, -21 },
  { 3725, 14, 21, 22, 5, -21 },
  { 3762, 16, 21, 22, 3, -21 },
  { 3804, 16, 26, 22, 3, -26 },
  { 3856, 14, 20, 22, 4, -20 },
  { 3891, 16, 20, 22, 3, -20 },
  { 3931, 18, 20, 22, 2, -20 },
  { 3976, 16, 20, 22, 3, -20 },
  { 4016, 16, 27, 22, 3, -20 },
  { 4070, 14, 20, 22, 4, -20 },
  { 4105, 15, 35, 22, 4, -31 },
  { 4171, 2, 35, 22, 10, -31 },
  { 4180, 15, 35, 22, 4, -31 },
  { 4246, 16, 6, 22, 3, -16 },
};

const GFXfont JetBrainsMono_Thin37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_THIN37PT7B_H_
