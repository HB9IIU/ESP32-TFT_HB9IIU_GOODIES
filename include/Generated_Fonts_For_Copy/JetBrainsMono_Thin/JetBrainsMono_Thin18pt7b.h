#ifndef _JETBRAINSMONO_THIN18PT7B_H_
#define _JETBRAINSMONO_THIN18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x40, 0x2E, 0x8C, 0x63, 0x18, 0x80, 0x11, 0x08,
  0x84, 0x44, 0x2F, 0xE9, 0x10, 0x88, 0x44, 0xFF, 0xA2, 0x11, 0x08, 0x84,
  0x40, 0x10, 0x20, 0x43, 0xE9, 0x32, 0x64, 0x48, 0x70, 0x30, 0x58, 0x91,
  0x32, 0x64, 0xBE, 0x10, 0x20, 0x40, 0x78, 0x52, 0x24, 0x89, 0x24, 0x4A,
  0x0C, 0x80, 0x40, 0x2E, 0x12, 0x44, 0x92, 0x25, 0x09, 0xC3, 0xC0, 0x3C,
  0x21, 0x10, 0x88, 0x02, 0x01, 0x81, 0x43, 0x12, 0x85, 0x43, 0x20, 0x90,
  0xA7, 0x88, 0xF8, 0x19, 0x11, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x41,
  0x04, 0x18, 0xC1, 0x04, 0x30, 0x84, 0x21, 0x08, 0x42, 0x10, 0x8C, 0x44,
  0xC0, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0x50, 0x44, 0x43, 0x00,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x2D, 0x25, 0x00, 0xF8,
  0xFC, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04,
  0x08, 0x10, 0x40, 0x80, 0x7D, 0x06, 0x0C, 0x18, 0x32, 0x6C, 0xC1, 0x83,
  0x06, 0x0C, 0x37, 0xC0, 0x30, 0x50, 0x90, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x7C, 0x82, 0x82, 0x02, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x07, 0x81,
  0x01, 0x02, 0x06, 0x0C, 0x27, 0xC0, 0x04, 0x10, 0x40, 0x82, 0x0C, 0x50,
  0xC1, 0x83, 0xFC, 0x08, 0x10, 0x20, 0xFF, 0x02, 0x04, 0x0B, 0x98, 0xA0,
  0x81, 0x02, 0x06, 0x0C, 0x27, 0xC0, 0x08, 0x20, 0x81, 0x04, 0x0F, 0x31,
  0xC1, 0x83, 0x06, 0x0C, 0x17, 0xC0, 0xFF, 0x06, 0x0C, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x00, 0x7D, 0x06, 0x0C, 0x18, 0x4D, 0x0E,
  0x22, 0x83, 0x06, 0x0C, 0x17, 0xC0, 0x7D, 0x06, 0x0C, 0x18, 0x30, 0x71,
  0x9E, 0x04, 0x10, 0x40, 0x82, 0x00, 0xFD, 0x00, 0x00, 0xFC, 0x77, 0x00,
  0x00, 0x02, 0x64, 0x44, 0x80, 0x06, 0x10, 0xC6, 0x08, 0x0C, 0x06, 0x03,
  0x02, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x61, 0x0C, 0x60,
  0x80, 0xF8, 0x20, 0x41, 0x04, 0x27, 0x10, 0x40, 0x00, 0x18, 0x60, 0x3E,
  0x20, 0x90, 0x30, 0x18, 0x6C, 0x4E, 0x43, 0x21, 0x90, 0xC8, 0x62, 0x31,
  0xF8, 0x02, 0x01, 0x00, 0x78, 0x08, 0x0C, 0x05, 0x02, 0x82, 0x41, 0x10,
  0x88, 0x44, 0x7E, 0x20, 0x90, 0x48, 0x28, 0x18, 0xFD, 0x0E, 0x0C, 0x18,
  0x30, 0xBF, 0x41, 0x83, 0x06, 0x0C, 0x1F, 0xC0, 0x7D, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x17, 0xC0, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x2F, 0x80, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x7D, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x4F, 0x83, 0x06, 0x0C, 0x17, 0xC0, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x1F, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x42, 0x3C, 0x83, 0x82, 0x84,
  0x84, 0x88, 0x88, 0xF8, 0x88, 0x84, 0x84, 0x86, 0x82, 0x83, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x83, 0x8F,
  0x1E, 0x5A, 0xB5, 0x64, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x83, 0x87,
  0x0D, 0x1A, 0x32, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x60, 0x7D, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x27, 0xC0, 0xFC, 0x82,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7D,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x27, 0xC1, 0x81,
  0x01, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x82, 0xFC, 0x88, 0x88, 0x84, 0x84,
  0x82, 0x83, 0x7D, 0x06, 0x0C, 0x08, 0x0C, 0x06, 0x03, 0x02, 0x06, 0x0C,
  0x17, 0xC0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x27, 0xC0, 0x81, 0xA0, 0x90, 0x48, 0x24, 0x21, 0x10,
  0x88, 0x44, 0x14, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x88, 0xCC, 0x65, 0x32,
  0x99, 0x4C, 0xAA, 0x54, 0xAA, 0x65, 0x32, 0x98, 0xCC, 0x66, 0x30, 0xC1,
  0xA0, 0x88, 0x84, 0x41, 0x40, 0xC0, 0x20, 0x28, 0x24, 0x11, 0x10, 0x88,
  0x28, 0x08, 0x80, 0xA0, 0x90, 0x44, 0x42, 0x20, 0xA0, 0x50, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xFE, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x0F, 0xE0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x01, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x10, 0x50, 0xA2, 0x24, 0x50, 0xA0, 0x80, 0xFF, 0x80, 0x8C,
  0x3E, 0x42, 0x41, 0x01, 0x3F, 0x41, 0x41, 0x81, 0x43, 0x3D, 0x81, 0x02,
  0x05, 0xEC, 0x50, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x2F, 0xC0, 0x7D, 0x0E,
  0x0C, 0x08, 0x10, 0x20, 0x41, 0x82, 0xF8, 0x02, 0x04, 0x0B, 0xD8, 0x70,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x37, 0xA0, 0x7D, 0x0A, 0x0C, 0x1F, 0xF0,
  0x20, 0x40, 0x82, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x7A, 0x04, 0x08, 0x17, 0xC0, 0x81, 0x02, 0x05, 0xEC, 0x50, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0x10, 0x18, 0x00, 0x00, 0xF0, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x0C, 0x30, 0x00, 0xFC, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0xF8, 0x80, 0x80, 0x80, 0x82,
  0x84, 0x84, 0x88, 0xF0, 0x98, 0x88, 0x84, 0x86, 0x83, 0xF0, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xF8,
  0xB7, 0xC9, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xBD, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x79, 0x0A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x84, 0xF8, 0xBD, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85,
  0xFA, 0x04, 0x08, 0x00, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86,
  0xF4, 0x08, 0x10, 0x20, 0xBD, 0x86, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81,
  0x00, 0x7D, 0x06, 0x04, 0x07, 0x01, 0x80, 0x81, 0x82, 0xF8, 0x10, 0x10,
  0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xF8, 0x81, 0x41, 0x41, 0x22,
  0x22, 0x22, 0x14, 0x14, 0x14, 0x08, 0x88, 0xCC, 0x65, 0x32, 0xA5, 0x52,
  0xA9, 0x54, 0xCA, 0x62, 0x31, 0x00, 0x41, 0x22, 0x22, 0x14, 0x08, 0x18,
  0x14, 0x22, 0x42, 0xC1, 0xC1, 0x41, 0x41, 0x22, 0x22, 0x24, 0x14, 0x14,
  0x08, 0x08, 0x08, 0x10, 0x10, 0xFE, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20,
  0x81, 0xFC, 0x0E, 0x30, 0x40, 0x81, 0x02, 0x02, 0x08, 0xE0, 0x20, 0x20,
  0x81, 0x02, 0x04, 0x0C, 0x0E, 0xFF, 0xFF, 0x80, 0xC0, 0x40, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x1E, 0x40, 0x81, 0x02, 0x04, 0x04, 0x10, 0xE0, 0xE3,
  0x26, 0x38,
};

const GFXglyph JetBrainsMono_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -13 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 7, 19, 11, 2, -16 },
  { 42, 10, 13, 11, 0, -13 },
  { 59, 9, 13, 11, 1, -13 },
  { 74, 1, 5, 11, 5, -13 },
  { 75, 5, 17, 11, 4, -15 },
  { 86, 5, 17, 11, 2, -15 },
  { 97, 9, 9, 11, 1, -11 },
  { 108, 8, 8, 11, 1, -10 },
  { 116, 3, 6, 11, 3, -3 },
  { 119, 5, 1, 11, 3, -6 },
  { 120, 3, 2, 11, 4, -2 },
  { 121, 7, 17, 11, 2, -15 },
  { 136, 7, 13, 11, 2, -13 },
  { 148, 8, 13, 11, 2, -13 },
  { 161, 8, 13, 11, 2, -13 },
  { 174, 7, 13, 11, 2, -13 },
  { 186, 7, 13, 11, 2, -13 },
  { 198, 7, 13, 11, 2, -13 },
  { 210, 7, 13, 11, 2, -13 },
  { 222, 7, 13, 11, 2, -13 },
  { 234, 7, 13, 11, 2, -13 },
  { 246, 7, 13, 11, 2, -13 },
  { 258, 3, 10, 11, 4, -10 },
  { 262, 4, 13, 11, 3, -10 },
  { 269, 7, 9, 11, 2, -10 },
  { 277, 7, 4, 11, 2, -8 },
  { 281, 7, 9, 11, 2, -10 },
  { 289, 6, 13, 11, 3, -13 },
  { 299, 9, 16, 11, 1, -13 },
  { 317, 9, 13, 11, 1, -13 },
  { 332, 7, 13, 11, 2, -13 },
  { 344, 7, 13, 11, 2, -13 },
  { 356, 7, 13, 11, 2, -13 },
  { 368, 7, 13, 11, 2, -13 },
  { 380, 7, 13, 11, 2, -13 },
  { 392, 7, 13, 11, 2, -13 },
  { 404, 7, 13, 11, 2, -13 },
  { 416, 7, 13, 11, 2, -13 },
  { 428, 8, 13, 11, 1, -13 },
  { 441, 8, 13, 11, 2, -13 },
  { 454, 7, 13, 11, 2, -13 },
  { 466, 7, 13, 11, 2, -13 },
  { 478, 7, 13, 11, 2, -13 },
  { 490, 7, 13, 11, 2, -13 },
  { 502, 8, 13, 11, 2, -13 },
  { 515, 7, 16, 11, 2, -13 },
  { 529, 8, 13, 11, 2, -13 },
  { 542, 7, 13, 11, 2, -13 },
  { 554, 9, 13, 11, 1, -13 },
  { 569, 7, 13, 11, 2, -13 },
  { 581, 9, 13, 11, 1, -13 },
  { 596, 9, 13, 11, 1, -13 },
  { 611, 9, 13, 11, 1, -13 },
  { 626, 9, 13, 11, 1, -13 },
  { 641, 7, 13, 11, 2, -13 },
  { 653, 4, 17, 11, 4, -15 },
  { 662, 7, 17, 11, 2, -15 },
  { 677, 4, 17, 11, 3, -15 },
  { 686, 7, 7, 11, 2, -13 },
  { 693, 9, 1, 11, 1, 0 },
  { 695, 3, 2, 11, 4, -14 },
  { 696, 8, 10, 11, 1, -10 },
  { 706, 7, 13, 11, 2, -13 },
  { 718, 7, 10, 11, 2, -10 },
  { 727, 7, 13, 11, 2, -13 },
  { 739, 7, 10, 11, 2, -10 },
  { 748, 8, 13, 11, 1, -13 },
  { 761, 7, 13, 11, 2, -10 },
  { 773, 7, 13, 11, 2, -13 },
  { 785, 8, 14, 11, 2, -14 },
  { 799, 6, 17, 11, 2, -14 },
  { 812, 8, 13, 11, 2, -13 },
  { 825, 9, 13, 11, 1, -13 },
  { 840, 8, 10, 11, 1, -10 },
  { 850, 7, 10, 11, 2, -10 },
  { 859, 7, 10, 11, 2, -10 },
  { 868, 7, 13, 11, 2, -10 },
  { 880, 7, 13, 11, 2, -10 },
  { 892, 7, 10, 11, 2, -10 },
  { 901, 7, 10, 11, 2, -10 },
  { 910, 8, 13, 11, 1, -13 },
  { 923, 7, 10, 11, 2, -10 },
  { 932, 8, 10, 11, 1, -10 },
  { 942, 9, 10, 11, 1, -10 },
  { 954, 8, 10, 11, 1, -10 },
  { 964, 8, 13, 11, 1, -10 },
  { 977, 7, 10, 11, 2, -10 },
  { 986, 7, 17, 11, 2, -15 },
  { 1001, 1, 17, 11, 5, -15 },
  { 1004, 7, 17, 11, 2, -15 },
  { 1019, 7, 3, 11, 2, -8 },
};

const GFXfont JetBrainsMono_Thin18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_THIN18PT7B_H_
