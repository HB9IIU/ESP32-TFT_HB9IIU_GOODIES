#ifndef _JETBRAINSMONO_THIN23PT7B_H_
#define _JETBRAINSMONO_THIN23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0xAA, 0x03, 0xC0, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x40,
  0x08, 0x20, 0x84, 0x08, 0x40, 0x84, 0x08, 0x47, 0xFF, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x20, 0x8F, 0xFE, 0x21, 0x02, 0x10, 0x21, 0x04, 0x10,
  0x43, 0x00, 0x04, 0x01, 0x00, 0x40, 0x78, 0x65, 0x91, 0x2C, 0x4F, 0x10,
  0x44, 0x19, 0x03, 0x40, 0x78, 0x05, 0x01, 0x20, 0x4C, 0x11, 0x84, 0x71,
  0x34, 0x48, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x38, 0x0A, 0x20, 0x90, 0x84,
  0x84, 0x44, 0x24, 0x23, 0x21, 0x92, 0x07, 0x20, 0x02, 0x00, 0x13, 0x01,
  0x24, 0x12, 0x10, 0x90, 0x88, 0x84, 0x84, 0x24, 0x31, 0xC0, 0xF0, 0x0F,
  0x03, 0x18, 0x20, 0x82, 0x08, 0x20, 0x02, 0x00, 0x10, 0x03, 0x80, 0x6C,
  0x14, 0x42, 0x42, 0x6C, 0x34, 0xC1, 0xC4, 0x08, 0x41, 0x44, 0x32, 0x3E,
  0x30, 0xFF, 0xF8, 0x0C, 0xC6, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0xC1, 0x06, 0x0C, 0x1C, 0x10, 0xC1, 0x81, 0x02, 0x08,
  0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x21, 0x8C, 0xE2,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x08, 0x60, 0xE4, 0x73, 0xDC, 0x06, 0x00,
  0xA0, 0x09, 0x01, 0x18, 0x30, 0xC2, 0x08, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x32, 0x66, 0x44,
  0x80, 0xFF, 0xEF, 0xE0, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x00, 0x1E, 0x18, 0x64, 0x0B,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x23, 0x8C, 0xE3, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x34, 0x09, 0x86, 0x3F, 0x00, 0x0C, 0x07, 0x02, 0x43, 0x10, 0x84,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xFF, 0xC0, 0x3E, 0x18, 0x6C, 0x0A, 0x03, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xFF, 0xC0, 0x7F, 0x80, 0x40, 0x40, 0x40, 0x40, 0x60, 0x70, 0x0E, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x0C, 0x07, 0x02, 0x82, 0x3E, 0x00, 0x01, 0x01,
  0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x61, 0x20, 0xA0, 0x70, 0x30, 0x1F,
  0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x05, 0xF1, 0x86, 0x40, 0x90, 0x20, 0x08, 0x03, 0x00, 0xA0, 0x24,
  0x09, 0x86, 0x3F, 0x00, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02,
  0x01, 0x7C, 0x61, 0xB0, 0x28, 0x0E, 0x01, 0x80, 0x60, 0x3C, 0x09, 0x86,
  0x3F, 0x00, 0xFF, 0xE0, 0x18, 0x0E, 0x02, 0x80, 0x80, 0x60, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x00,
  0x1E, 0x18, 0x64, 0x0B, 0x03, 0x40, 0xD0, 0x26, 0x18, 0x48, 0x1C, 0x0C,
  0xC4, 0x0B, 0x02, 0x80, 0x60, 0x1C, 0x09, 0x06, 0x3F, 0x00, 0x1E, 0x18,
  0x64, 0x0A, 0x03, 0x80, 0x60, 0x18, 0x07, 0x03, 0x41, 0x8F, 0xE0, 0x10,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x6F, 0xE0, 0x00, 0x00,
  0x00, 0x6F, 0xE0, 0x33, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x46, 0x31,
  0x08, 0x80, 0x00, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x00, 0xF8, 0x0C, 0x02, 0x02, 0x03, 0x02, 0x02, 0x06, 0x3C,
  0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x60, 0x60, 0x0F, 0x83, 0x0C, 0x20,
  0x64, 0x02, 0x40, 0x24, 0x03, 0x43, 0xFC, 0x43, 0xC4, 0x3C, 0x43, 0xC4,
  0x3C, 0x43, 0xC4, 0x3C, 0x43, 0x46, 0x74, 0x3B, 0x40, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x58, 0x12, 0x04, 0x83,
  0x20, 0x8C, 0x21, 0x08, 0x44, 0x11, 0xFE, 0x40, 0x90, 0x28, 0x0E, 0x01,
  0x80, 0x40, 0xFC, 0x43, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC,
  0x41, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x05, 0x06, 0xFC, 0x00, 0x1E, 0x18,
  0x64, 0x09, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x34, 0x09, 0x86, 0x3F, 0x00, 0xF8, 0x86, 0x83, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x86,
  0xFC, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x1E, 0x18, 0x64, 0x09, 0x03, 0xC0, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x31, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x34, 0x09,
  0x86, 0x3F, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x18, 0x0C, 0x06, 0x07, 0x82, 0x3E, 0x00, 0x80, 0xC0, 0xE0,
  0x50, 0x68, 0x24, 0x32, 0x11, 0x18, 0xF8, 0x46, 0x21, 0x10, 0xC8, 0x24,
  0x1A, 0x05, 0x03, 0x80, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF,
  0x80, 0xC0, 0xF0, 0x5A, 0x16, 0x85, 0xA2, 0x64, 0x99, 0x26, 0x31, 0x8C,
  0x63, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x81,
  0xC1, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85,
  0x85, 0x83, 0x83, 0x83, 0x1E, 0x30, 0x90, 0x28, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x05, 0x02, 0xC3, 0x3F, 0x00,
  0xFC, 0x41, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xFF, 0x7C, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1E, 0x18, 0x44, 0x09,
  0x02, 0xC0, 0xB0, 0x2C, 0x0B, 0x02, 0xC0, 0xB0, 0x2C, 0x0B, 0x02, 0xC0,
  0xB0, 0x24, 0x09, 0x86, 0x3F, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0xFC,
  0x41, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x02, 0xFE, 0x44, 0x21, 0x10,
  0x88, 0x24, 0x12, 0x05, 0x02, 0x80, 0x80, 0x1E, 0x18, 0x64, 0x0B, 0x03,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x1E, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x1C, 0x0D, 0x86, 0x3F, 0x00, 0xFF, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0A, 0x05, 0x02, 0xC3, 0x3F,
  0x00, 0x80, 0x60, 0x18, 0x0F, 0x02, 0x40, 0x90, 0x24, 0x18, 0x84, 0x21,
  0x08, 0x43, 0x20, 0x48, 0x12, 0x04, 0x81, 0xC0, 0x30, 0x0C, 0x00, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x62, 0xC6, 0x24, 0xA2, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x94, 0x71, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x40, 0x26, 0x04, 0x20, 0x43, 0x08, 0x10, 0x80, 0x90, 0x0B, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x09, 0x01, 0x90, 0x10, 0x82, 0x0C, 0x20, 0x44,
  0x06, 0xC0, 0x30, 0x80, 0x34, 0x02, 0x40, 0x62, 0x04, 0x20, 0xC1, 0x08,
  0x11, 0x80, 0x90, 0x0B, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xFF, 0x80, 0x20, 0x08, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03,
  0x00, 0xFF, 0xC0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x0F, 0xFC, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0xFC, 0x0C,
  0x03, 0x01, 0xE0, 0x48, 0x32, 0x08, 0x42, 0x11, 0x06, 0xC0, 0xC0, 0xFF,
  0xE0, 0x88, 0x80, 0x1E, 0x10, 0x90, 0x38, 0x10, 0x08, 0x05, 0xFF, 0x81,
  0x80, 0xC0, 0x60, 0x38, 0x37, 0xE8, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xBE, 0x1E,
  0x08, 0x44, 0x09, 0x02, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x24,
  0x09, 0x86, 0x3F, 0x00, 0x00, 0x80, 0x40, 0x20, 0x11, 0xCB, 0x1D, 0x02,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x05, 0x02, 0xC3, 0x3E, 0x80,
  0x1E, 0x10, 0x90, 0x28, 0x1C, 0x0E, 0x07, 0xFF, 0x80, 0xC0, 0x60, 0x10,
  0x2C, 0x33, 0xF0, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x1C, 0xB1, 0xD0, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0,
  0x58, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x03, 0x3F, 0x00, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x04, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F,
  0xF0, 0x03, 0x03, 0x03, 0x00, 0x00, 0x7F, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06, 0xFC, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x0A, 0x0D, 0x0C, 0x84, 0x44, 0x3E, 0x11,
  0x88, 0x44, 0x32, 0x0D, 0x02, 0x81, 0x80, 0xF8, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x07, 0xE0, 0xB3, 0xB3, 0x38, 0xC6, 0x21,
  0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x40,
  0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x1E, 0x10, 0x90, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x50, 0x2C, 0x33, 0xF0, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0xBE, 0x80, 0x80, 0x80, 0x80, 0x1C, 0xB1, 0xD0,
  0x28, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x50, 0x2C, 0x33, 0xE8,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x9E, 0x51, 0xB0, 0x50, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x3E, 0x18, 0x64, 0x0B,
  0x01, 0x40, 0x18, 0x03, 0xF0, 0x06, 0x00, 0x80, 0x18, 0x0D, 0x02, 0x3F,
  0x00, 0x10, 0x04, 0x01, 0x03, 0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x3E, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0, 0x50, 0x2C, 0x33, 0xF0,
  0x80, 0x60, 0x34, 0x09, 0x02, 0x41, 0x88, 0x42, 0x10, 0x8C, 0x12, 0x04,
  0x81, 0x40, 0x30, 0x0C, 0x00, 0x86, 0x18, 0x62, 0x46, 0x24, 0x62, 0x4A,
  0x24, 0x92, 0x49, 0x24, 0x94, 0x29, 0x42, 0x94, 0x31, 0x43, 0x0C, 0x30,
  0xC0, 0x80, 0xD0, 0x26, 0x10, 0x8C, 0x12, 0x03, 0x00, 0xC0, 0x30, 0x12,
  0x08, 0xC6, 0x11, 0x02, 0x80, 0xC0, 0x80, 0x60, 0x34, 0x09, 0x02, 0x61,
  0x08, 0x42, 0x10, 0x48, 0x12, 0x07, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30,
  0x10, 0x10, 0x10, 0x18, 0x08, 0x0F, 0xF8, 0x03, 0xC1, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0x80, 0x30, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xC0, 0x30, 0xFF,
  0xFF, 0xFC, 0xF0, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x7C, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0xF0, 0x30, 0x00, 0x70, 0x62, 0x18, 0x46, 0x0E,
};

const GFXglyph JetBrainsMono_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 6, 7, 14, 4, -17 },
  { 12, 12, 17, 14, 1, -17 },
  { 38, 10, 23, 14, 2, -20 },
  { 67, 13, 17, 14, 0, -17 },
  { 95, 12, 17, 14, 1, -17 },
  { 121, 2, 7, 14, 6, -17 },
  { 123, 6, 22, 14, 5, -19 },
  { 140, 6, 22, 14, 3, -19 },
  { 157, 12, 12, 14, 1, -14 },
  { 175, 10, 11, 14, 2, -13 },
  { 189, 4, 7, 14, 4, -3 },
  { 193, 8, 1, 14, 3, -8 },
  { 194, 4, 3, 14, 5, -3 },
  { 196, 10, 22, 14, 2, -19 },
  { 224, 10, 17, 14, 2, -17 },
  { 246, 10, 17, 14, 2, -17 },
  { 268, 10, 17, 14, 2, -17 },
  { 290, 9, 17, 14, 2, -17 },
  { 310, 9, 17, 14, 2, -17 },
  { 330, 10, 17, 14, 2, -17 },
  { 352, 10, 17, 14, 2, -17 },
  { 374, 10, 17, 14, 2, -17 },
  { 396, 10, 17, 14, 2, -17 },
  { 418, 10, 17, 14, 2, -17 },
  { 440, 4, 13, 14, 5, -13 },
  { 447, 5, 17, 14, 4, -13 },
  { 458, 10, 11, 14, 2, -13 },
  { 472, 10, 7, 14, 2, -11 },
  { 481, 10, 11, 14, 2, -13 },
  { 495, 8, 17, 14, 4, -17 },
  { 512, 12, 21, 14, 1, -17 },
  { 544, 10, 17, 14, 2, -17 },
  { 566, 9, 17, 14, 3, -17 },
  { 586, 10, 17, 14, 2, -17 },
  { 608, 8, 17, 14, 3, -17 },
  { 625, 9, 17, 14, 3, -17 },
  { 645, 9, 17, 14, 3, -17 },
  { 665, 10, 17, 14, 2, -17 },
  { 687, 8, 17, 14, 3, -17 },
  { 704, 8, 17, 14, 3, -17 },
  { 721, 9, 17, 14, 2, -17 },
  { 741, 9, 17, 14, 3, -17 },
  { 761, 9, 17, 14, 3, -17 },
  { 781, 10, 17, 14, 2, -17 },
  { 803, 8, 17, 14, 3, -17 },
  { 820, 9, 17, 14, 2, -17 },
  { 840, 9, 17, 14, 3, -17 },
  { 860, 10, 21, 14, 2, -17 },
  { 887, 9, 17, 14, 3, -17 },
  { 907, 10, 17, 14, 2, -17 },
  { 929, 11, 17, 14, 1, -17 },
  { 953, 9, 17, 14, 2, -17 },
  { 973, 10, 17, 14, 2, -17 },
  { 995, 12, 17, 14, 1, -17 },
  { 1021, 12, 17, 14, 1, -17 },
  { 1047, 12, 17, 14, 1, -17 },
  { 1073, 10, 17, 14, 2, -17 },
  { 1095, 5, 22, 14, 5, -19 },
  { 1109, 10, 22, 14, 2, -19 },
  { 1137, 5, 22, 14, 4, -19 },
  { 1151, 10, 9, 14, 2, -17 },
  { 1163, 11, 1, 14, 1, 1 },
  { 1165, 3, 3, 14, 5, -18 },
  { 1167, 9, 13, 14, 2, -13 },
  { 1182, 8, 17, 14, 3, -17 },
  { 1199, 10, 13, 14, 2, -13 },
  { 1216, 9, 17, 14, 2, -17 },
  { 1236, 9, 13, 14, 2, -13 },
  { 1251, 10, 17, 14, 2, -17 },
  { 1273, 9, 17, 14, 2, -13 },
  { 1293, 8, 17, 14, 3, -17 },
  { 1310, 10, 18, 14, 2, -18 },
  { 1333, 8, 22, 14, 2, -18 },
  { 1355, 9, 17, 14, 3, -17 },
  { 1375, 11, 17, 14, 1, -17 },
  { 1399, 10, 13, 14, 2, -13 },
  { 1416, 8, 13, 14, 3, -13 },
  { 1429, 9, 13, 14, 2, -13 },
  { 1444, 8, 17, 14, 3, -13 },
  { 1461, 9, 17, 14, 2, -13 },
  { 1481, 9, 13, 14, 3, -13 },
  { 1496, 10, 13, 14, 2, -13 },
  { 1513, 10, 16, 14, 2, -16 },
  { 1533, 9, 13, 14, 2, -13 },
  { 1548, 10, 13, 14, 2, -13 },
  { 1565, 12, 13, 14, 1, -13 },
  { 1585, 10, 13, 14, 2, -13 },
  { 1602, 10, 17, 14, 2, -13 },
  { 1624, 9, 13, 14, 2, -13 },
  { 1639, 10, 22, 14, 2, -19 },
  { 1667, 1, 22, 14, 6, -19 },
  { 1670, 10, 22, 14, 2, -19 },
  { 1698, 10, 4, 14, 2, -10 },
};

const GFXfont JetBrainsMono_Thin23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_THIN23PT7B_H_
