#ifndef _JETBRAINSMONO_THIN47PT7B_H_
#define _JETBRAINSMONO_THIN47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0x80, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x18, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x70, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xEF, 0x81, 0xC6, 0x1C, 0x38, 0x60, 0xE7, 0x06,
  0x0E, 0x70, 0x60, 0x66, 0x06, 0x07, 0x60, 0x60, 0x76, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x86, 0x00, 0x1C, 0x60, 0x00,
  0xF6, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x06, 0x78,
  0x00, 0x61, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x60,
  0x30, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xE0, 0x60, 0x3E, 0x06,
  0x07, 0x70, 0x60, 0x67, 0x86, 0x0E, 0x3C, 0x63, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x33, 0xDE, 0x00, 0x19, 0xC1, 0xC0, 0x0C, 0x60, 0x30, 0x07, 0x18,
  0x0C, 0x01, 0x86, 0x03, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x06, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x30,
  0xC0, 0x1C, 0x1C, 0x60, 0x03, 0xFE, 0x38, 0x00, 0x7F, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x30, 0xFE, 0x00, 0x1C, 0x7B, 0xC0, 0x06, 0x38, 0x18, 0x03, 0x0C,
  0x06, 0x01, 0x83, 0x01, 0xC0, 0x60, 0xC0, 0x30, 0x30, 0x30, 0x0C, 0x18,
  0x0C, 0x03, 0x06, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x31, 0x80, 0x30, 0x1C,
  0xE0, 0x0C, 0x06, 0x30, 0x01, 0x83, 0x98, 0x00, 0x7F, 0xCC, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x00, 0x38, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC3, 0x80, 0x3F, 0x03, 0x80, 0x6E, 0x03,
  0x81, 0x98, 0x03, 0x07, 0x30, 0x07, 0x0C, 0x60, 0x07, 0x38, 0xC0, 0x07,
  0x61, 0x80, 0x07, 0xC3, 0x00, 0x0F, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1E,
  0x1C, 0x00, 0x7C, 0x38, 0x01, 0xDC, 0x38, 0x07, 0x1C, 0x78, 0x1C, 0x1C,
  0x7F, 0xF0, 0x18, 0x7F, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0x80,
  0x00, 0x38, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0x80, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x18, 0x07,
  0xFC, 0x18, 0x3F, 0x3F, 0x99, 0xFE, 0x0F, 0xFB, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x04, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x1E, 0x1E, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x38, 0x01,
  0xC7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x06, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E,
  0x07, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x07, 0x80, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x01,
  0xE7, 0x00, 0x3C, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0C, 0x07, 0x00,
  0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xC3,
  0xE0, 0x70, 0x03, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x03,
  0x8E, 0x00, 0x71, 0xE0, 0x3C, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x70, 0x07, 0x18, 0x01,
  0xCE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x10, 0x0E, 0x3F, 0xE1, 0xDF, 0xFE,
  0x3F, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00, 0x1D,
  0xC0, 0x03, 0x9C, 0x00, 0xE1, 0xC0, 0x38, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC7, 0x80, 0x1B,
  0xFF, 0x03, 0xF9, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x0E, 0x70, 0x00, 0xE6,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x67, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E,
  0x00, 0x07, 0x70, 0x00, 0x33, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0x9F, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00,
  0x66, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x63, 0x00,
  0x0E, 0x38, 0x00, 0xC1, 0xC0, 0x1C, 0x0E, 0x07, 0x80, 0x78, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xDE, 0x00, 0xF0, 0x70, 0x1C, 0x03, 0x83,
  0x80, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0x67, 0x80, 0x0E, 0x3C, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x81, 0xC0, 0x3C, 0x38, 0x00, 0xC7,
  0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x76, 0x00, 0x07, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x03, 0xC0, 0xFF,
  0xFC, 0x07, 0xF9, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x79, 0xFB, 0xF7, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xBF, 0x7F,
  0xFC, 0xF8, 0x1F, 0x1F, 0x8F, 0xE7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xF0, 0x1F, 0xE0, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x78, 0xF8, 0x03, 0xFD, 0xF0, 0x0F,
  0x1F, 0xE0, 0x38, 0x0F, 0xC0, 0x60, 0x0F, 0x80, 0xC0, 0x1F, 0x01, 0x80,
  0x3E, 0x03, 0x00, 0x7C, 0x06, 0x00, 0xF8, 0x0C, 0x01, 0xF0, 0x18, 0x03,
  0xE0, 0x30, 0x07, 0xC0, 0x60, 0x0F, 0x80, 0xC0, 0x1F, 0x01, 0x80, 0x3E,
  0x03, 0x00, 0x7C, 0x07, 0x01, 0xF8, 0x0F, 0x07, 0xF0, 0x0F, 0xFB, 0xE0,
  0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x38, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x18, 0x00, 0x60, 0x60, 0x01, 0xC3, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0x80, 0x3C, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x37, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00,
  0x6E, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1C, 0x07, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0xFC,
  0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7C, 0x7C,
  0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x36, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x80, 0x1C, 0x3C, 0x07, 0x83,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0E, 0x01, 0xE3,
  0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00,
  0xEE, 0x00, 0x73, 0x80, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1C,
  0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x36, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x80, 0x1C, 0x3C, 0x07, 0x83, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00,
  0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xE0,
  0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x60, 0xE0,
  0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0xCE,
  0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xFD,
  0x80, 0x0F, 0xD8, 0x01, 0xBD, 0x80, 0x1B, 0xCC, 0x01, 0xBE, 0xC0, 0x33,
  0xEC, 0x03, 0x3E, 0x60, 0x23, 0xE6, 0x06, 0x3E, 0x20, 0x63, 0xE3, 0x0C,
  0x3E, 0x30, 0xC3, 0xE1, 0x8C, 0x3E, 0x19, 0x83, 0xE1, 0x98, 0x3E, 0x0D,
  0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0x60, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x60, 0x03, 0xD8, 0x00, 0xF3, 0x00, 0x3C,
  0xC0, 0x0F, 0x30, 0x03, 0xC6, 0x00, 0xF1, 0x80, 0x3C, 0x30, 0x0F, 0x0C,
  0x03, 0xC3, 0x00, 0xF0, 0x60, 0x3C, 0x18, 0x0F, 0x03, 0x03, 0xC0, 0xC0,
  0xF0, 0x30, 0x3C, 0x06, 0x0F, 0x01, 0x83, 0xC0, 0x70, 0xF0, 0x0C, 0x3C,
  0x03, 0x0F, 0x00, 0x63, 0xC0, 0x18, 0xF0, 0x07, 0x3C, 0x00, 0xCF, 0x00,
  0x33, 0xC0, 0x06, 0xF0, 0x01, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0xE0, 0x1C,
  0x70, 0x03, 0x98, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x76, 0x00,
  0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE,
  0x00, 0x1C, 0xE0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x7C, 0xF8, 0x1C, 0x03, 0x87, 0x00, 0x38, 0xC0,
  0x03, 0x38, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03, 0x98, 0x00,
  0x63, 0x80, 0x1C, 0x38, 0x07, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0,
  0x07, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0x9F, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0x66, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x70, 0x00,
  0x67, 0x80, 0x0E, 0x3C, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0x60, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x38, 0xF0, 0x1C, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00,
  0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x0C,
  0x00, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x70, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x0E, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x07,
  0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x34, 0x03,
  0xE0, 0x34, 0x03, 0x60, 0x36, 0x07, 0x60, 0x36, 0x06, 0x60, 0x26, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x70, 0x62, 0x06,
  0x70, 0x62, 0x06, 0x30, 0x63, 0x06, 0x30, 0x43, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x0C, 0x38, 0xC1, 0x0C,
  0x38, 0x81, 0x8C, 0x18, 0x81, 0x8C, 0x19, 0x81, 0x98, 0x19, 0x81, 0x98,
  0x19, 0x81, 0x98, 0x19, 0x81, 0x98, 0x19, 0x80, 0x98, 0x1D, 0x00, 0xD8,
  0x1D, 0x00, 0xD8, 0x0F, 0x00, 0xD8, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x18,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x0E,
  0x70, 0x01, 0x86, 0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x01, 0x81, 0xC0, 0x70,
  0x18, 0x0C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x0C, 0xE0, 0x01, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x78, 0x0E, 0x1C, 0x00, 0xE3, 0x00, 0x0C, 0xE0, 0x01, 0xDC, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xDC,
  0x00, 0x7B, 0xC0, 0x3B, 0x3F, 0xFE, 0x61, 0xFF, 0x0C, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE3, 0xFC, 0x3B, 0xFF, 0x8F, 0xC0, 0x73, 0xC0, 0x0E,
  0xF0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x6F, 0x00, 0x3B, 0xF0, 0x1C, 0xEF, 0xFE, 0x39,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xF0, 0x1C, 0x38, 0x01, 0xC6,
  0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x70,
  0x00, 0x6E, 0x00, 0x0C, 0xC0, 0x03, 0x9C, 0x00, 0xE1, 0xE0, 0x38, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x07, 0xF0,
  0xC7, 0xFF, 0x33, 0x80, 0xED, 0xC0, 0x0B, 0x60, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x77,
  0x00, 0x3C, 0xE0, 0x1B, 0x1F, 0xFC, 0xC3, 0xFE, 0x30, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xC0, 0x71, 0xC0, 0x0E, 0x60, 0x01, 0xB8, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x77, 0x00,
  0x38, 0xE0, 0x1C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0xC7, 0xFF, 0x33, 0x80,
  0xED, 0xC0, 0x0B, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1D, 0xC0, 0x0F, 0x70, 0x02, 0xCF, 0x03, 0xB1, 0xFF, 0xCC, 0x1F, 0xC3,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE3, 0xFC, 0x3B, 0xFF, 0x8F, 0xC0, 0x73,
  0xE0, 0x0E, 0xF0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x70,
  0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xE0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0xCF, 0x87, 0xCD, 0xFC, 0xFE, 0xE0, 0xF8, 0x7E,
  0x0F, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03,
  0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xE3, 0xFC, 0x3B,
  0xFF, 0x8E, 0xC0, 0x73, 0xE0, 0x0E, 0xF0, 0x01, 0xB8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x30, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xC0, 0xF1, 0xC0, 0x0E, 0x60, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x38,
  0xE0, 0x1C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xE3, 0xFC, 0x3B, 0xFF, 0x8F,
  0xC0, 0x73, 0xC0, 0x0E, 0xF0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x6F, 0x00, 0x3B, 0xF0,
  0x1C, 0xEF, 0xFE, 0x38, 0xFF, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xF0, 0xC7, 0xFF, 0x33, 0x80, 0xED, 0xC0, 0x0B, 0x60, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xD8,
  0x00, 0x77, 0x00, 0x3C, 0xE0, 0x1B, 0x1F, 0xFC, 0xC3, 0xFE, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0xC3, 0xFC, 0x33, 0xFF, 0x8D, 0xC0, 0xF3,
  0x40, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3C, 0x03, 0xC3,
  0x80, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x07, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70,
  0x00, 0xE3, 0x80, 0x1E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0xDC,
  0x00, 0x67, 0x00, 0x38, 0xF0, 0x1C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xB8, 0x00, 0x1C, 0xC0, 0x00, 0xC7, 0x00, 0x06,
  0x38, 0x00, 0x70, 0xC0, 0x03, 0x07, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0,
  0x0C, 0x07, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x80,
  0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3,
  0x00, 0x07, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x18, 0x03, 0x60,
  0x1C, 0x07, 0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x34, 0x06, 0x70,
  0x34, 0x06, 0x70, 0x26, 0x06, 0x30, 0x26, 0x0E, 0x30, 0x66, 0x0C, 0x30,
  0x66, 0x0C, 0x30, 0x62, 0x0C, 0x30, 0x63, 0x0C, 0x38, 0x43, 0x0C, 0x18,
  0xC3, 0x1C, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC1, 0x98, 0x18,
  0x81, 0x98, 0x1D, 0x81, 0x98, 0x0D, 0x81, 0xB8, 0x0D, 0x81, 0xB0, 0x0D,
  0x80, 0xB0, 0x0D, 0x00, 0xF0, 0x0D, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0xF0, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x70, 0x03,
  0x81, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0xE0, 0xC0, 0x03,
  0x0C, 0x00, 0x1C, 0xE0, 0x00, 0x76, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x33, 0x00, 0x03, 0x8C, 0x00, 0x38,
  0x70, 0x01, 0x81, 0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x38, 0x0C, 0x00, 0xE0,
  0xE0, 0x03, 0x0E, 0x00, 0x1C, 0x60, 0x00, 0x77, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x0E,
  0x18, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xE0,
  0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80,
  0x1C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0x67,
  0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x37,
  0xF8, 0x03, 0x61, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x03, 0x83,
  0xC0, 0x1C, 0x7C, 0x00, 0xFE, 0xC0, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 5, 34, 28, 12, -34 },
  { 23, 12, 14, 28, 8, -34 },
  { 44, 25, 34, 28, 2, -34 },
  { 151, 20, 48, 28, 4, -41 },
  { 271, 26, 35, 28, 1, -35 },
  { 385, 23, 35, 28, 3, -35 },
  { 486, 3, 14, 28, 13, -34 },
  { 492, 13, 45, 28, 10, -39 },
  { 566, 14, 45, 28, 5, -39 },
  { 645, 24, 24, 28, 2, -29 },
  { 717, 21, 22, 28, 4, -27 },
  { 775, 8, 15, 28, 9, -7 },
  { 790, 15, 3, 28, 7, -17 },
  { 796, 7, 6, 28, 11, -6 },
  { 802, 20, 44, 28, 4, -39 },
  { 912, 20, 35, 28, 4, -35 },
  { 1000, 20, 34, 28, 5, -34 },
  { 1085, 21, 35, 28, 4, -35 },
  { 1177, 19, 34, 28, 4, -34 },
  { 1258, 18, 34, 28, 5, -34 },
  { 1335, 19, 34, 28, 5, -34 },
  { 1416, 20, 34, 28, 4, -34 },
  { 1501, 21, 34, 28, 4, -34 },
  { 1591, 20, 35, 28, 4, -35 },
  { 1679, 20, 35, 28, 4, -35 },
  { 1767, 7, 26, 28, 11, -26 },
  { 1790, 9, 34, 28, 9, -26 },
  { 1829, 20, 23, 28, 4, -27 },
  { 1887, 20, 13, 28, 4, -22 },
  { 1920, 20, 23, 28, 4, -27 },
  { 1978, 16, 34, 28, 8, -34 },
  { 2046, 23, 43, 28, 3, -35 },
  { 2170, 22, 34, 28, 3, -34 },
  { 2264, 19, 34, 28, 5, -34 },
  { 2345, 19, 35, 28, 5, -35 },
  { 2429, 18, 34, 28, 5, -34 },
  { 2506, 18, 34, 28, 6, -34 },
  { 2583, 20, 34, 28, 5, -34 },
  { 2668, 19, 35, 28, 5, -35 },
  { 2752, 18, 34, 28, 5, -34 },
  { 2829, 17, 34, 28, 6, -34 },
  { 2902, 20, 34, 28, 3, -34 },
  { 2987, 20, 34, 28, 5, -34 },
  { 3072, 19, 34, 28, 6, -34 },
  { 3153, 20, 34, 28, 4, -34 },
  { 3238, 18, 34, 28, 5, -34 },
  { 3315, 18, 35, 28, 5, -35 },
  { 3394, 20, 34, 28, 5, -34 },
  { 3479, 19, 43, 28, 5, -35 },
  { 3582, 20, 34, 28, 5, -34 },
  { 3667, 20, 35, 28, 4, -35 },
  { 3755, 22, 34, 28, 3, -34 },
  { 3849, 18, 34, 28, 5, -34 },
  { 3926, 22, 34, 28, 3, -34 },
  { 4020, 24, 34, 28, 2, -34 },
  { 4122, 24, 34, 28, 2, -34 },
  { 4224, 24, 34, 28, 2, -34 },
  { 4326, 20, 34, 28, 4, -34 },
  { 4411, 11, 44, 28, 10, -39 },
  { 4472, 20, 44, 28, 4, -39 },
  { 4582, 11, 44, 28, 7, -39 },
  { 4643, 19, 18, 28, 5, -34 },
  { 4686, 22, 2, 28, 3, 1 },
  { 4692, 8, 7, 28, 9, -37 },
  { 4699, 19, 26, 28, 4, -26 },
  { 4761, 18, 34, 28, 5, -34 },
  { 4838, 19, 26, 28, 5, -26 },
  { 4900, 18, 34, 28, 5, -34 },
  { 4977, 18, 26, 28, 5, -26 },
  { 5036, 22, 34, 28, 3, -34 },
  { 5130, 18, 34, 28, 5, -26 },
  { 5207, 18, 34, 28, 5, -34 },
  { 5284, 21, 36, 28, 4, -36 },
  { 5379, 17, 44, 28, 4, -36 },
  { 5473, 20, 34, 28, 5, -34 },
  { 5558, 23, 34, 28, 2, -34 },
  { 5656, 20, 26, 28, 4, -26 },
  { 5721, 18, 26, 28, 5, -26 },
  { 5780, 18, 26, 28, 5, -26 },
  { 5839, 18, 34, 28, 5, -26 },
  { 5916, 18, 34, 28, 5, -26 },
  { 5993, 18, 26, 28, 6, -26 },
  { 6052, 20, 26, 28, 4, -26 },
  { 6117, 21, 33, 28, 3, -33 },
  { 6204, 18, 26, 28, 5, -26 },
  { 6263, 21, 26, 28, 4, -26 },
  { 6332, 24, 26, 28, 2, -26 },
  { 6410, 21, 26, 28, 4, -26 },
  { 6479, 21, 34, 28, 4, -26 },
  { 6569, 18, 26, 28, 5, -26 },
  { 6628, 19, 44, 28, 5, -39 },
  { 6733, 2, 44, 28, 13, -39 },
  { 6744, 19, 44, 28, 5, -39 },
  { 6849, 20, 9, 28, 4, -21 },
};

const GFXfont JetBrainsMono_Thin47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_THIN47PT7B_H_
