#ifndef _JETBRAINSMONO_THIN13PT7B_H_
#define _JETBRAINSMONO_THIN13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0x99, 0x90, 0x12, 0x49, 0xF9, 0x22, 0x56, 0xD2,
  0x24, 0x48, 0x20, 0xC6, 0xA9, 0xA1, 0x81, 0x89, 0x26, 0x95, 0x88, 0x20,
  0x61, 0x92, 0x94, 0x94, 0x68, 0x14, 0x1A, 0x29, 0x49, 0x8E, 0x31, 0x28,
  0x90, 0x42, 0x99, 0x62, 0x8B, 0xD0, 0xE0, 0x2A, 0x49, 0x24, 0x92, 0x22,
  0xC2, 0x11, 0x11, 0x11, 0x11, 0x16, 0x80, 0x20, 0x8A, 0xDC, 0x31, 0x24,
  0x80, 0x20, 0x8F, 0xC8, 0x20, 0x80, 0x69, 0x40, 0xF0, 0xF0, 0x04, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x31, 0x28, 0x61, 0x86, 0xD8,
  0x61, 0x85, 0xE0, 0x72, 0x41, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x33, 0x28,
  0x41, 0x08, 0x21, 0x08, 0x43, 0xF0, 0xF8, 0x88, 0x60, 0x84, 0x31, 0x78,
  0x18, 0x88, 0x84, 0xC7, 0xE1, 0x08, 0xFA, 0x08, 0x1E, 0x84, 0x10, 0x62,
  0x78, 0x10, 0x84, 0x1C, 0x8A, 0x18, 0x61, 0x78, 0xFE, 0x20, 0x82, 0x10,
  0x41, 0x08, 0x20, 0x31, 0x28, 0x62, 0x51, 0xC8, 0xA1, 0x85, 0xE0, 0x31,
  0x28, 0x61, 0x85, 0xE0, 0x84, 0x10, 0x80, 0xE0, 0x3C, 0x68, 0x00, 0xD2,
  0x80, 0x04, 0x62, 0x30, 0x60, 0x40, 0xC0, 0xFC, 0x0F, 0xC0, 0x81, 0x03,
  0x03, 0x19, 0x88, 0x00, 0xF0, 0x42, 0x26, 0x20, 0x00, 0x40, 0x31, 0x38,
  0x61, 0xBE, 0x9A, 0x69, 0xBE, 0x08, 0x1C, 0x30, 0xC5, 0x12, 0x49, 0xE8,
  0xA1, 0x84, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x61, 0xF8, 0x31, 0x28, 0x60,
  0x82, 0x08, 0x21, 0x85, 0xE0, 0xFC, 0x63, 0x18, 0xC6, 0x31, 0xF0, 0xFC,
  0x21, 0x0F, 0x42, 0x10, 0xF8, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80,
  0x31, 0x28, 0x60, 0x82, 0x78, 0x61, 0x85, 0xE0, 0x8C, 0x63, 0x1F, 0xC6,
  0x31, 0x88, 0xF4, 0x44, 0x44, 0x44, 0x4F, 0x38, 0x42, 0x10, 0x86, 0x31,
  0x70, 0x86, 0x18, 0xA2, 0x93, 0xC9, 0x22, 0x8A, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xF8, 0xCF, 0x3D, 0x6D, 0xA6, 0x18, 0x61, 0x84, 0xCE, 0x6B,
  0x5A, 0xCE, 0x71, 0x88, 0x32, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0xC0, 0xFE,
  0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61,
  0x89, 0xE0, 0x83, 0xFA, 0x18, 0x61, 0xFA, 0x48, 0xA2, 0x84, 0x31, 0x28,
  0x60, 0x60, 0x60, 0x41, 0x85, 0xE0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x86, 0x14, 0x92, 0x49, 0x43,
  0x0C, 0x20, 0xA6, 0xDB, 0x6D, 0xB7, 0x5C, 0x92, 0x48, 0x85, 0x25, 0x0C,
  0x30, 0xC4, 0xA2, 0x84, 0x86, 0x24, 0x94, 0x30, 0x82, 0x08, 0x20, 0xF8,
  0x21, 0x04, 0x20, 0x84, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x81,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x83, 0xE4, 0x92, 0x49, 0x24,
  0xF0, 0x30, 0xC4, 0x92, 0x84, 0xFC, 0x90, 0x7C, 0x42, 0xF8, 0xC5, 0xE0,
  0x84, 0x3F, 0x18, 0xC6, 0x31, 0xF8, 0x7A, 0x18, 0x20, 0x82, 0x17, 0x80,
  0x08, 0x5F, 0x18, 0xC6, 0x31, 0x78, 0x7C, 0x63, 0xF8, 0x45, 0xE0, 0x3C,
  0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x7C, 0x63, 0x18, 0xA4, 0xE1, 0x78,
  0x84, 0x3F, 0x18, 0xC6, 0x31, 0x88, 0x30, 0x00, 0x1C, 0x10, 0x41, 0x04,
  0x13, 0xF0, 0x18, 0x00, 0xF0, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x82, 0x08,
  0xE2, 0x93, 0xC9, 0x22, 0x84, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C,
  0xFE, 0x9A, 0x69, 0xA6, 0x9A, 0x40, 0xFC, 0x63, 0x18, 0xC6, 0x20, 0x7C,
  0x63, 0x18, 0xC5, 0xE0, 0xFC, 0x63, 0x18, 0xC7, 0xF0, 0x80, 0x7C, 0x63,
  0x18, 0xC5, 0xE1, 0x08, 0xF4, 0x63, 0x08, 0x42, 0x00, 0x7A, 0x1C, 0x0E,
  0x06, 0x17, 0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x38, 0x8C, 0x63,
  0x18, 0xC5, 0xE0, 0x86, 0x24, 0x92, 0x50, 0xC2, 0x00, 0xA6, 0xDB, 0x6D,
  0xD5, 0x24, 0x80, 0x8D, 0x23, 0x08, 0x31, 0x28, 0x40, 0x86, 0x24, 0x92,
  0x30, 0xC2, 0x08, 0x20, 0xF8, 0x44, 0x42, 0x23, 0xE0, 0x0C, 0x41, 0x04,
  0x10, 0x4E, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xF0, 0xC0, 0x82, 0x08, 0x20,
  0x81, 0xC8, 0x20, 0x82, 0x38, 0x46, 0x99, 0x80,
};

const GFXglyph JetBrainsMono_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 1, 3, 8, 3, -9 },
  { 43, 3, 13, 8, 3, -11 },
  { 48, 4, 13, 8, 1, -11 },
  { 55, 6, 7, 8, 1, -8 },
  { 61, 6, 6, 8, 1, -7 },
  { 66, 3, 4, 8, 2, -2 },
  { 68, 4, 1, 8, 2, -5 },
  { 69, 2, 2, 8, 3, -2 },
  { 70, 6, 12, 8, 1, -11 },
  { 79, 6, 10, 8, 1, -10 },
  { 87, 6, 9, 8, 1, -9 },
  { 94, 6, 10, 8, 1, -10 },
  { 102, 5, 9, 8, 1, -9 },
  { 108, 5, 9, 8, 1, -9 },
  { 114, 6, 9, 8, 1, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 6, 10, 8, 1, -10 },
  { 151, 2, 7, 8, 3, -7 },
  { 153, 3, 9, 8, 2, -7 },
  { 157, 6, 7, 8, 1, -8 },
  { 163, 6, 3, 8, 1, -6 },
  { 166, 6, 7, 8, 1, -8 },
  { 172, 5, 9, 8, 2, -9 },
  { 178, 6, 12, 8, 1, -10 },
  { 187, 6, 9, 8, 1, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 6, 10, 8, 1, -10 },
  { 209, 5, 9, 8, 1, -9 },
  { 215, 5, 9, 8, 2, -9 },
  { 221, 6, 9, 8, 1, -9 },
  { 228, 6, 10, 8, 1, -10 },
  { 236, 5, 9, 8, 1, -9 },
  { 242, 4, 10, 8, 2, -10 },
  { 247, 5, 9, 8, 1, -9 },
  { 253, 6, 10, 8, 1, -10 },
  { 261, 5, 9, 8, 2, -9 },
  { 267, 6, 9, 8, 1, -9 },
  { 274, 5, 9, 8, 1, -9 },
  { 280, 5, 10, 8, 1, -10 },
  { 287, 6, 9, 8, 1, -9 },
  { 294, 6, 12, 8, 1, -10 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 6, 10, 8, 1, -10 },
  { 318, 6, 9, 8, 1, -9 },
  { 325, 5, 9, 8, 1, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 6, 9, 8, 1, -9 },
  { 345, 6, 9, 8, 1, -9 },
  { 352, 6, 9, 8, 1, -9 },
  { 359, 6, 9, 8, 1, -9 },
  { 366, 3, 12, 8, 3, -11 },
  { 371, 6, 12, 8, 1, -11 },
  { 380, 3, 12, 8, 2, -11 },
  { 385, 6, 5, 8, 1, -9 },
  { 389, 6, 1, 8, 1, 0 },
  { 390, 2, 2, 8, 3, -10 },
  { 391, 5, 7, 8, 1, -7 },
  { 396, 5, 9, 8, 1, -9 },
  { 402, 6, 7, 8, 1, -7 },
  { 408, 5, 9, 8, 1, -9 },
  { 414, 5, 7, 8, 1, -7 },
  { 419, 6, 9, 8, 1, -9 },
  { 426, 5, 9, 8, 1, -7 },
  { 432, 5, 9, 8, 1, -9 },
  { 438, 6, 10, 8, 1, -10 },
  { 446, 5, 12, 8, 1, -10 },
  { 454, 6, 9, 8, 1, -9 },
  { 461, 6, 9, 8, 1, -9 },
  { 468, 6, 7, 8, 1, -7 },
  { 474, 5, 7, 8, 1, -7 },
  { 479, 5, 7, 8, 1, -7 },
  { 484, 5, 9, 8, 1, -7 },
  { 490, 5, 9, 8, 1, -7 },
  { 496, 5, 7, 8, 2, -7 },
  { 501, 6, 7, 8, 1, -7 },
  { 507, 6, 9, 8, 1, -9 },
  { 514, 5, 7, 8, 1, -7 },
  { 519, 6, 7, 8, 1, -7 },
  { 525, 6, 7, 8, 1, -7 },
  { 531, 6, 7, 8, 1, -7 },
  { 537, 6, 9, 8, 1, -7 },
  { 544, 5, 7, 8, 1, -7 },
  { 549, 6, 12, 8, 1, -11 },
  { 558, 1, 12, 8, 3, -11 },
  { 560, 6, 12, 8, 1, -11 },
  { 569, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Thin13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_THIN13PT7B_H_
