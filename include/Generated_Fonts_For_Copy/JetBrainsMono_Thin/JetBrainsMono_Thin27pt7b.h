#ifndef _JETBRAINSMONO_THIN27PT7B_H_
#define _JETBRAINSMONO_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xD9, 0x24, 0x80, 0x1B, 0xF0, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x04, 0x18, 0x10, 0x60, 0x41, 0x01, 0x04, 0x0C,
  0x10, 0x30, 0x47, 0xFF, 0xC2, 0x08, 0x08, 0x20, 0x60, 0x81, 0x82, 0x04,
  0x18, 0x10, 0x43, 0xFF, 0xE1, 0x04, 0x0C, 0x10, 0x20, 0xC0, 0x82, 0x02,
  0x08, 0x18, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xF8, 0x3A, 0xC6, 0x26,
  0x42, 0x24, 0x23, 0x42, 0x06, 0x20, 0x62, 0x03, 0x20, 0x1E, 0x00, 0x38,
  0x02, 0x60, 0x22, 0x02, 0x30, 0x21, 0xC2, 0x1C, 0x23, 0x42, 0x23, 0x26,
  0x1F, 0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x38, 0x07, 0x98, 0x0A,
  0x18, 0x24, 0x10, 0x88, 0x23, 0x10, 0x44, 0x21, 0x90, 0x62, 0x60, 0x7C,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x13, 0xC0, 0x4C, 0xC1, 0x10, 0x86, 0x61,
  0x08, 0xC2, 0x21, 0x84, 0xC1, 0x09, 0x02, 0x34, 0x03, 0xC0, 0x0F, 0x01,
  0xCC, 0x08, 0x30, 0xC0, 0x86, 0x04, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x03, 0xC0, 0x33, 0x07, 0x0C, 0x28, 0x33, 0x40, 0x92, 0x03, 0x90, 0x18,
  0x80, 0xE4, 0x0D, 0x30, 0xC4, 0xFC, 0x30, 0xFF, 0xFF, 0x02, 0x1C, 0x61,
  0x86, 0x18, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x1C, 0x0C, 0x80, 0xE0, 0x38, 0x08,
  0x0C, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x70, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE3, 0x1D, 0xE5, 0xE0, 0xFC, 0x00, 0xC0,
  0x06, 0x80, 0x33, 0x00, 0x86, 0x06, 0x18, 0x30, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x39, 0x8C, 0xC6, 0x21, 0x18, 0xFF, 0xFF, 0x6F, 0xFF,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x00, 0x1F,
  0x0E, 0x73, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71,
  0x8E, 0x31, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x58, 0x19,
  0x86, 0x1F, 0x80, 0x06, 0x03, 0xC0, 0xD8, 0x33, 0x08, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x7F, 0xF0, 0x1F, 0x83, 0x0C, 0x60, 0x64,
  0x02, 0xC0, 0x3C, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x07,
  0xFF, 0x7F, 0xEF, 0xFC, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20,
  0x0F, 0x80, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0E, 0x01, 0x40,
  0x2C, 0x0C, 0xC3, 0x0F, 0xC0, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x16, 0x07, 0x01, 0x80, 0x60, 0x1F, 0xFC,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0xF8, 0xB1, 0x98, 0x1B, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x18, 0x02, 0x80, 0x58, 0x19, 0x86, 0x1F, 0x80, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x27, 0x83,
  0x9C, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x03, 0x40, 0x36,
  0x06, 0x30, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x2C,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x0F, 0x03,
  0x0C, 0x60, 0x66, 0x02, 0x40, 0x34, 0x02, 0x60, 0x22, 0x06, 0x18, 0xC0,
  0xF0, 0x0F, 0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0x40, 0x34,
  0x02, 0x30, 0x61, 0xF8, 0x0F, 0x83, 0x8C, 0x60, 0x64, 0x02, 0xC0, 0x3C,
  0x01, 0xC0, 0x1C, 0x03, 0x40, 0x36, 0x06, 0x30, 0xE1, 0xF4, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x7F, 0xF6,
  0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x7B, 0xDE, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x73, 0x19, 0x8C, 0x42, 0x30, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0xF8,
  0x7F, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x04, 0x02, 0x03, 0x03, 0x1F, 0x0C,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x0F, 0x81,
  0xC7, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x7B, 0x86,
  0x3C, 0x20, 0xE1, 0x07, 0x08, 0x38, 0x41, 0xC2, 0x0E, 0x10, 0x70, 0x83,
  0x86, 0x1C, 0x1F, 0xE0, 0x21, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x06, 0x00, 0x60, 0x07, 0x00, 0xD0, 0x09, 0x00, 0x90,
  0x09, 0x81, 0x88, 0x10, 0x81, 0x08, 0x30, 0xC2, 0x04, 0x20, 0x43, 0xFE,
  0x60, 0x64, 0x02, 0x40, 0x24, 0x03, 0xC0, 0x18, 0x01, 0xFC, 0x1F, 0xF2,
  0x03, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x1E,
  0x40, 0x68, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x0A, 0x06, 0x7F,
  0x80, 0x1F, 0x0E, 0x31, 0x03, 0x60, 0x28, 0x07, 0x00, 0xE0, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x03, 0x80,
  0x78, 0x09, 0x86, 0x1F, 0x80, 0xFC, 0x3F, 0xC8, 0x1A, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x28, 0x3B, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFB,
  0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x00, 0x1F, 0x0E, 0x31, 0x03, 0x60, 0x28, 0x07, 0x00, 0xE0, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x09, 0x86, 0x1F, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x07, 0xE0, 0xFC, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0xC0, 0x78, 0x09, 0x83, 0x1F, 0x80,
  0x80, 0x28, 0x06, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x18, 0x81, 0x08, 0x30,
  0x82, 0x0F, 0xE0, 0x86, 0x08, 0x30, 0x83, 0x08, 0x10, 0x81, 0x88, 0x08,
  0x80, 0xC8, 0x04, 0x80, 0x68, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xF0, 0xE0, 0x3E,
  0x07, 0xE0, 0x7D, 0x07, 0xD0, 0xBD, 0x0B, 0xC9, 0xBC, 0x93, 0xCD, 0x3C,
  0x63, 0xC6, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0xA0, 0x64, 0x19,
  0x06, 0x61, 0x88, 0x62, 0x18, 0x46, 0x11, 0x86, 0x60, 0x98, 0x26, 0x05,
  0x81, 0x60, 0x78, 0x0E, 0x03, 0x1E, 0x18, 0x64, 0x0F, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x36, 0x18, 0xFC, 0xFF, 0x1F, 0xFA, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x1B, 0xFE, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x1F, 0x0E,
  0x31, 0x03, 0x60, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x58, 0x19, 0x86,
  0x1F, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0xFE, 0x1F, 0xF2,
  0x03, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x3B, 0xFC,
  0x43, 0x08, 0x21, 0x06, 0x20, 0x44, 0x0C, 0x80, 0xD0, 0x1A, 0x01, 0xC0,
  0x30, 0x0F, 0x83, 0x8C, 0x60, 0x64, 0x02, 0x40, 0x34, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x20, 0x03, 0x00, 0x1C,
  0x01, 0xC0, 0x34, 0x02, 0x30, 0x61, 0xFC, 0xFF, 0xFF, 0xFF, 0xC1, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x36, 0x18, 0xFC, 0x80, 0x1C, 0x01, 0xC0, 0x34, 0x02, 0x40,
  0x26, 0x02, 0x20, 0x62, 0x04, 0x20, 0x43, 0x04, 0x10, 0xC1, 0x08, 0x18,
  0x81, 0x98, 0x09, 0x00, 0x90, 0x0D, 0x00, 0x70, 0x06, 0x00, 0x60, 0x83,
  0x06, 0x0C, 0x1C, 0x30, 0x70, 0xC3, 0x42, 0x8D, 0x0A, 0x24, 0x48, 0x91,
  0x22, 0x44, 0x89, 0x12, 0x26, 0x48, 0x99, 0x12, 0x24, 0x58, 0xA1, 0x42,
  0x85, 0x0A, 0x14, 0x28, 0x50, 0xA1, 0x43, 0x83, 0x0C, 0x0C, 0x40, 0x08,
  0x80, 0x63, 0x01, 0x04, 0x0C, 0x18, 0x20, 0x21, 0x00, 0xCC, 0x01, 0x20,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xA0, 0x04, 0xC0, 0x31, 0x00, 0x86,
  0x04, 0x08, 0x30, 0x30, 0x80, 0x46, 0x01, 0xB0, 0x03, 0xC0, 0x0D, 0x00,
  0x26, 0x01, 0x88, 0x04, 0x30, 0x30, 0x40, 0x81, 0x86, 0x02, 0x10, 0x0C,
  0xC0, 0x12, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x7F, 0xE7, 0xFE, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0F, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0xFC, 0x0C, 0x01, 0x80, 0x78, 0x09, 0x01, 0x30, 0x62, 0x08,
  0x63, 0x04, 0x40, 0x98, 0x1A, 0x01, 0x80, 0xFF, 0xF8, 0xE1, 0x04, 0x30,
  0x1F, 0x86, 0x19, 0x81, 0xA0, 0x10, 0x02, 0x00, 0x40, 0x09, 0xFF, 0x60,
  0x38, 0x07, 0x00, 0xE0, 0x14, 0x06, 0xC1, 0x4F, 0xC8, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x27, 0xCA, 0x1B, 0x03, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x3A, 0x1A, 0x7C, 0x3F, 0x0C,
  0x33, 0x03, 0x40, 0x28, 0x05, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x01, 0xC0, 0x2C, 0x0C, 0xC3, 0x0F, 0xC0, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x4F, 0x96, 0x17, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x36, 0x1C, 0xFD, 0x3F, 0x18, 0x6C, 0x0E,
  0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x01, 0xC0,
  0xD8, 0x63, 0xF0, 0x01, 0xF0, 0x7F, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x0F, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3E, 0x58, 0x5C,
  0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03,
  0x61, 0x47, 0x90, 0x04, 0x01, 0x00, 0x40, 0x30, 0x18, 0xFC, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x27, 0xCA, 0x1B, 0x03, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x04,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0F, 0xFE, 0x01, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x0E, 0x7E, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xE0, 0x14, 0x06, 0x81, 0x90, 0x62,
  0x08, 0x43, 0x0F, 0xC1, 0x0C, 0x20, 0xC4, 0x08, 0x81, 0x90, 0x1A, 0x01,
  0x40, 0x30, 0xFC, 0x03, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0xBD, 0xEC, 0x53, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10,
  0x9F, 0x28, 0x6C, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x3F, 0x18, 0x6C, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xD8,
  0x63, 0xF0, 0x9F, 0x28, 0x6C, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0xE8, 0x69, 0xF2, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x3E, 0x58, 0x5C, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xD8, 0x73, 0xF4, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0xDF, 0x9E, 0x1B, 0x81, 0x60, 0x3C, 0x07, 0x80,
  0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x00, 0x3F, 0x0C, 0x1B, 0x01, 0x40, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xFC,
  0x00, 0xC0, 0x08, 0x01, 0xC0, 0x38, 0x05, 0x81, 0x9F, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xD8, 0x63, 0xF0, 0xC0, 0x14,
  0x03, 0x40, 0x26, 0x02, 0x20, 0x62, 0x04, 0x30, 0x41, 0x0C, 0x10, 0x81,
  0x88, 0x09, 0x80, 0x90, 0x0D, 0x00, 0x60, 0x06, 0x00, 0xC3, 0x05, 0x0C,
  0x34, 0x30, 0x90, 0xC2, 0x42, 0x89, 0x92, 0x26, 0x48, 0x89, 0x26, 0x24,
  0x90, 0x91, 0x42, 0x85, 0x0E, 0x14, 0x38, 0x50, 0x61, 0xC1, 0x86, 0x00,
  0xC0, 0x36, 0x06, 0x30, 0x41, 0x0C, 0x19, 0x80, 0xD0, 0x07, 0x00, 0x60,
  0x07, 0x00, 0x90, 0x18, 0x83, 0x0C, 0x20, 0x46, 0x02, 0xC0, 0x30, 0xC0,
  0x14, 0x03, 0x40, 0x26, 0x06, 0x20, 0x63, 0x04, 0x10, 0xC1, 0x08, 0x18,
  0x80, 0x98, 0x0D, 0x00, 0x50, 0x07, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0xFF, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x0F, 0xFC,
  0x03, 0xE0, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x0F, 0x80, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x20, 0x06, 0x00, 0x7E,
  0x10, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x14, 0xC1, 0xC6, 0x1C, 0x33, 0xC1,
  0xE0,
};

const GFXglyph JetBrainsMono_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 20, 16, 7, -20 },
  { 9, 7, 8, 16, 5, -20 },
  { 16, 14, 20, 16, 1, -20 },
  { 51, 12, 27, 16, 2, -23 },
  { 92, 15, 20, 16, 1, -20 },
  { 130, 13, 20, 16, 2, -20 },
  { 163, 2, 8, 16, 7, -20 },
  { 165, 7, 26, 16, 6, -23 },
  { 188, 8, 26, 16, 3, -23 },
  { 214, 14, 13, 16, 1, -16 },
  { 237, 12, 12, 16, 2, -15 },
  { 255, 5, 8, 16, 5, -4 },
  { 260, 8, 2, 16, 4, -10 },
  { 262, 4, 4, 16, 6, -4 },
  { 264, 11, 25, 16, 3, -22 },
  { 299, 11, 20, 16, 3, -20 },
  { 327, 11, 20, 16, 3, -20 },
  { 355, 12, 20, 16, 2, -20 },
  { 385, 11, 20, 16, 2, -20 },
  { 413, 10, 20, 16, 3, -20 },
  { 438, 11, 20, 16, 3, -20 },
  { 466, 12, 20, 16, 2, -20 },
  { 496, 12, 20, 16, 2, -20 },
  { 526, 12, 20, 16, 2, -20 },
  { 556, 12, 20, 16, 2, -20 },
  { 586, 4, 15, 16, 6, -15 },
  { 594, 5, 19, 16, 5, -15 },
  { 606, 12, 14, 16, 2, -16 },
  { 627, 11, 8, 16, 3, -13 },
  { 638, 12, 14, 16, 2, -16 },
  { 659, 9, 20, 16, 5, -20 },
  { 682, 13, 25, 16, 2, -20 },
  { 723, 12, 20, 16, 2, -20 },
  { 753, 11, 20, 16, 3, -20 },
  { 781, 11, 20, 16, 3, -20 },
  { 809, 10, 20, 16, 3, -20 },
  { 834, 11, 20, 16, 3, -20 },
  { 862, 11, 20, 16, 3, -20 },
  { 890, 11, 20, 16, 3, -20 },
  { 918, 10, 20, 16, 3, -20 },
  { 943, 10, 20, 16, 3, -20 },
  { 968, 11, 20, 16, 2, -20 },
  { 996, 12, 20, 16, 3, -20 },
  { 1026, 11, 20, 16, 3, -20 },
  { 1054, 12, 20, 16, 2, -20 },
  { 1084, 10, 20, 16, 3, -20 },
  { 1109, 10, 20, 16, 3, -20 },
  { 1134, 11, 20, 16, 3, -20 },
  { 1162, 11, 25, 16, 3, -20 },
  { 1197, 11, 20, 16, 3, -20 },
  { 1225, 12, 20, 16, 2, -20 },
  { 1255, 13, 20, 16, 2, -20 },
  { 1288, 10, 20, 16, 3, -20 },
  { 1313, 12, 20, 16, 2, -20 },
  { 1343, 14, 20, 16, 1, -20 },
  { 1378, 14, 20, 16, 1, -20 },
  { 1413, 14, 20, 16, 1, -20 },
  { 1448, 12, 20, 16, 2, -20 },
  { 1478, 6, 25, 16, 6, -22 },
  { 1497, 11, 25, 16, 3, -22 },
  { 1532, 6, 25, 16, 4, -22 },
  { 1551, 11, 11, 16, 3, -20 },
  { 1567, 13, 1, 16, 2, 1 },
  { 1569, 5, 4, 16, 5, -21 },
  { 1572, 11, 15, 16, 2, -15 },
  { 1593, 10, 20, 16, 3, -20 },
  { 1618, 11, 15, 16, 3, -15 },
  { 1639, 10, 20, 16, 3, -20 },
  { 1664, 10, 15, 16, 3, -15 },
  { 1683, 12, 20, 16, 2, -20 },
  { 1713, 10, 20, 16, 3, -15 },
  { 1738, 10, 20, 16, 3, -20 },
  { 1763, 11, 21, 16, 3, -21 },
  { 1792, 9, 26, 16, 3, -21 },
  { 1822, 11, 20, 16, 3, -20 },
  { 1850, 14, 20, 16, 1, -20 },
  { 1885, 12, 15, 16, 2, -15 },
  { 1908, 10, 15, 16, 3, -15 },
  { 1927, 10, 15, 16, 3, -15 },
  { 1946, 10, 20, 16, 3, -15 },
  { 1971, 10, 20, 16, 3, -15 },
  { 1996, 11, 15, 16, 3, -15 },
  { 2017, 11, 15, 16, 3, -15 },
  { 2038, 12, 19, 16, 2, -19 },
  { 2067, 10, 15, 16, 3, -15 },
  { 2086, 12, 15, 16, 2, -15 },
  { 2109, 14, 15, 16, 1, -15 },
  { 2136, 12, 15, 16, 2, -15 },
  { 2159, 12, 20, 16, 2, -15 },
  { 2189, 10, 15, 16, 3, -15 },
  { 2208, 11, 25, 16, 3, -22 },
  { 2243, 2, 25, 16, 7, -22 },
  { 2250, 11, 25, 16, 3, -22 },
  { 2285, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Thin27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_THIN27PT7B_H_
