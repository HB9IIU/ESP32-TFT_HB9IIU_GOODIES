#ifndef _JETBRAINSMONO_THIN45PT7B_H_
#define _JETBRAINSMONO_THIN45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x31,
  0x08, 0x42, 0x10, 0x84, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x78, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC1, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x1C, 0x67, 0x87, 0x0C, 0x31, 0xC1, 0x87, 0x30, 0x30, 0x66, 0x06, 0x0E,
  0xC0, 0xC1, 0xD8, 0x18, 0x03, 0x03, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x00,
  0xE1, 0x80, 0x0E, 0x30, 0x00, 0xF6, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x67, 0x80, 0x0C, 0x70, 0x01, 0x87, 0x00, 0x30, 0x70,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x1E, 0x03, 0x03, 0xC0, 0x60, 0x7C,
  0x0C, 0x1D, 0x81, 0x83, 0xB8, 0x30, 0xE3, 0x86, 0x38, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x01, 0x9F, 0xE0, 0x01, 0x9C, 0x18,
  0x01, 0x8C, 0x0E, 0x00, 0xC6, 0x03, 0x00, 0xC3, 0x01, 0x80, 0xC1, 0x80,
  0xC0, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x60, 0x30, 0x18, 0x70, 0x18,
  0x0C, 0x30, 0x0C, 0x0E, 0x30, 0x07, 0x0E, 0x30, 0x01, 0xFE, 0x18, 0x00,
  0x3E, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x1E, 0x00, 0x0C, 0x3F, 0xC0, 0x06, 0x38, 0x70, 0x06, 0x18,
  0x18, 0x06, 0x18, 0x0C, 0x03, 0x0C, 0x06, 0x03, 0x06, 0x03, 0x03, 0x03,
  0x01, 0x83, 0x81, 0x80, 0xC1, 0x80, 0xC0, 0x61, 0x80, 0x60, 0x31, 0x80,
  0x30, 0x18, 0xC0, 0x0C, 0x1C, 0xC0, 0x03, 0xFC, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x71, 0xC0, 0x05, 0x83,
  0x80, 0x6E, 0x06, 0x03, 0xB0, 0x0C, 0x0C, 0xC0, 0x38, 0x73, 0x00, 0x71,
  0x8C, 0x00, 0xCE, 0x30, 0x01, 0xB0, 0xC0, 0x07, 0xC3, 0x00, 0x0E, 0x0C,
  0x00, 0x38, 0x30, 0x01, 0xF0, 0xE0, 0x06, 0xE3, 0x80, 0x39, 0xC7, 0x03,
  0xC3, 0x0F, 0xFE, 0x06, 0x1F, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0E, 0x80,
  0x07, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x20, 0x0E, 0x00, 0xF8, 0x1C, 0x0F, 0xFC, 0x18, 0x7E, 0x7F,
  0x27, 0xF0, 0x1F, 0x5F, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x0E, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x38, 0xF1,
  0xE3, 0x87, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x0C, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xF8, 0x3E, 0x1C, 0x01, 0xC7, 0x00, 0x1C,
  0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x38, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x81, 0x83, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00, 0x1C, 0x70, 0x07, 0x0F,
  0x01, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x03, 0xB0, 0x00, 0x73, 0x00, 0x1E, 0x30, 0x03, 0x83, 0x00, 0x70, 0x30,
  0x06, 0x03, 0x00, 0x40, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3C,
  0x07, 0x87, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x0C, 0xC0, 0x00, 0xEC,
  0x00, 0x06, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0x9C, 0x00,
  0xE3, 0x80, 0x70, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00,
  0x33, 0x80, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x06, 0x3F, 0xE0, 0xCF, 0x7E, 0x1B, 0x01, 0xE3, 0x40,
  0x0C, 0x70, 0x01, 0xCE, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x67, 0x00, 0x1C, 0x60, 0x07, 0x0F, 0x01,
  0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x31, 0xF0, 0x0E, 0xFF, 0x81, 0xF0, 0x78, 0x78, 0x03, 0x8E, 0x00,
  0x39, 0x80, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xB0, 0x00,
  0x67, 0x00, 0x1C, 0x60, 0x07, 0x0F, 0x01, 0xE0, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x70, 0x1E, 0x1C, 0x00, 0xC7, 0x00, 0x1C,
  0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x19,
  0xC0, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x38, 0x1C, 0x1E, 0x01, 0xE7, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xE3, 0x80, 0x78, 0x3C, 0x1C, 0x01, 0xC7,
  0x00, 0x1C, 0xC0, 0x01, 0xB8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x0C, 0xE0, 0x03, 0x8E,
  0x00, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x01, 0xB8, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x0E, 0x38, 0x03, 0xC7,
  0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xF1, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x7C, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xDF, 0xFF, 0xFF, 0x7C,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x1F, 0xE0, 0x3F, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x71, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x98, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x03, 0xC7, 0xC0, 0x3F,
  0xDF, 0x01, 0xE1, 0xFC, 0x06, 0x03, 0xF0, 0x38, 0x07, 0xC0, 0xC0, 0x1F,
  0x03, 0x00, 0x7C, 0x0C, 0x01, 0xF0, 0x30, 0x07, 0xC0, 0xC0, 0x1F, 0x03,
  0x00, 0x7C, 0x0C, 0x01, 0xF0, 0x30, 0x07, 0xC0, 0xC0, 0x1F, 0x03, 0x00,
  0x7C, 0x0E, 0x01, 0xF0, 0x1C, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0x7C,
  0x00, 0x20, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x01, 0xC0,
  0x18, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x38, 0x00, 0xE1,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x07, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xC0, 0x00, 0x38, 0xFF, 0xE0, 0x3F,
  0xFF, 0x0C, 0x03, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x30,
  0x07, 0x8C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xB0, 0x01, 0xEC, 0x00, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0xF1, 0xC0, 0x0C, 0x60, 0x03, 0xB8,
  0x00, 0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x06, 0xE0, 0x01, 0x9C, 0x00, 0xE3, 0x80, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x30, 0x1F, 0x18, 0x01, 0xCC,
  0x00, 0x76, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x73, 0x00, 0xF1, 0xFF, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xFC, 0xFF, 0xFF, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x98, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0xF1, 0xC0, 0x0C, 0x60, 0x03, 0xB8,
  0x00, 0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x06, 0xE0, 0x01, 0x9C, 0x00, 0xE3, 0x80, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0x30, 0x00, 0x67, 0x00, 0x1C, 0xE0, 0x07,
  0x0F, 0x01, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01,
  0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x70, 0x60, 0x0C,
  0x0C, 0x03, 0x81, 0x80, 0x60, 0x30, 0x1C, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x38,
  0x30, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xE3, 0x00, 0x0C,
  0x60, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x07,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x40, 0x05, 0xEC, 0x01, 0xBD, 0x80, 0x37, 0x90, 0x04,
  0xF3, 0x01, 0x9E, 0x60, 0x33, 0xC6, 0x04, 0x78, 0xC1, 0x8F, 0x18, 0x31,
  0xE1, 0x8C, 0x3C, 0x31, 0x87, 0x82, 0x20, 0xF0, 0x6C, 0x1E, 0x0D, 0x83,
  0xC0, 0xA0, 0x78, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3D, 0x80, 0x1E, 0xC0, 0x0F, 0x30, 0x07, 0x98, 0x03, 0xCC, 0x01,
  0xE3, 0x00, 0xF1, 0x80, 0x78, 0xE0, 0x3C, 0x30, 0x1E, 0x18, 0x0F, 0x06,
  0x07, 0x83, 0x03, 0xC1, 0xC1, 0xE0, 0x60, 0xF0, 0x30, 0x78, 0x0C, 0x3C,
  0x06, 0x1E, 0x03, 0x0F, 0x00, 0xC7, 0x80, 0x63, 0xC0, 0x19, 0xE0, 0x0C,
  0xF0, 0x06, 0x78, 0x01, 0xBC, 0x00, 0xDE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00,
  0xE6, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x38, 0xE0, 0x38, 0x3F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x00, 0x7C, 0x60, 0x01,
  0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xB0, 0x00, 0x76, 0x00, 0x3C, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0x80, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0x30, 0x00, 0xEC,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xE0, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0x00, 0x7C, 0x60, 0x01, 0xCC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0xE6, 0x00, 0x78, 0xFF, 0xFE, 0x1F,
  0xFF, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x70, 0x30,
  0x06, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x1C, 0x60,
  0x03, 0x8C, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x76, 0x00, 0x0E, 0xC0,
  0x00, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x1E, 0x1C, 0x00, 0xC7,
  0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xE0,
  0x03, 0x8F, 0x00, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x76,
  0x00, 0x33, 0x80, 0x38, 0xE0, 0x38, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x03,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0xC0, 0x1C, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80,
  0xC0, 0x0E, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0x60, 0x3C, 0x02, 0xC0, 0x7C, 0x0D, 0x81, 0xD8, 0x1B, 0x03, 0x30, 0x36,
  0x06, 0x60, 0x6C, 0x0C, 0xC0, 0xC8, 0x19, 0x81, 0x10, 0x33, 0x02, 0x30,
  0x66, 0x0C, 0x60, 0xCE, 0x18, 0xC1, 0x8C, 0x31, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xC2, 0x18, 0x61, 0x04, 0x30, 0xC2, 0x0C, 0x61, 0x8C, 0x18, 0xC3,
  0x18, 0x31, 0x87, 0x30, 0x63, 0x06, 0x60, 0xC4, 0x0C, 0x80, 0x98, 0x19,
  0x01, 0x30, 0x32, 0x03, 0x60, 0x6C, 0x06, 0xC0, 0xD8, 0x0D, 0x81, 0xB0,
  0x1B, 0x03, 0xE0, 0x36, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0xC0, 0x01,
  0x80, 0xC0, 0x06, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x80, 0xE0,
  0x03, 0x01, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0xC0, 0x07, 0x01,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x03,
  0x07, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3,
  0x80, 0x03, 0x83, 0x00, 0x06, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x38,
  0x38, 0x00, 0x30, 0x60, 0x00, 0x71, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x30, 0x00, 0xC7,
  0x00, 0x38, 0x60, 0x06, 0x0C, 0x01, 0xC1, 0xC0, 0x30, 0x18, 0x0E, 0x03,
  0x81, 0x80, 0x30, 0x70, 0x07, 0x0E, 0x00, 0x63, 0x80, 0x0E, 0x70, 0x01,
  0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0C, 0x07, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0x70, 0xE0, 0x0E,
  0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x3F, 0xFF, 0x3F, 0xFF, 0xDE, 0x00, 0x36, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xF7, 0x80, 0x6C, 0xFF, 0xF3, 0x0F, 0xF8, 0xC0,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC3, 0xF8, 0x67, 0xFE, 0x36, 0x03, 0x9E,
  0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x3B, 0x60, 0x39, 0x9F, 0xFC, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0x80, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0xB8, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xE0, 0x03, 0x9C, 0x00,
  0xC3, 0x80, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x0F, 0xE1, 0x8F, 0xFC, 0xCE, 0x03, 0x6E, 0x00, 0xF6, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x3C,
  0xE0, 0x36, 0x7F, 0xF3, 0x0F, 0xF1, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0E,
  0x03, 0x8E, 0x00, 0xE6, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x3E, 0x00, 0x3B, 0x80, 0x18, 0xE0, 0x3C, 0x3F, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE1, 0x8F, 0xFC, 0xCE, 0x03, 0x6E, 0x00,
  0xB6, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xD8, 0x00, 0xEE, 0x00, 0xB3, 0x80,
  0xD8, 0xFF, 0xCC, 0x3F, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x3C, 0x3F, 0xFC,
  0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC3, 0xF8, 0x67, 0xFE,
  0x36, 0x03, 0x9E, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0xFF,
  0xF0, 0xFF, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x3B, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x1C,
  0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0xC0,
  0xC0, 0x18, 0x18, 0x03, 0x83, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00, 0x71,
  0x80, 0x07, 0x30, 0x00, 0x66, 0x00, 0x0E, 0xC0, 0x00, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0xDF, 0x0F, 0x9F, 0xF3, 0xFB, 0x87, 0x43,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x60, 0xC3, 0xF8, 0x67, 0xFE, 0x36, 0x03, 0x9A,
  0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x07,
  0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xE6, 0x00, 0x37, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x38, 0xE0, 0x38,
  0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xC3, 0xF8, 0x67, 0xFE, 0x36, 0x03, 0x9E,
  0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x3B, 0x60, 0x39, 0x9F, 0xFC, 0xC7, 0xF8, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE1, 0x8F, 0xFC, 0xCE, 0x03, 0x6E, 0x00,
  0xF6, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x3B, 0x80, 0x3C, 0xE0, 0x36, 0x7F, 0xF3, 0x0F, 0xF1, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xC7, 0xF8, 0x67, 0xFE, 0x36, 0x03, 0x9E, 0x00, 0xEE,
  0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xF0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x0C, 0xC0, 0x01, 0xD8,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x0E, 0xE0,
  0x01, 0x8E, 0x00, 0x70, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x76,
  0x00, 0x33, 0x80, 0x38, 0xE0, 0x38, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0,
  0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x06,
  0x1C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x00, 0x18, 0x1C, 0x01, 0xC0, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x70, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x07, 0xC0, 0x70, 0x1D, 0x80,
  0xA0, 0x33, 0x01, 0x40, 0x66, 0x02, 0xC0, 0xCC, 0x0D, 0x81, 0x98, 0x1B,
  0x03, 0x38, 0x36, 0x0E, 0x30, 0x44, 0x18, 0x60, 0x88, 0x30, 0xC3, 0x18,
  0x61, 0x86, 0x30, 0xC3, 0x0C, 0x61, 0x87, 0x18, 0x46, 0x06, 0x20, 0x8C,
  0x0C, 0xC1, 0x98, 0x19, 0x83, 0x30, 0x33, 0x06, 0x60, 0x66, 0x0C, 0xC0,
  0x68, 0x0B, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x70, 0x00, 0x71, 0x80, 0x03, 0x0E, 0x00,
  0x38, 0x38, 0x03, 0x80, 0xC0, 0x18, 0x03, 0x01, 0xC0, 0x1C, 0x1C, 0x00,
  0x60, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x36, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x31, 0x80, 0x03,
  0x8E, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C,
  0x0C, 0x00, 0x60, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x06,
  0x0C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x70, 0x30, 0x01, 0x83, 0x80,
  0x0C, 0x18, 0x00, 0x70, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x37,
  0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x6F, 0xE0,
  0x0F, 0x86, 0x01, 0xE0, 0x60, 0x3C, 0x06, 0x07, 0x80, 0xE0, 0xF0, 0x0F,
  0xF6, 0x00, 0x7C,
};

const GFXglyph JetBrainsMono_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 5, 33, 27, 11, -33 },
  { 22, 11, 14, 27, 8, -33 },
  { 42, 23, 33, 27, 2, -33 },
  { 137, 19, 45, 27, 4, -39 },
  { 244, 25, 33, 27, 1, -33 },
  { 348, 22, 33, 27, 3, -33 },
  { 439, 3, 14, 27, 12, -33 },
  { 445, 13, 43, 27, 9, -38 },
  { 515, 13, 43, 27, 5, -38 },
  { 585, 23, 22, 27, 2, -27 },
  { 649, 21, 21, 27, 3, -25 },
  { 705, 7, 14, 27, 9, -7 },
  { 718, 15, 2, 27, 6, -16 },
  { 722, 7, 6, 27, 10, -6 },
  { 728, 19, 42, 27, 4, -37 },
  { 828, 19, 33, 27, 4, -33 },
  { 907, 20, 33, 27, 4, -33 },
  { 990, 20, 33, 27, 4, -33 },
  { 1073, 18, 33, 27, 4, -33 },
  { 1148, 18, 33, 27, 4, -33 },
  { 1223, 19, 33, 27, 4, -33 },
  { 1302, 19, 33, 27, 4, -33 },
  { 1381, 20, 33, 27, 4, -33 },
  { 1464, 19, 33, 27, 4, -33 },
  { 1543, 19, 33, 27, 4, -33 },
  { 1622, 7, 25, 27, 10, -25 },
  { 1644, 8, 32, 27, 9, -25 },
  { 1676, 19, 22, 27, 4, -26 },
  { 1729, 19, 12, 27, 4, -21 },
  { 1758, 19, 22, 27, 4, -26 },
  { 1811, 15, 33, 27, 8, -33 },
  { 1873, 22, 41, 27, 3, -33 },
  { 1986, 21, 33, 27, 3, -33 },
  { 2073, 18, 33, 27, 5, -33 },
  { 2148, 18, 33, 27, 5, -33 },
  { 2223, 17, 33, 27, 5, -33 },
  { 2294, 18, 33, 27, 5, -33 },
  { 2369, 19, 33, 27, 5, -33 },
  { 2448, 18, 33, 27, 5, -33 },
  { 2523, 17, 33, 27, 5, -33 },
  { 2594, 17, 33, 27, 5, -33 },
  { 2665, 19, 33, 27, 3, -33 },
  { 2744, 19, 33, 27, 5, -33 },
  { 2823, 19, 33, 27, 5, -33 },
  { 2902, 19, 33, 27, 4, -33 },
  { 2981, 17, 33, 27, 5, -33 },
  { 3052, 17, 33, 27, 5, -33 },
  { 3123, 19, 33, 27, 5, -33 },
  { 3202, 18, 41, 27, 5, -33 },
  { 3295, 19, 33, 27, 5, -33 },
  { 3374, 19, 33, 27, 4, -33 },
  { 3453, 21, 33, 27, 3, -33 },
  { 3540, 17, 33, 27, 5, -33 },
  { 3611, 21, 33, 27, 3, -33 },
  { 3698, 23, 33, 27, 2, -33 },
  { 3793, 23, 33, 27, 2, -33 },
  { 3888, 23, 33, 27, 2, -33 },
  { 3983, 19, 33, 27, 4, -33 },
  { 4062, 10, 42, 27, 10, -37 },
  { 4115, 19, 42, 27, 4, -37 },
  { 4215, 10, 42, 27, 7, -37 },
  { 4268, 19, 18, 27, 4, -33 },
  { 4311, 21, 2, 27, 3, 1 },
  { 4317, 8, 6, 27, 9, -35 },
  { 4323, 18, 25, 27, 4, -25 },
  { 4380, 17, 33, 27, 5, -33 },
  { 4451, 18, 25, 27, 5, -25 },
  { 4508, 17, 33, 27, 5, -33 },
  { 4579, 17, 25, 27, 5, -25 },
  { 4633, 21, 33, 27, 3, -33 },
  { 4720, 17, 33, 27, 5, -25 },
  { 4791, 17, 33, 27, 5, -33 },
  { 4862, 20, 34, 27, 4, -34 },
  { 4947, 16, 42, 27, 4, -34 },
  { 5031, 19, 33, 27, 5, -33 },
  { 5110, 22, 33, 27, 2, -33 },
  { 5201, 19, 25, 27, 4, -25 },
  { 5261, 17, 25, 27, 5, -25 },
  { 5315, 17, 25, 27, 5, -25 },
  { 5369, 17, 33, 27, 5, -25 },
  { 5440, 17, 33, 27, 5, -25 },
  { 5511, 17, 25, 27, 6, -25 },
  { 5565, 19, 25, 27, 4, -25 },
  { 5625, 20, 32, 27, 3, -32 },
  { 5705, 17, 25, 27, 5, -25 },
  { 5759, 21, 25, 27, 3, -25 },
  { 5825, 23, 25, 27, 2, -25 },
  { 5897, 21, 25, 27, 3, -25 },
  { 5963, 21, 33, 27, 3, -25 },
  { 6050, 17, 25, 27, 5, -25 },
  { 6104, 19, 42, 27, 4, -37 },
  { 6204, 3, 42, 27, 12, -37 },
  { 6220, 19, 42, 27, 4, -37 },
  { 6320, 19, 8, 27, 4, -20 },
};

const GFXfont JetBrainsMono_Thin45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_THIN45PT7B_H_
