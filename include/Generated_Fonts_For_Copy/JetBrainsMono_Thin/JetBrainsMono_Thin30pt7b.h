#ifndef _JETBRAINSMONO_THIN30PT7B_H_
#define _JETBRAINSMONO_THIN30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x00, 0x07, 0xF7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x02, 0x04, 0x02,
  0x04, 0x06, 0x0C, 0x06, 0x0C, 0x04, 0x08, 0x04, 0x08, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0C, 0x18, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x18,
  0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x20, 0x10, 0x20, 0x30, 0x60, 0x30,
  0x60, 0x20, 0x40, 0x20, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x1F,
  0x83, 0x2E, 0x62, 0x2C, 0x23, 0xC2, 0x1C, 0x21, 0xC2, 0x04, 0x20, 0x62,
  0x03, 0xA0, 0x1F, 0x00, 0x3C, 0x02, 0x60, 0x23, 0x02, 0x30, 0x21, 0x82,
  0x18, 0x21, 0xC2, 0x1C, 0x23, 0x72, 0x63, 0xFC, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x3C, 0x01, 0x66, 0x02, 0xC2, 0x06, 0x83, 0x04, 0x83, 0x08,
  0x83, 0x18, 0x83, 0x10, 0xC2, 0x20, 0x66, 0x40, 0x3C, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x3C, 0x02, 0x66, 0x04, 0x43, 0x0C, 0xC1, 0x18, 0xC1,
  0x10, 0xC1, 0x20, 0xC1, 0x60, 0x43, 0x40, 0x62, 0x80, 0x3C, 0x0F, 0x80,
  0x31, 0x80, 0xC1, 0x81, 0x01, 0x02, 0x03, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x01, 0xF0, 0x06, 0x30, 0x2C, 0x30, 0xD0, 0x31,
  0x20, 0x26, 0x40, 0x68, 0x80, 0x71, 0x00, 0xC3, 0x01, 0xC6, 0x06, 0xC6,
  0x18, 0xC7, 0xE0, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0x83, 0x87, 0x07, 0x03,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C,
  0x03, 0x80, 0x70, 0x08, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x06, 0x0E, 0x1C, 0x08,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x41, 0x82, 0xF1,
  0x8F, 0x3D, 0xBC, 0x07, 0xE0, 0x01, 0x80, 0x02, 0xC0, 0x06, 0x60, 0x0C,
  0x30, 0x0C, 0x30, 0x18, 0x18, 0x10, 0x08, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x39, 0x9C, 0xC6, 0x33,
  0x18, 0x84, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x1F, 0x87, 0x9E, 0x60, 0x6C, 0x03, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x41, 0x8F, 0x18, 0x61, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x36, 0x06, 0x70, 0xE1, 0xF8, 0x07,
  0x00, 0x78, 0x0E, 0xC0, 0xC6, 0x0C, 0x30, 0x41, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFC, 0x1F,
  0x83, 0x87, 0x30, 0x09, 0x80, 0x68, 0x01, 0x40, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xFC, 0xFF,
  0xE0, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0F,
  0x00, 0xFC, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x2C, 0x06, 0x70, 0xC3, 0xF8, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x83, 0x30,
  0x32, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xF0, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xDF, 0xCF, 0x0E, 0xE0, 0x2C, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x34, 0x06, 0x70,
  0xC1, 0xF8, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x06, 0xF8, 0x70, 0xEE, 0x06, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x06, 0x70, 0xE1, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0x05, 0x00, 0x68, 0x03, 0x40, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x1F,
  0x83, 0x0C, 0x60, 0x2C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x34, 0x02, 0x20,
  0x61, 0x98, 0x0F, 0x01, 0xF8, 0x30, 0xC6, 0x06, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x3C, 0x03, 0x70, 0xE3, 0xFC, 0x1F, 0x83, 0x0C, 0x60,
  0x6C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0,
  0x37, 0x0E, 0x3F, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x6F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0xF0, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x99, 0xCC,
  0x63, 0x31, 0x88, 0x40, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x00,
  0x80, 0x00, 0xFC, 0x03, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x70, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x78, 0x1C, 0x00, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x98,
  0x03, 0x40, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x11, 0x83, 0xF6, 0x0C, 0x38,
  0x60, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06,
  0x08, 0x38, 0x30, 0xE0, 0x7D, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01,
  0x60, 0x04, 0x80, 0x12, 0x00, 0xCC, 0x02, 0x10, 0x08, 0x40, 0x61, 0x81,
  0x86, 0x04, 0x08, 0x10, 0x20, 0xC0, 0xC3, 0xFF, 0x0F, 0xFC, 0x20, 0x11,
  0x80, 0x64, 0x01, 0x90, 0x02, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0x0C, 0x3C,
  0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x0E,
  0xFF, 0x8C, 0x1C, 0xC0, 0x6C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x02, 0xC1, 0xEF, 0xF8, 0x1F, 0x83, 0x0E, 0x60, 0x24, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x36, 0x02,
  0x30, 0xE1, 0xF8, 0xFF, 0x0C, 0x7C, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC3, 0xCF, 0xF0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F,
  0xFD, 0xFF, 0xEC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F, 0x83, 0x0E, 0x60, 0x24,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x3F, 0xC3, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x36,
  0x02, 0x30, 0xE1, 0xF8, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFC, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x36, 0x03, 0x30,
  0xE1, 0xFC, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x23,
  0x03, 0x18, 0x10, 0xC1, 0x86, 0x08, 0x3F, 0xC1, 0x86, 0x0C, 0x18, 0x60,
  0xC3, 0x03, 0x18, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01,
  0x60, 0x0C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0,
  0x3E, 0x07, 0xA0, 0x5A, 0x05, 0xB0, 0xD9, 0x09, 0x90, 0x99, 0x99, 0x89,
  0x18, 0x91, 0x86, 0x18, 0x61, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3F, 0x03, 0xD0, 0x3D, 0x03, 0xC8, 0x3C, 0x83, 0xCC, 0x3C, 0x43, 0xC4,
  0x3C, 0x23, 0xC2, 0x3C, 0x33, 0xC1, 0x3C, 0x13, 0xC1, 0xBC, 0x0B, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0x1F, 0x83, 0x0C, 0x60, 0x6C, 0x02, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x30,
  0xC1, 0xF8, 0xFF, 0x86, 0x0F, 0x30, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xB0, 0x19, 0xFF, 0x8C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x6C, 0x02, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x30, 0xC1, 0xF8, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFF, 0x86, 0x1F, 0x30, 0x0D,
  0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x16, 0x01, 0xB0,
  0x39, 0xFF, 0x8C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03,
  0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0C, 0x1F, 0x83, 0x0E, 0x60, 0x2C,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C,
  0x03, 0x70, 0x63, 0xFC, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x26,
  0x06, 0x30, 0xC1, 0xF8, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0x98, 0x02, 0x60,
  0x18, 0x80, 0x42, 0x01, 0x0C, 0x0C, 0x30, 0x30, 0x40, 0x81, 0x02, 0x06,
  0x18, 0x18, 0x60, 0x21, 0x00, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12, 0x00,
  0x68, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0x41, 0xC2, 0x43, 0x42, 0x42, 0x42, 0x42, 0x42, 0x62, 0x42, 0x62,
  0x46, 0x62, 0x46, 0x62, 0x46, 0x26, 0x64, 0x24, 0x24, 0x24, 0x24, 0x24,
  0x24, 0x34, 0x24, 0x34, 0x2C, 0x34, 0x2C, 0x3C, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x8C, 0x0C, 0x10, 0x20,
  0x61, 0x80, 0x84, 0x03, 0x30, 0x04, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x80, 0x33, 0x00, 0x84, 0x06, 0x18, 0x10, 0x20, 0xC0, 0xC2, 0x01,
  0x18, 0x06, 0xC0, 0x0F, 0x00, 0x30, 0xC0, 0x03, 0x60, 0x06, 0x20, 0x04,
  0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20,
  0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x0F, 0xFF, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x06,
  0x00, 0x60, 0x0F, 0x00, 0x90, 0x19, 0x81, 0x88, 0x30, 0xC3, 0x0C, 0x60,
  0x66, 0x06, 0x40, 0x2C, 0x03, 0xFF, 0xFC, 0xC3, 0x08, 0x61, 0x80, 0x07,
  0x80, 0xFF, 0x0C, 0x0C, 0x40, 0x26, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x1F, 0xFB, 0x00, 0xD0, 0x07, 0x80, 0x3C, 0x01, 0xA0, 0x0D, 0x80, 0xE6,
  0x0F, 0x1F, 0x98, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF0,
  0xDF, 0xCE, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x06, 0xF0, 0xED, 0xF8,
  0x0F, 0x03, 0xFC, 0x60, 0x64, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0x60, 0x23, 0x0E,
  0x1F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xF3, 0x3F,
  0xB6, 0x07, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x07, 0x30, 0xF1, 0xFB, 0x0F,
  0x03, 0xFC, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x60, 0x63, 0x0E, 0x1F,
  0x80, 0x01, 0xFC, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x3F, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x0F, 0x33, 0xFB, 0x60, 0x74, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x36,
  0x07, 0x3F, 0xB0, 0xE3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x63,
  0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF0, 0xDF, 0xCE,
  0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0,
  0x00, 0xC0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x0E, 0x7F, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x0F, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30,
  0x7F, 0x03, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x06, 0x30, 0x19, 0x80, 0xCC,
  0x03, 0x60, 0x0C, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0xDC, 0x73, 0xFB,
  0xEC, 0x30, 0xB0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0,
  0xC3, 0xC3, 0x0C, 0xC7, 0x0D, 0xFC, 0xE0, 0x6C, 0x02, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x0F, 0x03, 0xFC, 0x60, 0x64, 0x02, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0xCF, 0x0D, 0xFC, 0xE0, 0x6C,
  0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x6F, 0x0C, 0xDF, 0x8C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x33, 0xFB, 0x60, 0x74, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x73, 0x0F, 0x1F, 0xB0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x8F, 0x0B, 0xFC, 0xA0, 0x6C, 0x06, 0xC0, 0x28, 0x03, 0x80, 0x38,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x1F, 0x83, 0xFE, 0x60, 0x2C, 0x03, 0xC0, 0x0C, 0x00,
  0x40, 0x07, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x36, 0x06, 0x3F, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x0F,
  0xFF, 0xFF, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x0E, 0x00, 0x3F, 0x80, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34,
  0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x98,
  0x06, 0x20, 0x10, 0xC0, 0xC3, 0x03, 0x04, 0x08, 0x18, 0x60, 0x61, 0x80,
  0x84, 0x03, 0x30, 0x0C, 0xC0, 0x12, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00,
  0xC1, 0x83, 0x41, 0x82, 0x41, 0x82, 0x41, 0x82, 0x63, 0xC6, 0x62, 0x46,
  0x22, 0x44, 0x22, 0x44, 0x22, 0x44, 0x22, 0x64, 0x34, 0x2C, 0x34, 0x2C,
  0x14, 0x28, 0x14, 0x28, 0x14, 0x28, 0x1C, 0x38, 0x18, 0x18, 0x40, 0x09,
  0x80, 0x63, 0x03, 0x04, 0x08, 0x18, 0x60, 0x33, 0x00, 0x48, 0x01, 0xE0,
  0x03, 0x00, 0x1E, 0x00, 0x48, 0x03, 0x30, 0x18, 0x60, 0x40, 0x83, 0x03,
  0x18, 0x06, 0xC0, 0x0C, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x98, 0x06, 0x30,
  0x10, 0xC0, 0xC1, 0x02, 0x06, 0x18, 0x18, 0x60, 0x21, 0x00, 0xCC, 0x01,
  0x30, 0x06, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x1C,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0xE0, 0xFC, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0xF0, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x1C, 0x0F, 0x80, 0xF8, 0x18, 0xC1, 0x86, 0x18, 0x31, 0x81, 0xE0,
};

const GFXglyph JetBrainsMono_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 8, 9, 18, 5, -22 },
  { 21, 16, 22, 18, 1, -22 },
  { 65, 12, 30, 18, 3, -26 },
  { 110, 16, 22, 18, 1, -22 },
  { 154, 15, 22, 18, 2, -22 },
  { 196, 2, 9, 18, 8, -22 },
  { 199, 9, 29, 18, 6, -25 },
  { 232, 9, 29, 18, 3, -25 },
  { 265, 16, 15, 18, 1, -18 },
  { 295, 14, 14, 18, 2, -17 },
  { 320, 5, 10, 18, 6, -5 },
  { 327, 10, 2, 18, 4, -11 },
  { 330, 4, 4, 18, 7, -4 },
  { 332, 12, 28, 18, 3, -25 },
  { 374, 12, 22, 18, 3, -22 },
  { 407, 13, 22, 18, 3, -22 },
  { 443, 13, 22, 18, 3, -22 },
  { 479, 12, 22, 18, 3, -22 },
  { 512, 12, 22, 18, 3, -22 },
  { 545, 12, 22, 18, 3, -22 },
  { 578, 12, 22, 18, 3, -22 },
  { 611, 13, 22, 18, 3, -22 },
  { 647, 12, 22, 18, 3, -22 },
  { 680, 12, 22, 18, 3, -22 },
  { 713, 4, 17, 18, 7, -17 },
  { 722, 5, 22, 18, 6, -17 },
  { 736, 12, 15, 18, 3, -17 },
  { 759, 12, 8, 18, 3, -14 },
  { 771, 12, 15, 18, 3, -17 },
  { 794, 10, 22, 18, 5, -22 },
  { 822, 14, 27, 18, 2, -22 },
  { 870, 14, 22, 18, 2, -22 },
  { 909, 12, 22, 18, 3, -22 },
  { 942, 12, 22, 18, 3, -22 },
  { 975, 12, 22, 18, 3, -22 },
  { 1008, 11, 22, 18, 4, -22 },
  { 1039, 13, 22, 18, 3, -22 },
  { 1075, 12, 22, 18, 3, -22 },
  { 1108, 12, 22, 18, 3, -22 },
  { 1141, 10, 22, 18, 4, -22 },
  { 1169, 12, 22, 18, 2, -22 },
  { 1202, 13, 22, 18, 3, -22 },
  { 1238, 12, 22, 18, 4, -22 },
  { 1271, 12, 22, 18, 3, -22 },
  { 1304, 12, 22, 18, 3, -22 },
  { 1337, 12, 22, 18, 3, -22 },
  { 1370, 13, 22, 18, 3, -22 },
  { 1406, 12, 27, 18, 3, -22 },
  { 1447, 13, 22, 18, 3, -22 },
  { 1483, 12, 22, 18, 3, -22 },
  { 1516, 14, 22, 18, 2, -22 },
  { 1555, 12, 22, 18, 3, -22 },
  { 1588, 14, 22, 18, 2, -22 },
  { 1627, 16, 22, 18, 1, -22 },
  { 1671, 14, 22, 18, 2, -22 },
  { 1710, 16, 22, 18, 1, -22 },
  { 1754, 12, 22, 18, 3, -22 },
  { 1787, 6, 28, 18, 7, -25 },
  { 1808, 12, 28, 18, 3, -25 },
  { 1850, 6, 28, 18, 5, -25 },
  { 1871, 12, 12, 18, 3, -22 },
  { 1889, 14, 1, 18, 2, 1 },
  { 1891, 5, 5, 18, 6, -24 },
  { 1895, 13, 17, 18, 2, -17 },
  { 1923, 12, 22, 18, 3, -22 },
  { 1956, 12, 17, 18, 3, -17 },
  { 1982, 12, 22, 18, 3, -22 },
  { 2015, 12, 17, 18, 3, -17 },
  { 2041, 14, 22, 18, 2, -22 },
  { 2080, 12, 22, 18, 3, -17 },
  { 2113, 12, 22, 18, 3, -22 },
  { 2146, 13, 23, 18, 3, -23 },
  { 2184, 11, 28, 18, 3, -23 },
  { 2223, 13, 22, 18, 3, -22 },
  { 2259, 15, 22, 18, 1, -22 },
  { 2301, 14, 17, 18, 2, -17 },
  { 2331, 12, 17, 18, 3, -17 },
  { 2357, 12, 17, 18, 3, -17 },
  { 2383, 12, 22, 18, 3, -17 },
  { 2416, 12, 22, 18, 3, -17 },
  { 2449, 12, 17, 18, 4, -17 },
  { 2475, 12, 17, 18, 3, -17 },
  { 2501, 13, 21, 18, 2, -21 },
  { 2536, 12, 17, 18, 3, -17 },
  { 2562, 14, 17, 18, 2, -17 },
  { 2592, 16, 17, 18, 1, -17 },
  { 2626, 14, 17, 18, 2, -17 },
  { 2656, 14, 22, 18, 2, -17 },
  { 2695, 12, 17, 18, 3, -17 },
  { 2721, 12, 28, 18, 3, -25 },
  { 2763, 2, 28, 18, 8, -25 },
  { 2770, 12, 28, 18, 3, -25 },
  { 2812, 12, 5, 18, 3, -13 },
};

const GFXfont JetBrainsMono_Thin30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_THIN30PT7B_H_
