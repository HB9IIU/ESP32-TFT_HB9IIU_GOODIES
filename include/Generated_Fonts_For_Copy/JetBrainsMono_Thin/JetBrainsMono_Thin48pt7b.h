#ifndef _JETBRAINSMONO_THIN48PT7B_H_
#define _JETBRAINSMONO_THIN48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x18, 0xC6, 0x10, 0x84, 0x20, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDE, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x03, 0x70, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x0C,
  0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x1C, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x1C,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x01, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80,
  0xF1, 0x9E, 0x0E, 0x0C, 0x38, 0x60, 0x60, 0xC7, 0x03, 0x07, 0x38, 0x18,
  0x19, 0x80, 0xC0, 0xCC, 0x06, 0x06, 0x70, 0x30, 0x03, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x00, 0x0F, 0x18, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0xF0, 0x00,
  0x61, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x38, 0x00, 0xC0, 0xC0, 0x06, 0x07,
  0x00, 0x30, 0x3E, 0x01, 0x81, 0xF8, 0x0C, 0x0F, 0xC0, 0x60, 0x76, 0x03,
  0x03, 0x38, 0x18, 0x38, 0xE0, 0xC3, 0x87, 0x86, 0x3C, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x00,
  0xE7, 0xFC, 0x00, 0x19, 0xC1, 0xC0, 0x06, 0x30, 0x18, 0x01, 0x86, 0x03,
  0x80, 0x70, 0xC0, 0x30, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xE0,
  0x60, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x01, 0x80, 0x61, 0x80, 0x30, 0x1C,
  0x30, 0x07, 0x03, 0x0C, 0x00, 0x71, 0xE3, 0x00, 0x07, 0xF8, 0xE0, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x1E, 0x00, 0x03, 0x0F, 0xF0, 0x00, 0xE3, 0x87, 0x00,
  0x18, 0x60, 0x70, 0x06, 0x18, 0x06, 0x01, 0xC3, 0x00, 0xC0, 0x30, 0x60,
  0x18, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x60, 0x30, 0x0C, 0x18,
  0x06, 0x01, 0x86, 0x00, 0xC0, 0x31, 0xC0, 0x1C, 0x06, 0x30, 0x01, 0xC1,
  0x8C, 0x00, 0x1F, 0xF3, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x0E, 0xE0, 0x30, 0x0C, 0xE0,
  0x38, 0x1C, 0xE0, 0x1C, 0x18, 0xE0, 0x0E, 0x38, 0xE0, 0x06, 0x30, 0xE0,
  0x07, 0x70, 0xE0, 0x03, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xC0, 0xE0,
  0x01, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x07, 0x38, 0x70, 0x0E, 0x18, 0x78,
  0x1E, 0x1C, 0x3F, 0xF8, 0x0E, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0x80, 0x04, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x38, 0x02, 0xF8, 0x1C, 0x0F,
  0x7F, 0x8C, 0x3F, 0xC7, 0xF2, 0x7F, 0x00, 0x7F, 0x7C, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x08, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xE3, 0x80,
  0x0E, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x70, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x70, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x73, 0x80, 0x0E, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x0F,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00,
  0xF3, 0x00, 0x1E, 0x30, 0x07, 0x83, 0x00, 0xF0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x78, 0x07, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x31,
  0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00,
  0xE3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x03, 0x1C,
  0x00, 0xC6, 0x00, 0x33, 0x80, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x1F,
  0xC0, 0xCF, 0xFE, 0x1B, 0x83, 0xE3, 0xC0, 0x1C, 0x70, 0x01, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x80, 0x1C, 0x3C, 0x07,
  0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x73, 0xF8, 0x03, 0x7F, 0xF0,
  0x3E, 0x07, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x38, 0xE0, 0x00, 0xE6, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00,
  0x38, 0xC0, 0x03, 0x87, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0C, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x38, 0x00, 0xE3, 0x00,
  0x06, 0x70, 0x00, 0x77, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x03, 0x70,
  0x00, 0x33, 0x00, 0x07, 0x38, 0x00, 0x61, 0x80, 0x0C, 0x1C, 0x01, 0xC0,
  0x70, 0x70, 0x03, 0xDE, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x78, 0xE0,
  0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0x60, 0x00, 0x37, 0x00, 0x07, 0x38, 0x00, 0xE3, 0xC0, 0x1C, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0,
  0x3C, 0x07, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00,
  0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x70, 0x00,
  0x73, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x3E, 0x0F, 0xC0, 0xFF, 0xEC, 0x01,
  0xFC, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF,
  0xFF, 0xFD, 0xF0, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x0F, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81,
  0xC0, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x01, 0xFC, 0xF8, 0x0F, 0xFD, 0xF0, 0x1C, 0x0B, 0xE0, 0x70,
  0x0F, 0xC0, 0xC0, 0x1F, 0x81, 0x80, 0x1F, 0x03, 0x00, 0x3E, 0x06, 0x00,
  0x7C, 0x0C, 0x00, 0xF8, 0x18, 0x01, 0xF0, 0x30, 0x03, 0xE0, 0x60, 0x07,
  0xC0, 0xC0, 0x0F, 0x81, 0x80, 0x1F, 0x03, 0x00, 0x3E, 0x07, 0x00, 0xFC,
  0x0E, 0x01, 0xF8, 0x0E, 0x05, 0xF0, 0x1F, 0xFB, 0xE0, 0x0F, 0xE7, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00,
  0x60, 0x70, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C,
  0x03, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0x80,
  0x1C, 0x03, 0x00, 0x18, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x86, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x38, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0, 0x1F, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE,
  0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xE0, 0x0F, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x3C, 0xE0,
  0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x38,
  0x01, 0xC7, 0x80, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0x80, 0xF8, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x00,
  0x38, 0xE0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E,
  0x03, 0xC3, 0x80, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x38, 0x01, 0xC7, 0x80,
  0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x06,
  0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x03, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x01, 0xCE,
  0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x07, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x06, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00, 0xE1,
  0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7D,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0B, 0xEC, 0x01, 0xBE, 0xC0, 0x1B,
  0xEC, 0x03, 0x3E, 0x60, 0x33, 0xE6, 0x03, 0x3E, 0x20, 0x63, 0xE3, 0x06,
  0x3E, 0x30, 0x63, 0xE1, 0x8C, 0x3E, 0x18, 0xC3, 0xE1, 0x88, 0x3E, 0x0D,
  0x83, 0xE0, 0xD8, 0x3E, 0x0D, 0x03, 0xE0, 0x70, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x30, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xD8, 0x01, 0xFB, 0x00, 0x3F, 0x70, 0x07, 0xE6, 0x00, 0xFC, 0xC0,
  0x1F, 0x8C, 0x03, 0xF1, 0x80, 0x7E, 0x38, 0x0F, 0xC3, 0x01, 0xF8, 0x60,
  0x3F, 0x06, 0x07, 0xE0, 0xC0, 0xFC, 0x1C, 0x1F, 0x81, 0x83, 0xF0, 0x30,
  0x7E, 0x03, 0x0F, 0xC0, 0x61, 0xF8, 0x0C, 0x3F, 0x00, 0xC7, 0xE0, 0x18,
  0xFC, 0x03, 0x9F, 0x80, 0x33, 0xF0, 0x06, 0x7E, 0x00, 0x6F, 0xC0, 0x0D,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0x80, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x03, 0xC7, 0x00,
  0x38, 0xE0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xD8, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x03, 0x87, 0x80, 0xF0, 0x7F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x38, 0x01, 0xF1, 0xC0,
  0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x06,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x03, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x03, 0xC7, 0x00, 0x38, 0xE0,
  0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xD8, 0x00,
  0x33, 0x80, 0x0E, 0x30, 0x03, 0x87, 0x80, 0xF0, 0x7F, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x1C, 0xE0, 0x07, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0E, 0x03, 0x00,
  0xE0, 0x38, 0x0E, 0x01, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0E,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07,
  0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80, 0x00, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0xE1, 0xF0, 0x0E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x71, 0xC0, 0x1C, 0x3C, 0x07,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x05, 0x00, 0xFC, 0x06, 0xC0, 0x6E,
  0x03, 0x60, 0x33, 0x01, 0xB0, 0x19, 0x80, 0xD8, 0x0C, 0xC0, 0x6C, 0x06,
  0x60, 0x36, 0x03, 0x30, 0x11, 0x01, 0x98, 0x18, 0xC1, 0xCE, 0x0C, 0x60,
  0xC7, 0x06, 0x30, 0x61, 0x83, 0x18, 0x30, 0xC1, 0x8C, 0x18, 0x60, 0xC6,
  0x0C, 0x30, 0x41, 0x06, 0x18, 0x60, 0x83, 0x0C, 0x30, 0x63, 0x87, 0x18,
  0x31, 0x83, 0x8C, 0x18, 0xC0, 0xC6, 0x0C, 0x60, 0x62, 0x06, 0x30, 0x31,
  0x03, 0x18, 0x19, 0x80, 0x8C, 0x0C, 0xC0, 0x66, 0x06, 0x60, 0x33, 0x03,
  0xB0, 0x1B, 0x01, 0xD8, 0x0D, 0x80, 0x68, 0x06, 0xC0, 0x34, 0x03, 0x60,
  0x1E, 0x00, 0xB0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xC0, 0x00, 0x61, 0xC0, 0x01,
  0x81, 0x80, 0x07, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x01,
  0x80, 0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x07,
  0x03, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x07,
  0x30, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0xC1, 0xC0,
  0x00, 0xC1, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x63, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0x80, 0x30,
  0x70, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1B,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x8F, 0x81,
  0xC0, 0x1C, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x07, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3C, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xF7, 0x00, 0x1F, 0x3C, 0x03, 0x71, 0xFF, 0xE7, 0x0F, 0xFC, 0x70,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xF8, 0x1C, 0xFF, 0xC3,
  0xB8, 0x3C, 0x7C, 0x01, 0xCF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x37,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xBC,
  0x00, 0x77, 0xC0, 0x1C, 0xFC, 0x07, 0x9D, 0xFF, 0xE3, 0x8F, 0xF0, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1C, 0x01, 0xC7, 0x00, 0x1C,
  0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x73, 0xC0, 0x0E, 0x3C, 0x07, 0x83,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x03, 0xF0, 0xE1, 0xFF, 0x9C, 0x78, 0x7B, 0x9C, 0x01, 0xF7, 0x00, 0x1E,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0E, 0xC0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x1F, 0x3C, 0x06, 0xE3,
  0xFF, 0x9C, 0x3F, 0xE3, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x78, 0x7C,
  0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x02, 0xC0, 0x01, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x9C, 0x78, 0x7B, 0x9C, 0x01, 0x77, 0x00, 0x1E, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0xF7, 0x00,
  0x1E, 0x70, 0x07, 0xCF, 0x03, 0xB8, 0x7F, 0xE7, 0x07, 0xF0, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x83, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xF8, 0x1C, 0xFF,
  0xC3, 0xB8, 0x3C, 0x7C, 0x01, 0xCF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00,
  0x37, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x1F, 0xFF,
  0x0F, 0xFE, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x0E,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x70, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0x83, 0xC6, 0xFE, 0x3F, 0x34,
  0x7B, 0x1D, 0xC1, 0xD0, 0x7E, 0x07, 0x03, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x06, 0x01, 0xF8, 0x1C, 0xFF, 0xC3, 0xB8, 0x3C,
  0x7C, 0x01, 0xCF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x06,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x03,
  0xB8, 0x00, 0x37, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E,
  0xC0, 0x01, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x3C, 0x07, 0x83, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x1C, 0xFF, 0xC3, 0xBC, 0x3C, 0x7C, 0x01,
  0xCF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xBC, 0x00, 0x77, 0xC0, 0x1C,
  0xFC, 0x07, 0x9D, 0xFF, 0xE3, 0x8F, 0xF0, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x9C, 0x78, 0x7B,
  0x9C, 0x01, 0xF7, 0x00, 0x1E, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xC0, 0x03, 0xDC, 0x00, 0x7B,
  0x80, 0x1F, 0x3C, 0x06, 0xE3, 0xFF, 0x9C, 0x3F, 0xE3, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0xF8, 0x1C, 0xFF, 0xC3,
  0xB8, 0x3C, 0x7C, 0x01, 0xCF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x37,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0x07, 0xC3, 0x80, 0x0E, 0x30, 0x00,
  0x67, 0x00, 0x07, 0x70, 0x00, 0x37, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x07,
  0x3C, 0x00, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x66, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xE1, 0xE0, 0x38, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x0C,
  0xC0, 0x00, 0xE7, 0x00, 0x06, 0x18, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x38, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xEC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x14, 0x03, 0x60, 0x34,
  0x07, 0x70, 0x36, 0x07, 0x70, 0x36, 0x06, 0x30, 0x36, 0x06, 0x30, 0x26,
  0x06, 0x30, 0x62, 0x06, 0x30, 0x63, 0x0E, 0x38, 0x63, 0x0E, 0x38, 0x63,
  0x0C, 0x18, 0x63, 0x0C, 0x18, 0x41, 0x0C, 0x18, 0xC1, 0x8C, 0x18, 0xC1,
  0x9C, 0x1C, 0xC1, 0x9C, 0x1C, 0xC1, 0x98, 0x0C, 0x81, 0x98, 0x0D, 0x80,
  0xD8, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x70, 0xF0, 0x00, 0x7B, 0x80, 0x03,
  0x0E, 0x00, 0x38, 0x38, 0x03, 0x80, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x1C,
  0x1C, 0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0xE0, 0x00, 0x36, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x33,
  0x80, 0x03, 0x8E, 0x00, 0x38, 0x30, 0x01, 0x81, 0xC0, 0x1C, 0x07, 0x01,
  0xC0, 0x18, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x8E, 0x00, 0x0C, 0x60, 0x00,
  0x77, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x1C,
  0xE0, 0x00, 0xE3, 0x00, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x00,
  0x18, 0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0x60, 0x30, 0x03, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x8E,
  0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1B, 0xFE, 0x00, 0xF8, 0x78,
  0x07, 0x80, 0xC0, 0x3C, 0x07, 0x03, 0xE0, 0x1C, 0x1B, 0x00, 0x7F, 0xD8,
  0x01, 0xFC, 0xC0, 0x01, 0x00,
};

const GFXglyph JetBrainsMono_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 5, 35, 29, 12, -35 },
  { 23, 13, 14, 29, 8, -35 },
  { 46, 25, 35, 29, 2, -35 },
  { 156, 21, 49, 29, 4, -42 },
  { 285, 27, 35, 29, 1, -35 },
  { 404, 24, 36, 29, 3, -36 },
  { 512, 3, 14, 29, 13, -35 },
  { 518, 13, 46, 29, 10, -40 },
  { 593, 13, 46, 29, 6, -40 },
  { 668, 25, 24, 29, 2, -29 },
  { 743, 21, 22, 29, 4, -27 },
  { 801, 8, 15, 29, 9, -7 },
  { 816, 15, 2, 29, 7, -17 },
  { 820, 7, 7, 29, 11, -7 },
  { 827, 19, 45, 29, 5, -40 },
  { 934, 20, 36, 29, 4, -36 },
  { 1024, 20, 35, 29, 5, -35 },
  { 1112, 21, 36, 29, 4, -36 },
  { 1207, 20, 35, 29, 4, -35 },
  { 1295, 18, 35, 29, 5, -35 },
  { 1374, 19, 35, 29, 5, -35 },
  { 1458, 21, 35, 29, 4, -35 },
  { 1550, 21, 35, 29, 4, -35 },
  { 1642, 20, 36, 29, 4, -36 },
  { 1732, 21, 36, 29, 4, -36 },
  { 1827, 7, 27, 29, 11, -27 },
  { 1851, 9, 35, 29, 9, -27 },
  { 1891, 20, 24, 29, 4, -28 },
  { 1951, 19, 13, 29, 5, -22 },
  { 1982, 20, 24, 29, 4, -28 },
  { 2042, 16, 35, 29, 8, -35 },
  { 2112, 23, 45, 29, 3, -36 },
  { 2242, 23, 35, 29, 3, -35 },
  { 2343, 20, 35, 29, 5, -35 },
  { 2431, 19, 36, 29, 5, -36 },
  { 2517, 19, 35, 29, 5, -35 },
  { 2601, 18, 35, 29, 6, -35 },
  { 2680, 19, 35, 29, 6, -35 },
  { 2764, 19, 36, 29, 5, -36 },
  { 2850, 19, 35, 29, 5, -35 },
  { 2934, 17, 35, 29, 6, -35 },
  { 3009, 20, 35, 29, 3, -35 },
  { 3097, 21, 35, 29, 5, -35 },
  { 3189, 19, 35, 29, 6, -35 },
  { 3273, 20, 35, 29, 4, -35 },
  { 3361, 19, 35, 29, 5, -35 },
  { 3445, 19, 36, 29, 5, -36 },
  { 3531, 21, 35, 29, 5, -35 },
  { 3623, 19, 45, 29, 5, -36 },
  { 3730, 20, 35, 29, 5, -35 },
  { 3818, 21, 36, 29, 4, -36 },
  { 3913, 23, 35, 29, 3, -35 },
  { 4014, 19, 35, 29, 5, -35 },
  { 4098, 23, 35, 29, 3, -35 },
  { 4199, 25, 35, 29, 2, -35 },
  { 4309, 23, 35, 29, 3, -35 },
  { 4410, 24, 35, 29, 2, -35 },
  { 4515, 20, 35, 29, 4, -35 },
  { 4603, 10, 45, 29, 11, -40 },
  { 4660, 19, 45, 29, 5, -40 },
  { 4767, 11, 45, 29, 7, -40 },
  { 4829, 19, 19, 29, 5, -35 },
  { 4875, 23, 2, 29, 3, 1 },
  { 4881, 8, 7, 29, 10, -38 },
  { 4888, 20, 27, 29, 4, -27 },
  { 4956, 19, 35, 29, 5, -35 },
  { 5040, 19, 27, 29, 5, -27 },
  { 5105, 19, 35, 29, 5, -35 },
  { 5189, 19, 27, 29, 5, -27 },
  { 5254, 22, 35, 29, 3, -35 },
  { 5351, 19, 36, 29, 5, -27 },
  { 5437, 19, 35, 29, 5, -35 },
  { 5521, 21, 37, 29, 5, -37 },
  { 5619, 17, 46, 29, 5, -37 },
  { 5717, 20, 35, 29, 5, -35 },
  { 5805, 24, 35, 29, 2, -35 },
  { 5910, 21, 27, 29, 4, -27 },
  { 5981, 19, 27, 29, 5, -27 },
  { 6046, 19, 27, 29, 5, -27 },
  { 6111, 19, 36, 29, 5, -27 },
  { 6197, 19, 36, 29, 5, -27 },
  { 6283, 19, 27, 29, 6, -27 },
  { 6348, 20, 27, 29, 4, -27 },
  { 6416, 21, 34, 29, 3, -34 },
  { 6506, 19, 26, 29, 5, -26 },
  { 6568, 21, 26, 29, 4, -26 },
  { 6637, 24, 26, 29, 2, -26 },
  { 6715, 21, 26, 29, 4, -26 },
  { 6784, 21, 35, 29, 4, -26 },
  { 6876, 19, 26, 29, 5, -26 },
  { 6938, 19, 45, 29, 5, -40 },
  { 7045, 3, 45, 29, 13, -40 },
  { 7062, 19, 45, 29, 5, -40 },
  { 7169, 21, 9, 29, 4, -21 },
};

const GFXfont JetBrainsMono_Thin48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_THIN48PT7B_H_
