#ifndef _JETBRAINSMONO_THIN65PT7B_H_
#define _JETBRAINSMONO_THIN65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x63, 0xF0, 0x3E, 0x0C,
  0x1E, 0x0F, 0x01, 0x81, 0xE1, 0xC0, 0x30, 0x1E, 0x78, 0x06, 0x03, 0xCF,
  0x00, 0xC0, 0x39, 0xC0, 0x18, 0x07, 0xB8, 0x03, 0x00, 0xF7, 0x00, 0x60,
  0x0E, 0xE0, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x78,
  0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x0F, 0x03, 0x00,
  0x01, 0xF0, 0x60, 0x00, 0x1F, 0x8C, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x3F, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x0C, 0x0F, 0x00, 0x01,
  0x80, 0xF0, 0x00, 0x30, 0x1E, 0x00, 0x06, 0x01, 0xE0, 0x00, 0xC0, 0x3C,
  0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0F, 0xC0, 0x0C,
  0x01, 0xF8, 0x01, 0x80, 0x3F, 0x00, 0x30, 0x07, 0xE0, 0x06, 0x00, 0xFE,
  0x00, 0xC0, 0x3D, 0xC0, 0x18, 0x07, 0xBC, 0x03, 0x01, 0xE3, 0xC0, 0x60,
  0x78, 0x3E, 0x0C, 0x1F, 0x03, 0xF9, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x08, 0x3F, 0xE0, 0x00, 0x03, 0x87, 0xFF, 0x80, 0x00, 0x38, 0x3C,
  0x1E, 0x00, 0x01, 0xC3, 0x80, 0x78, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x01,
  0xC1, 0xC0, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x01,
  0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x38,
  0x03, 0x81, 0x80, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x0F, 0x01, 0xC1, 0xC0,
  0x00, 0x3F, 0xFE, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0xE0, 0x00, 0x01, 0xFC,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x83, 0xFE, 0x00, 0x00, 0x38, 0x3F, 0xF8, 0x00,
  0x03, 0x83, 0xE3, 0xE0, 0x00, 0x1C, 0x3C, 0x07, 0x80, 0x01, 0xC1, 0xC0,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x80, 0x1C, 0x38, 0x00, 0x1C, 0x01, 0xC1, 0xC0, 0x00, 0xF0,
  0x1E, 0x1C, 0x00, 0x03, 0xF7, 0xE1, 0xC0, 0x00, 0x0F, 0xFE, 0x1E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0x78, 0x0F, 0x00, 0x0E, 0x70,
  0x07, 0x00, 0x1E, 0x70, 0x07, 0x80, 0x1C, 0xF0, 0x03, 0xC0, 0x38, 0xF0,
  0x01, 0xE0, 0x38, 0xE0, 0x00, 0xE0, 0x70, 0xE0, 0x00, 0xF0, 0x70, 0xE0,
  0x00, 0x78, 0xE0, 0xE0, 0x00, 0x3D, 0xE0, 0xE0, 0x00, 0x1D, 0xC0, 0xE0,
  0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0x70,
  0x00, 0x1C, 0xF0, 0x78, 0x00, 0x3C, 0x70, 0x78, 0x00, 0x78, 0x38, 0x3E,
  0x01, 0xF0, 0x3C, 0x1F, 0x8F, 0xE0, 0x1E, 0x0F, 0xFF, 0xC0, 0x0E, 0x07,
  0xFF, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xB9, 0xCE, 0x73, 0x9C, 0x00, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x18, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x10, 0x00, 0x70, 0x00, 0x5E, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x1C, 0x03,
  0xFF, 0xFE, 0x0E, 0x0F, 0xFC, 0xFF, 0xC7, 0x1F, 0xF8, 0x0F, 0xF9, 0xBF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xE0, 0x3F, 0xC0,
  0x7C, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xB8, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x7C,
  0x38, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xE0, 0x38, 0x00, 0x7C, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xC3, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x3F, 0xE0, 0x07, 0x1F, 0xFF, 0x00, 0xE7, 0xFF, 0xF8, 0x1D, 0xE0, 0x1F,
  0x83, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x87,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x0C, 0x00, 0x07, 0x3F, 0xF8, 0x01, 0xCF, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFC, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x0F, 0x80, 0x0F, 0x80, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x1F,
  0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0xC1,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0,
  0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x83, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xDC, 0x01, 0xFF, 0xF7, 0x80, 0x0F,
  0xF8, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x87, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x80,
  0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x0F, 0xE0, 0x01, 0xFF, 0x1F, 0x80,
  0x07, 0xFF, 0xBF, 0x00, 0x1F, 0xDF, 0x7E, 0x00, 0x7C, 0x03, 0xFC, 0x00,
  0xE0, 0x03, 0xF8, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0x00, 0x07, 0xE0, 0x0E,
  0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x3F, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0x80,
  0x03, 0xF0, 0x07, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0x1C, 0x00,
  0x1F, 0x80, 0x38, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0xE0, 0x00,
  0xFC, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x0F,
  0xE0, 0x07, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0x3F,
  0x80, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x3E, 0x0E, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x3C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x1C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x7C, 0x70, 0x00,
  0x3F, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x01,
  0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1F,
  0x00, 0x3E, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xC7, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x7F, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7E,
  0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x3E, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x7C, 0x00,
  0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xF0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF6, 0x00, 0x03,
  0x7E, 0xE0, 0x00, 0xEF, 0xDC, 0x00, 0x1D, 0xF9, 0x80, 0x03, 0x3F, 0x38,
  0x00, 0xE7, 0xE7, 0x00, 0x1C, 0xFC, 0x60, 0x03, 0x1F, 0x8E, 0x00, 0xE3,
  0xF0, 0xC0, 0x18, 0x7E, 0x1C, 0x03, 0x0F, 0xC3, 0x80, 0xE1, 0xF8, 0x30,
  0x18, 0x3F, 0x07, 0x07, 0x07, 0xE0, 0xE0, 0xE0, 0xFC, 0x0C, 0x18, 0x1F,
  0x81, 0xC7, 0x03, 0xF0, 0x38, 0xE0, 0x7E, 0x03, 0x18, 0x0F, 0xC0, 0x77,
  0x01, 0xF8, 0x06, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x01, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x38, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0xE0, 0x00, 0x3F, 0x70, 0x00, 0x1F, 0xB8, 0x00, 0x0F,
  0xCE, 0x00, 0x07, 0xE7, 0x00, 0x03, 0xF1, 0xC0, 0x01, 0xF8, 0xE0, 0x00,
  0xFC, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x83, 0x00,
  0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF0, 0x38, 0x01, 0xF8, 0x1C,
  0x00, 0xFC, 0x06, 0x00, 0x7E, 0x03, 0x80, 0x3F, 0x01, 0xC0, 0x1F, 0x80,
  0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x0C, 0x03, 0xF0, 0x07, 0x01, 0xF8,
  0x03, 0x80, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x38, 0x1F,
  0x80, 0x0E, 0x0F, 0xC0, 0x07, 0x07, 0xE0, 0x01, 0xC3, 0xF0, 0x00, 0xE1,
  0xF8, 0x00, 0x70, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x0E, 0x3F, 0x00, 0x03,
  0x9F, 0x80, 0x01, 0xCF, 0xC0, 0x00, 0xE7, 0xE0, 0x00, 0x3B, 0xF0, 0x00,
  0x1D, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x3F, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x03,
  0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x70, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x78, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x07,
  0x80, 0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x6C, 0x00, 0x7E, 0x00, 0x36, 0x00,
  0x3F, 0x00, 0x1B, 0x80, 0x1F, 0x80, 0x0D, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0x70, 0x07, 0x30, 0x07, 0x38, 0x03, 0x98, 0x03, 0x9C, 0x01, 0xCC,
  0x01, 0xCE, 0x00, 0xC6, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x73, 0x80, 0x31,
  0xC0, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x0E,
  0x18, 0x0E, 0x1C, 0x06, 0x0C, 0x07, 0x0E, 0x03, 0x06, 0x03, 0x87, 0x01,
  0x83, 0x81, 0xC3, 0x80, 0xC1, 0xC0, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x1C, 0x0E,
  0x0C, 0x06, 0x0E, 0x07, 0x06, 0x03, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x81,
  0xC3, 0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x18, 0x70,
  0x1C, 0x60, 0x0C, 0x30, 0x0E, 0x30, 0x06, 0x18, 0x07, 0x18, 0x03, 0x1C,
  0x03, 0x8C, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x73, 0x00, 0x19, 0xC0, 0x39, 0x80, 0x0C, 0xE0, 0x0E, 0xC0, 0x06,
  0x60, 0x07, 0x60, 0x03, 0x30, 0x03, 0xB0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x37, 0x3F, 0x00, 0x1E, 0xE3, 0xFC,
  0x1F, 0x9C, 0x1F, 0xFF, 0xE3, 0x81, 0xFF, 0xF0, 0x70, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x0F,
  0xF8, 0x0E, 0x1F, 0xFF, 0x07, 0x3F, 0x1F, 0xC3, 0x9C, 0x01, 0xF1, 0xD8,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x7C, 0x00, 0x07, 0xBB,
  0x00, 0x07, 0x9D, 0xE0, 0x07, 0x8E, 0x7C, 0x0F, 0xC7, 0x1F, 0xFF, 0x83,
  0x83, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF8, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x3F, 0xF0, 0x70, 0x7F, 0xFC, 0x38,
  0x7F, 0x1F, 0x9C, 0x7C, 0x01, 0xCE, 0x78, 0x00, 0x37, 0x78, 0x00, 0x1F,
  0xB8, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x06, 0xE3, 0xC0, 0x07,
  0x71, 0xF8, 0x1F, 0x38, 0x3F, 0xFF, 0x1C, 0x0F, 0xFE, 0x0E, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xE0,
  0x0F, 0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x07, 0xE0, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFF, 0x83, 0x83, 0xFF, 0xE1, 0xC3, 0xF8, 0xF8, 0xE3, 0xE0, 0x0E,
  0x73, 0xC0, 0x01, 0xBB, 0xC0, 0x00, 0xDD, 0xC0, 0x00, 0x3E, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0xEF, 0x00, 0x03, 0x73, 0xC0, 0x01, 0xB8, 0xF8, 0x03, 0x9C, 0x3F, 0x8F,
  0x8E, 0x0F, 0xFF, 0x87, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0xF8, 0x0E, 0x1F, 0xFF, 0x07, 0x1F,
  0x1F, 0xC3, 0x9C, 0x01, 0xF1, 0xDC, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x7C,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0x3F, 0xE3, 0xFF, 0x3B, 0xDF,
  0x9C, 0xFD, 0xD0, 0x3D, 0x81, 0xEF, 0x00, 0xF8, 0x07, 0x78, 0x07, 0xC0,
  0x3F, 0xC0, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F,
  0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03,
  0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E,
  0x00, 0x70, 0xE0, 0x7F, 0xC0, 0x70, 0xFF, 0xF8, 0x38, 0xF8, 0xFE, 0x1C,
  0xE0, 0x0F, 0x8E, 0xE0, 0x01, 0xE7, 0x60, 0x00, 0x7B, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0xFF, 0xC0, 0x70, 0xFF, 0xF8, 0x39, 0xF8, 0xFE,
  0x1C, 0xE0, 0x0F, 0x8E, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x3B, 0xE0, 0x00, 0x3D, 0xD8, 0x00, 0x3C, 0xEF, 0x00, 0x3C, 0x73, 0xE0,
  0x7C, 0x38, 0xFF, 0xFC, 0x1C, 0x1F, 0xFC, 0x0E, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x83,
  0x83, 0xFF, 0xE1, 0xC3, 0xF8, 0xFC, 0xE3, 0xC0, 0x0E, 0x73, 0xC0, 0x01,
  0xBB, 0xC0, 0x00, 0x7D, 0xC0, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0x78, 0x00,
  0x37, 0x1E, 0x00, 0x3B, 0x8F, 0xC0, 0xF9, 0xC1, 0xFF, 0xF8, 0xE0, 0x7F,
  0xF0, 0x70, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x3C, 0x7F, 0xFC, 0x0F, 0x3E, 0x3F,
  0xC3, 0xDC, 0x00, 0xF8, 0xFE, 0x00, 0x1E, 0x3F, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0x80,
  0x07, 0xC3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0xE0,
  0x03, 0xDC, 0x00, 0xF8, 0x01, 0xCE, 0x00, 0x6C, 0x00, 0xE7, 0x00, 0x36,
  0x00, 0x73, 0x80, 0x1B, 0x00, 0x39, 0xC0, 0x0D, 0x80, 0x1C, 0xF0, 0x06,
  0xE0, 0x1E, 0x38, 0x07, 0x30, 0x0E, 0x1C, 0x03, 0x18, 0x07, 0x0E, 0x01,
  0x8C, 0x03, 0x87, 0x00, 0xC6, 0x01, 0xC3, 0x80, 0x63, 0x80, 0xE1, 0xE0,
  0x71, 0xC0, 0xE0, 0x70, 0x38, 0x60, 0x70, 0x38, 0x18, 0x30, 0x38, 0x1C,
  0x0C, 0x18, 0x1C, 0x0E, 0x06, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x01,
  0xC3, 0x83, 0x87, 0x00, 0xE1, 0x80, 0xC3, 0x80, 0x70, 0xC0, 0x61, 0xC0,
  0x38, 0x60, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x38,
  0x03, 0x9C, 0x07, 0x38, 0x01, 0xCC, 0x01, 0x9C, 0x00, 0xE6, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x1D,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x38,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x67, 0xFC, 0x00, 0x0D, 0xFF, 0xC0, 0x01, 0xF8, 0x3C, 0x00,
  0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00,
  0x3C, 0x07, 0xC0, 0x03, 0xC1, 0xF8, 0x00, 0x3F, 0xFB, 0x00, 0x03, 0xFE,
  0x60, 0x00, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 7, 47, 39, 16, -47 },
  { 43, 17, 19, 39, 11, -47 },
  { 84, 35, 47, 39, 2, -47 },
  { 290, 27, 66, 39, 6, -57 },
  { 513, 37, 48, 39, 1, -48 },
  { 735, 32, 49, 39, 4, -48 },
  { 931, 5, 19, 39, 17, -47 },
  { 943, 19, 63, 39, 13, -55 },
  { 1093, 19, 63, 39, 7, -55 },
  { 1243, 33, 33, 39, 3, -40 },
  { 1380, 29, 31, 39, 5, -37 },
  { 1493, 11, 20, 39, 12, -10 },
  { 1521, 21, 3, 39, 9, -23 },
  { 1529, 9, 10, 39, 15, -9 },
  { 1541, 27, 61, 39, 6, -54 },
  { 1747, 27, 49, 39, 6, -48 },
  { 1913, 28, 47, 39, 6, -47 },
  { 2078, 29, 48, 39, 5, -48 },
  { 2252, 26, 48, 39, 6, -47 },
  { 2408, 26, 47, 39, 6, -47 },
  { 2561, 27, 48, 39, 6, -47 },
  { 2723, 27, 48, 39, 6, -47 },
  { 2885, 28, 47, 39, 6, -47 },
  { 3050, 27, 49, 39, 6, -48 },
  { 3216, 27, 48, 39, 6, -48 },
  { 3378, 9, 37, 39, 15, -36 },
  { 3420, 12, 46, 39, 12, -36 },
  { 3489, 27, 33, 39, 6, -38 },
  { 3601, 27, 17, 39, 6, -30 },
  { 3659, 27, 33, 39, 6, -38 },
  { 3771, 22, 47, 39, 11, -47 },
  { 3901, 31, 60, 39, 4, -48 },
  { 4134, 31, 47, 39, 4, -47 },
  { 4317, 27, 47, 39, 7, -47 },
  { 4476, 26, 49, 39, 7, -48 },
  { 4636, 25, 47, 39, 7, -47 },
  { 4783, 25, 47, 39, 8, -47 },
  { 4930, 27, 47, 39, 7, -47 },
  { 5089, 26, 49, 39, 7, -48 },
  { 5249, 25, 47, 39, 7, -47 },
  { 5396, 23, 48, 39, 8, -48 },
  { 5534, 26, 48, 39, 5, -47 },
  { 5690, 28, 48, 39, 7, -48 },
  { 5858, 26, 47, 39, 8, -47 },
  { 6011, 27, 47, 39, 6, -47 },
  { 6170, 25, 47, 39, 7, -47 },
  { 6317, 25, 49, 39, 7, -48 },
  { 6471, 28, 47, 39, 7, -47 },
  { 6636, 26, 60, 39, 7, -48 },
  { 6831, 27, 47, 39, 7, -47 },
  { 6990, 27, 49, 39, 6, -48 },
  { 7156, 31, 47, 39, 4, -47 },
  { 7339, 25, 48, 39, 7, -47 },
  { 7489, 31, 47, 39, 4, -47 },
  { 7672, 33, 47, 39, 3, -47 },
  { 7866, 33, 47, 39, 3, -47 },
  { 8060, 33, 47, 39, 3, -47 },
  { 8254, 27, 47, 39, 6, -47 },
  { 8413, 15, 61, 39, 14, -54 },
  { 8528, 27, 61, 39, 6, -54 },
  { 8734, 15, 61, 39, 10, -54 },
  { 8849, 27, 25, 39, 6, -47 },
  { 8934, 31, 3, 39, 4, 2 },
  { 8946, 11, 9, 39, 13, -51 },
  { 8959, 27, 37, 39, 5, -36 },
  { 9084, 25, 48, 39, 7, -47 },
  { 9234, 26, 37, 39, 7, -36 },
  { 9355, 25, 48, 39, 7, -47 },
  { 9505, 25, 37, 39, 7, -36 },
  { 9621, 29, 47, 39, 5, -47 },
  { 9792, 25, 48, 39, 7, -36 },
  { 9942, 25, 47, 39, 7, -47 },
  { 10089, 29, 50, 39, 6, -50 },
  { 10271, 23, 62, 39, 6, -50 },
  { 10450, 28, 47, 39, 7, -47 },
  { 10615, 32, 47, 39, 3, -47 },
  { 10803, 29, 36, 39, 5, -36 },
  { 10934, 25, 36, 39, 7, -36 },
  { 11047, 25, 37, 39, 7, -36 },
  { 11163, 25, 48, 39, 7, -36 },
  { 11313, 25, 48, 39, 7, -36 },
  { 11463, 26, 36, 39, 8, -36 },
  { 11580, 27, 37, 39, 6, -36 },
  { 11705, 28, 46, 39, 5, -46 },
  { 11866, 25, 37, 39, 7, -36 },
  { 11982, 29, 36, 39, 5, -36 },
  { 12113, 33, 36, 39, 3, -36 },
  { 12262, 29, 36, 39, 5, -36 },
  { 12393, 29, 48, 39, 5, -36 },
  { 12567, 25, 36, 39, 7, -36 },
  { 12680, 27, 61, 39, 6, -54 },
  { 12886, 3, 61, 39, 18, -54 },
  { 12909, 27, 61, 39, 6, -54 },
  { 13115, 27, 12, 39, 6, -29 },
};

const GFXfont JetBrainsMono_Thin65pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin65pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _JETBRAINSMONO_THIN65PT7B_H_
