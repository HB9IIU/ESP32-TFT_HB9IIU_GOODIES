#ifndef _JETBRAINSMONO_THIN64PT7B_H_
#define _JETBRAINSMONO_THIN64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x77, 0x80,
  0x3B, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xC7, 0x1F, 0x00, 0xF0, 0x70, 0x78, 0x1E, 0x07, 0x03,
  0xC1, 0xC0, 0x70, 0x1C, 0x3C, 0x07, 0x01, 0xE3, 0x80, 0x70, 0x0E, 0x38,
  0x07, 0x00, 0xE3, 0x80, 0x70, 0x0E, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0xC7,
  0x00, 0x00, 0x3F, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x7E, 0x00, 0x00,
  0x71, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x70,
  0x07, 0x70, 0x07, 0x00, 0x77, 0x00, 0x70, 0x0F, 0x78, 0x07, 0x00, 0xE7,
  0x80, 0x70, 0x0E, 0x3C, 0x07, 0x01, 0xE1, 0xE0, 0x70, 0x3C, 0x1F, 0x87,
  0x0F, 0x80, 0x7F, 0x77, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x70, 0xFF, 0xC0, 0x00, 0x0E, 0x1F, 0xFE, 0x00, 0x00, 0xE3, 0xC0, 0xF0,
  0x00, 0x1C, 0x38, 0x07, 0x80, 0x03, 0x87, 0x00, 0x38, 0x00, 0x30, 0x70,
  0x03, 0x80, 0x07, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x03, 0x81, 0xC0, 0x07, 0x00, 0x38, 0x38, 0x00, 0x38, 0x03, 0x83, 0x80,
  0x03, 0xC0, 0x70, 0x70, 0x00, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0xFF, 0xE0,
  0xE0, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x00, 0x38,
  0x3F, 0xF0, 0x00, 0x07, 0x07, 0xFF, 0x80, 0x00, 0x70, 0xF0, 0x1C, 0x00,
  0x0E, 0x0E, 0x01, 0xE0, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x00,
  0xF0, 0x1C, 0x38, 0x00, 0x07, 0xCF, 0xC7, 0x00, 0x00, 0x3F, 0xF8, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x70, 0x0F, 0x00, 0x1C,
  0x70, 0x07, 0x80, 0x3C, 0xF0, 0x03, 0x80, 0x38, 0xE0, 0x03, 0xC0, 0x78,
  0xE0, 0x01, 0xE0, 0x70, 0xE0, 0x00, 0xF0, 0xF0, 0xE0, 0x00, 0x70, 0xE0,
  0xE0, 0x00, 0x79, 0xC0, 0xE0, 0x00, 0x3D, 0xC0, 0xE0, 0x00, 0x1F, 0x80,
  0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0x70, 0x00, 0x3D, 0xE0,
  0x70, 0x00, 0x78, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x3C, 0x01, 0xF0, 0x38,
  0x3F, 0x0F, 0xE0, 0x1C, 0x1F, 0xFF, 0x80, 0x1E, 0x07, 0xFF, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x77, 0x70, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xDF, 0x80, 0x38, 0x03, 0xEF, 0xF8, 0x1C, 0x0F, 0xFB,
  0xFF, 0x0C, 0x3F, 0xF0, 0x3F, 0xE6, 0x3F, 0xE0, 0x03, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xB8, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x83, 0x80, 0x01, 0xF0,
  0x38, 0x00, 0x7C, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x70, 0x03, 0x80,
  0x04, 0x00, 0x38, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0x83, 0xC0, 0x07, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3B, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x1E, 0x1F, 0xFC, 0x07, 0x9F, 0xFF, 0xC1, 0xEF, 0x83, 0xF8,
  0x7F, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x71, 0xFF, 0x00, 0x0E, 0x7F, 0xFC, 0x00, 0xEF, 0xFF, 0xE0,
  0x1F, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x01,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x78,
  0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x8F, 0xB8, 0x03,
  0xFF, 0xF7, 0x00, 0x0F, 0xFC, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC1, 0xC0, 0x07, 0x81, 0xFE, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0xBF, 0x00, 0x3E, 0x03,
  0x7E, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0x80, 0x07,
  0xF0, 0x07, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x1F,
  0x80, 0x38, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xFC,
  0x01, 0xC0, 0x01, 0xF8, 0x03, 0x80, 0x03, 0xF0, 0x07, 0x00, 0x07, 0xE0,
  0x0E, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xFC, 0x01, 0xE0, 0x03, 0xF8, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x37, 0xE0, 0x03, 0xFB, 0xEF, 0xC0, 0x07,
  0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80,
  0x07, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x7C, 0x38, 0x01, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xF8, 0x38, 0x00,
  0x0F, 0x8E, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x03, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0xC1, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0xFE, 0x0E, 0x00,
  0x0F, 0x87, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x1C, 0x00, 0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x38,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x80, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1B, 0xFE, 0x00, 0x03, 0x7E, 0xC0, 0x00,
  0xEF, 0xDC, 0x00, 0x19, 0xFB, 0x80, 0x03, 0x3F, 0x30, 0x00, 0xE7, 0xE7,
  0x00, 0x19, 0xFC, 0xE0, 0x07, 0x3F, 0x8C, 0x00, 0xE7, 0xF1, 0xC0, 0x18,
  0xFE, 0x18, 0x07, 0x1F, 0xC3, 0x80, 0xE3, 0xF8, 0x70, 0x18, 0x7F, 0x06,
  0x07, 0x0F, 0xE0, 0xE0, 0xC1, 0xFC, 0x1C, 0x18, 0x3F, 0x81, 0x87, 0x07,
  0xF0, 0x38, 0xC0, 0xFE, 0x07, 0x38, 0x1F, 0xC0, 0x67, 0x03, 0xF8, 0x0E,
  0xC0, 0x7F, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xC0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xEC, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xE7,
  0x00, 0x07, 0xE7, 0x00, 0x07, 0xE3, 0x00, 0x07, 0xE3, 0x80, 0x07, 0xE3,
  0x80, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE0, 0xC0, 0x07, 0xE0,
  0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x30, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0,
  0x07, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x03, 0x87, 0xE0,
  0x03, 0x87, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xC7, 0xE0,
  0x00, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x77, 0xE0,
  0x00, 0x77, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x03, 0xC3,
  0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87, 0xC0,
  0x0F, 0x81, 0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x70, 0x00, 0x7F, 0x0E, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x01,
  0xE0, 0x78, 0x01, 0xF0, 0x1F, 0xC1, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x7F, 0x0E, 0x00, 0x01, 0xF1, 0xC0, 0x00,
  0x1E, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1C,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x7C, 0x0F,
  0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xEE, 0x00, 0x36, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x3B, 0x80, 0x1D, 0x80,
  0x1D, 0xC0, 0x0E, 0xC0, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x38, 0x03, 0x38,
  0x03, 0x9C, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xC6, 0x00, 0xC7, 0x00, 0x63,
  0x00, 0xE3, 0x80, 0x71, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x1C, 0x06, 0x1C, 0x07, 0x0E, 0x03,
  0x0E, 0x03, 0x87, 0x01, 0x83, 0x01, 0x83, 0x81, 0xC1, 0x81, 0xC1, 0xC0,
  0xE0, 0xC0, 0xE0, 0xE0, 0x70, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1C,
  0x18, 0x1C, 0x1C, 0x0E, 0x0C, 0x0E, 0x0E, 0x07, 0x06, 0x03, 0x07, 0x03,
  0x87, 0x01, 0x83, 0x01, 0xC3, 0x80, 0xC1, 0x80, 0xE1, 0x80, 0x61, 0xC0,
  0x70, 0xC0, 0x38, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0E, 0x30, 0x0E, 0x38,
  0x07, 0x18, 0x03, 0x1C, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xCE, 0x00, 0xC6,
  0x00, 0xE6, 0x00, 0x63, 0x00, 0x73, 0x00, 0x3B, 0x80, 0x39, 0x80, 0x1D,
  0xC0, 0x1C, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x03, 0x70, 0x03, 0xF0, 0x01,
  0xB8, 0x01, 0xF0, 0x00, 0xDC, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x7C, 0x00,
  0x36, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x3C,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x0F, 0x80,
  0x0F, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7C,
  0x00, 0x07, 0x3C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x1D, 0xC7, 0xF0, 0x3E, 0x70,
  0xFF, 0xFF, 0x1C, 0x0F, 0xFF, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x0E,
  0x1F, 0xFE, 0x07, 0x1F, 0xFF, 0x83, 0x9E, 0x03, 0xE1, 0xDC, 0x00, 0x78,
  0xFC, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x3B, 0x00, 0x07,
  0x9D, 0xC0, 0x07, 0x8E, 0x78, 0x1F, 0x87, 0x1F, 0xFF, 0x83, 0x83, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x3F, 0x83, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x0F,
  0xE0, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x07,
  0x03, 0xFF, 0x87, 0x0F, 0xFF, 0xE7, 0x1F, 0x00, 0xF7, 0x3E, 0x00, 0x37,
  0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x77,
  0x1F, 0x81, 0xE7, 0x0F, 0xFF, 0xC7, 0x03, 0xFF, 0x87, 0x00, 0x38, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x1F,
  0x03, 0xE0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x0F, 0xC0, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0x00, 0xE7, 0x3E,
  0x00, 0x37, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x3F, 0x3E, 0x00, 0x77, 0x1F, 0xC3, 0xE7, 0x07, 0xFF, 0xC7, 0x03,
  0xFF, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0x00, 0xE1,
  0xFF, 0xE0, 0xE3, 0xFF, 0xF0, 0xE7, 0x80, 0xF8, 0xEE, 0x00, 0x3C, 0xEC,
  0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x3C, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x1C,
  0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x78, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xE0, 0x0F, 0x0E, 0x7F,
  0x83, 0xFC, 0xEF, 0xFC, 0x7F, 0xEE, 0xC3, 0xEC, 0x1E, 0xF8, 0x1E, 0x80,
  0xFF, 0x00, 0xE8, 0x07, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0,
  0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70,
  0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E,
  0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07,
  0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07,
  0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00,
  0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00,
  0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0,
  0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70,
  0x07, 0x00, 0x3F, 0x00, 0xE1, 0xFF, 0xE0, 0xE3, 0xFF, 0xF0, 0xE7, 0x80,
  0xF8, 0xEE, 0x00, 0x3C, 0xEC, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xF0,
  0x1F, 0x03, 0xE0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x0F, 0xE0, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x70, 0xFF, 0xF0, 0x38, 0xFF, 0xFC, 0x1C, 0xF0, 0x1F, 0x0E, 0xE0, 0x03,
  0xC7, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x39, 0xD8, 0x00,
  0x3C, 0xEE, 0x00, 0x3C, 0x73, 0xC0, 0xFC, 0x38, 0xFF, 0xFC, 0x1C, 0x1F,
  0xF8, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0x0F, 0xFF, 0xE7,
  0x1F, 0x00, 0xF7, 0x3C, 0x00, 0x37, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x77, 0x1F, 0x81, 0xE7, 0x0F, 0xFF, 0xC7,
  0x03, 0xFF, 0x87, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x70, 0xFF, 0xF0, 0x38, 0xFF, 0xFE,
  0x1C, 0xF0, 0x1F, 0x8E, 0xE0, 0x03, 0xE7, 0x60, 0x00, 0xF3, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x0E, 0x3E, 0x00, 0x07, 0x87, 0xF0, 0x0F, 0xC0, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F,
  0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0x70, 0x03, 0xC0, 0x07, 0x70, 0x03, 0xE0, 0x07, 0x70, 0x03,
  0x60, 0x0E, 0x70, 0x03, 0x60, 0x0E, 0x70, 0x07, 0x60, 0x0E, 0x38, 0x06,
  0x60, 0x0E, 0x38, 0x06, 0x70, 0x0E, 0x38, 0x06, 0x70, 0x0E, 0x38, 0x06,
  0x30, 0x1C, 0x38, 0x0E, 0x30, 0x1C, 0x38, 0x0E, 0x30, 0x1C, 0x1C, 0x0C,
  0x38, 0x1C, 0x1C, 0x0C, 0x38, 0x1C, 0x1C, 0x0C, 0x18, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x1C, 0x1C, 0x18, 0x38, 0x1C, 0x18, 0x1C, 0x38, 0x0E, 0x18,
  0x1C, 0x38, 0x0E, 0x18, 0x1C, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x0E, 0x38,
  0x0C, 0x70, 0x0E, 0x38, 0x0C, 0x70, 0x0E, 0x30, 0x0E, 0x70, 0x07, 0x30,
  0x0E, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x06, 0x60, 0x07, 0x70,
  0x06, 0xE0, 0x07, 0x60, 0x07, 0xE0, 0x07, 0x60, 0x07, 0xE0, 0x03, 0x60,
  0x07, 0xE0, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x73, 0xFF,
  0x00, 0x07, 0x7C, 0x7C, 0x00, 0x77, 0x03, 0xC0, 0x07, 0x70, 0x0E, 0x00,
  0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x3C, 0x0E, 0xE0,
  0x01, 0xF3, 0xEE, 0x00, 0x0F, 0xFC, 0xE0, 0x00, 0x3F, 0x80,
};

const GFXglyph JetBrainsMono_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 7, 47, 38, 16, -47 },
  { 43, 17, 19, 38, 11, -47 },
  { 84, 34, 47, 38, 2, -47 },
  { 284, 28, 65, 38, 5, -56 },
  { 512, 36, 47, 38, 1, -47 },
  { 724, 32, 48, 38, 4, -47 },
  { 916, 4, 19, 38, 17, -47 },
  { 926, 18, 62, 38, 13, -54 },
  { 1066, 18, 62, 38, 7, -54 },
  { 1206, 33, 32, 38, 3, -39 },
  { 1338, 29, 30, 38, 5, -36 },
  { 1447, 11, 20, 38, 12, -10 },
  { 1475, 20, 3, 38, 9, -23 },
  { 1483, 9, 10, 38, 15, -9 },
  { 1495, 26, 60, 38, 6, -53 },
  { 1690, 26, 48, 38, 6, -47 },
  { 1846, 28, 47, 38, 6, -47 },
  { 2011, 29, 47, 38, 5, -47 },
  { 2182, 25, 48, 38, 6, -47 },
  { 2332, 25, 47, 38, 6, -47 },
  { 2479, 26, 48, 38, 6, -47 },
  { 2635, 28, 48, 38, 5, -47 },
  { 2803, 29, 47, 38, 5, -47 },
  { 2974, 27, 48, 38, 6, -47 },
  { 3136, 28, 47, 38, 5, -47 },
  { 3301, 9, 37, 38, 15, -36 },
  { 3343, 12, 46, 38, 12, -36 },
  { 3412, 27, 32, 38, 6, -37 },
  { 3520, 26, 18, 38, 6, -30 },
  { 3579, 27, 32, 38, 6, -37 },
  { 3687, 21, 47, 38, 11, -47 },
  { 3811, 31, 58, 38, 4, -47 },
  { 4036, 30, 47, 38, 4, -47 },
  { 4213, 26, 47, 38, 7, -47 },
  { 4366, 26, 48, 38, 7, -47 },
  { 4522, 25, 47, 38, 7, -47 },
  { 4669, 25, 47, 38, 8, -47 },
  { 4816, 27, 47, 38, 7, -47 },
  { 4975, 26, 48, 38, 7, -47 },
  { 5131, 24, 47, 38, 7, -47 },
  { 5272, 23, 47, 38, 8, -47 },
  { 5408, 27, 48, 38, 4, -47 },
  { 5570, 28, 47, 38, 7, -47 },
  { 5735, 26, 47, 38, 8, -47 },
  { 5888, 27, 47, 38, 6, -47 },
  { 6047, 24, 47, 38, 7, -47 },
  { 6188, 25, 48, 38, 7, -47 },
  { 6338, 27, 47, 38, 7, -47 },
  { 6497, 26, 59, 38, 7, -47 },
  { 6689, 27, 47, 38, 7, -47 },
  { 6848, 28, 48, 38, 5, -47 },
  { 7016, 31, 47, 38, 4, -47 },
  { 7199, 24, 48, 38, 7, -47 },
  { 7343, 30, 47, 38, 4, -47 },
  { 7520, 33, 47, 38, 3, -47 },
  { 7714, 32, 47, 38, 3, -47 },
  { 7902, 32, 47, 38, 3, -47 },
  { 8090, 27, 47, 38, 6, -47 },
  { 8249, 14, 60, 38, 14, -53 },
  { 8354, 26, 60, 38, 6, -53 },
  { 8549, 14, 60, 38, 10, -53 },
  { 8654, 26, 25, 38, 6, -47 },
  { 8736, 31, 2, 38, 4, 2 },
  { 8744, 11, 9, 38, 13, -50 },
  { 8757, 26, 37, 38, 5, -36 },
  { 8878, 25, 48, 38, 7, -47 },
  { 9028, 25, 37, 38, 7, -36 },
  { 9144, 24, 48, 38, 7, -47 },
  { 9288, 25, 37, 38, 7, -36 },
  { 9404, 29, 47, 38, 4, -47 },
  { 9575, 24, 48, 38, 7, -36 },
  { 9719, 24, 47, 38, 7, -47 },
  { 9860, 28, 49, 38, 6, -49 },
  { 10032, 23, 61, 38, 6, -49 },
  { 10208, 27, 47, 38, 7, -47 },
  { 10367, 32, 47, 38, 3, -47 },
  { 10555, 28, 36, 38, 5, -36 },
  { 10681, 24, 36, 38, 7, -36 },
  { 10789, 25, 37, 38, 7, -36 },
  { 10905, 25, 48, 38, 7, -36 },
  { 11055, 24, 48, 38, 7, -36 },
  { 11199, 25, 36, 38, 8, -36 },
  { 11312, 26, 37, 38, 6, -36 },
  { 11433, 28, 45, 38, 4, -45 },
  { 11591, 24, 36, 38, 7, -35 },
  { 11699, 29, 35, 38, 5, -35 },
  { 11826, 32, 35, 38, 3, -35 },
  { 11966, 29, 35, 38, 5, -35 },
  { 12093, 29, 47, 38, 5, -35 },
  { 12264, 25, 35, 38, 7, -35 },
  { 12374, 26, 60, 38, 6, -53 },
  { 12569, 3, 60, 38, 18, -53 },
  { 12592, 26, 60, 38, 6, -53 },
  { 12787, 28, 11, 38, 5, -28 },
};

const GFXfont JetBrainsMono_Thin64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_THIN64PT7B_H_
