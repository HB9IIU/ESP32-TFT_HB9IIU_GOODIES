#ifndef _JETBRAINSMONO_THIN61PT7B_H_
#define _JETBRAINSMONO_THIN61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x38, 0xF8, 0x1E, 0x0E,
  0x0F, 0x07, 0x03, 0x81, 0xC3, 0x80, 0xE0, 0x78, 0xE0, 0x38, 0x0E, 0x38,
  0x0E, 0x03, 0xDE, 0x03, 0x80, 0x77, 0x00, 0xE0, 0x1D, 0xC0, 0x38, 0x07,
  0x78, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x1F,
  0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0E, 0xFC, 0x00, 0x03, 0x8F, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x7E,
  0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xF0, 0x0E, 0x01, 0xDC, 0x03, 0x80,
  0x77, 0x00, 0xE0, 0x3D, 0xE0, 0x38, 0x0E, 0x3C, 0x0E, 0x07, 0x87, 0xC3,
  0x87, 0xC0, 0xFC, 0xE7, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC3, 0xFE, 0x00,
  0x00, 0x71, 0xFF, 0xE0, 0x00, 0x38, 0xF0, 0x38, 0x00, 0x1C, 0x38, 0x07,
  0x00, 0x07, 0x1C, 0x01, 0xC0, 0x03, 0x87, 0x00, 0x30, 0x01, 0xC1, 0xC0,
  0x0C, 0x00, 0x60, 0x70, 0x03, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x1C, 0x07,
  0x00, 0x30, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x03, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x38, 0x01, 0xC0, 0x1C, 0x1C,
  0x00, 0x38, 0x07, 0x0E, 0x00, 0x0F, 0x07, 0x83, 0x00, 0x01, 0xFF, 0xC1,
  0xC0, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x00, 0x70, 0x7F, 0xE0,
  0x00, 0x18, 0x3E, 0xFC, 0x00, 0x0E, 0x1C, 0x07, 0x80, 0x07, 0x07, 0x00,
  0xE0, 0x03, 0x83, 0x80, 0x18, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x0C, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0xE0, 0x07, 0x03, 0x80, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x80, 0x18, 0x38, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0x18, 0x03, 0x86,
  0x00, 0x07, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xF1, 0xC0, 0x00, 0x1F, 0xF8,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x70,
  0x1E, 0x00, 0x3B, 0xC0, 0x3C, 0x01, 0xCE, 0x00, 0x70, 0x0F, 0x38, 0x00,
  0xE0, 0x38, 0xE0, 0x03, 0xC1, 0xC3, 0x80, 0x07, 0x87, 0x0E, 0x00, 0x0E,
  0x38, 0x38, 0x00, 0x1C, 0xE0, 0xE0, 0x00, 0x7F, 0x03, 0x80, 0x00, 0xFC,
  0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0x03,
  0x80, 0x00, 0xFE, 0x0E, 0x00, 0x03, 0xB8, 0x1C, 0x00, 0x1C, 0x70, 0x78,
  0x00, 0xF0, 0xE1, 0xF0, 0x0F, 0x83, 0xC3, 0xF0, 0xFC, 0x07, 0x07, 0xFF,
  0xC0, 0x0E, 0x07, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x70, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x80, 0x07,
  0x00, 0x0B, 0xE0, 0x0E, 0x00, 0xF7, 0xF0, 0x1C, 0x0F, 0xFF, 0xFC, 0x38,
  0x7F, 0xC3, 0xFE, 0x63, 0xFE, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x83, 0xE0, 0x03, 0xC3,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0x00, 0x7E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x04, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x07, 0xFD, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xE7, 0x00,
  0x01, 0xF1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x07,
  0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x1F,
  0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x78, 0x00,
  0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0xC0,
  0x38, 0xFF, 0xF8, 0x1C, 0xFD, 0xFE, 0x0E, 0xE0, 0x0F, 0x87, 0xE0, 0x03,
  0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x39, 0xFF, 0xC0,
  0x1D, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0xF8, 0x1E, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x07,
  0x83, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x07, 0xC0,
  0x07, 0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x8F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x0F, 0xF1, 0xF7,
  0x00, 0xFF, 0xFB, 0x80, 0x1F, 0xF9, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x8F, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x02, 0x00, 0x1F, 0x87,
  0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0x07, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x3F, 0xFD, 0xF8, 0x03, 0xF0,
  0xFF, 0xC0, 0x1E, 0x01, 0xFE, 0x01, 0xE0, 0x07, 0xF0, 0x0E, 0x00, 0x1F,
  0x80, 0x70, 0x00, 0xFC, 0x03, 0x80, 0x07, 0xE0, 0x1C, 0x00, 0x3F, 0x00,
  0xE0, 0x01, 0xF8, 0x07, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x7E, 0x01, 0xC0,
  0x03, 0xF0, 0x0E, 0x00, 0x1F, 0x80, 0x70, 0x00, 0xFC, 0x03, 0x80, 0x07,
  0xE0, 0x1C, 0x00, 0x3F, 0x00, 0xE0, 0x01, 0xF8, 0x07, 0x00, 0x0F, 0xC0,
  0x38, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x1F,
  0x0F, 0xFC, 0x00, 0xFF, 0xF7, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xE0, 0x07, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xE0, 0x0F, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x01, 0xE1,
  0xE0, 0x00, 0x71, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xF0, 0x3E, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x7F, 0x0E, 0x00, 0x1F, 0x1C, 0x00,
  0x1F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0x70, 0x00, 0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x07, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00,
  0x71, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFB, 0x00, 0x03, 0xFD, 0xC0, 0x01, 0xBE,
  0x60, 0x00, 0xDF, 0x30, 0x00, 0xEF, 0x9C, 0x00, 0x67, 0xC6, 0x00, 0x33,
  0xE3, 0x00, 0x39, 0xF9, 0xC0, 0x18, 0xFC, 0x60, 0x1C, 0x7E, 0x38, 0x0E,
  0x3F, 0x1C, 0x06, 0x1F, 0x86, 0x07, 0x0F, 0xC3, 0x83, 0x07, 0xE0, 0xC1,
  0x83, 0xF0, 0x61, 0xC1, 0xF8, 0x38, 0xC0, 0xFC, 0x0C, 0x60, 0x7E, 0x06,
  0x70, 0x3F, 0x03, 0xB0, 0x1F, 0x80, 0xD8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3C, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFB, 0x00,
  0x03, 0xF7, 0x00, 0x07, 0xEE, 0x00, 0x0F, 0xCC, 0x00, 0x1F, 0x9C, 0x00,
  0x3F, 0x18, 0x00, 0x7E, 0x38, 0x00, 0xFC, 0x70, 0x01, 0xF8, 0x60, 0x03,
  0xF0, 0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0xC1, 0xC0, 0x1F, 0x83, 0x80, 0x3F,
  0x03, 0x00, 0x7E, 0x07, 0x00, 0xFC, 0x0E, 0x01, 0xF8, 0x0E, 0x03, 0xF0,
  0x1C, 0x07, 0xE0, 0x18, 0x0F, 0xC0, 0x38, 0x1F, 0x80, 0x70, 0x3F, 0x00,
  0x70, 0x7E, 0x00, 0xE0, 0xFC, 0x00, 0xC1, 0xF8, 0x01, 0xC3, 0xF0, 0x03,
  0x87, 0xE0, 0x03, 0x8F, 0xC0, 0x07, 0x1F, 0x80, 0x06, 0x3F, 0x00, 0x0E,
  0x7E, 0x00, 0x1C, 0xFC, 0x00, 0x1D, 0xF8, 0x00, 0x3B, 0xF0, 0x00, 0x37,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x0F, 0x81, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0xF0, 0xE0, 0x00,
  0x3E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x0F,
  0x01, 0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x3E, 0x03,
  0xF0, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xC7, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x03,
  0xE7, 0x00, 0x07, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x78, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x38, 0x00,
  0x1E, 0x78, 0x00, 0x38, 0x78, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x60, 0x03, 0xE0, 0x07, 0x70, 0x03, 0xE0, 0x07, 0x70, 0x03, 0x60,
  0x07, 0x70, 0x03, 0x60, 0x07, 0x70, 0x03, 0x60, 0x07, 0x70, 0x03, 0x60,
  0x06, 0x70, 0x03, 0x60, 0x0E, 0x70, 0x07, 0x70, 0x0E, 0x30, 0x07, 0x70,
  0x0E, 0x38, 0x06, 0x70, 0x0E, 0x38, 0x06, 0x30, 0x0E, 0x38, 0x06, 0x30,
  0x0E, 0x38, 0x06, 0x30, 0x0E, 0x38, 0x06, 0x30, 0x0C, 0x38, 0x0E, 0x38,
  0x0C, 0x38, 0x0E, 0x38, 0x1C, 0x18, 0x0C, 0x38, 0x1C, 0x1C, 0x0C, 0x18,
  0x1C, 0x1C, 0x0C, 0x18, 0x1C, 0x1C, 0x0C, 0x18, 0x1C, 0x1C, 0x0C, 0x18,
  0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x1C, 0x18, 0x1C, 0x18, 0x1C,
  0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x18, 0x0C, 0x38, 0x0E, 0x18, 0x0C,
  0x38, 0x0E, 0x18, 0x0C, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x0E, 0x30, 0x0E,
  0x30, 0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x70, 0x07, 0x30, 0x06, 0x70, 0x07, 0x30, 0x06, 0x70, 0x07, 0x70, 0x06,
  0x70, 0x07, 0x60, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07,
  0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0x60, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0x9E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0x71, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xF0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0xFC, 0xF8, 0x00, 0xEE, 0x3F, 0x01, 0xE7, 0x0F, 0xFF, 0xE3, 0x81, 0xFF,
  0xC1, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x07, 0xF8, 0x0E, 0x3F, 0xFC, 0x1C, 0xFD, 0xFC, 0x3B, 0x80, 0x3C,
  0x7E, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x0E,
  0xF8, 0x00, 0x39, 0xD8, 0x00, 0xF3, 0xBC, 0x07, 0xC7, 0x3F, 0xFF, 0x0E,
  0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00,
  0x71, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x07, 0x07, 0xFF, 0xC7, 0x0F,
  0xFF, 0xE7, 0x1F, 0x00, 0x77, 0x3C, 0x00, 0x37, 0x38, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x1E,
  0x00, 0x77, 0x0F, 0x81, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x87, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x07, 0x78,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F,
  0x80, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0x07, 0x07, 0xFF, 0xC7, 0x0F, 0xFF, 0xE7, 0x1F, 0x00,
  0x77, 0x3C, 0x00, 0x37, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x3C, 0x00, 0x37, 0x1E, 0x00,
  0x77, 0x0F, 0x81, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x10,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x07, 0xF8, 0x0E, 0x3F, 0xFC, 0x1C, 0xFD, 0xFC, 0x3B, 0x80, 0x3C, 0x7E,
  0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x1E, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F,
  0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x78, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0xE7, 0xE0, 0x7E, 0x1D, 0xFF,
  0x1F, 0xF3, 0xFB, 0xE7, 0xBE, 0x7C, 0x1E, 0xC1, 0xEF, 0x01, 0xD0, 0x1D,
  0xC0, 0x3C, 0x03, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E,
  0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E,
  0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70,
  0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0,
  0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80,
  0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01,
  0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01,
  0xC0, 0x1C, 0xE0, 0xFF, 0x01, 0xC7, 0xFF, 0x83, 0x9F, 0xBF, 0x87, 0x70,
  0x07, 0x8F, 0xC0, 0x07, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1E, 0x00,
  0x3C, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xE0, 0xFF, 0x01, 0xC7, 0xFF, 0x83, 0x9F, 0xBF, 0xC7, 0x70, 0x07,
  0x8F, 0xC0, 0x07, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x01,
  0xDF, 0x00, 0x07, 0x3B, 0x00, 0x1E, 0x77, 0x80, 0xF8, 0xE7, 0xFF, 0xE1,
  0xC3, 0xFF, 0x03, 0x80, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x07, 0x07, 0xFF, 0xC7, 0x0F, 0xFF, 0xE7, 0x1F, 0x00, 0x77, 0x3C,
  0x00, 0x37, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x1E, 0x00, 0x77, 0x0F, 0x81, 0xE7, 0x07,
  0xFF, 0xC7, 0x03, 0xFF, 0x87, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0x00, 0xE3, 0xFF, 0xC0, 0xE7, 0xEF, 0xF0, 0xEE,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xE3,
  0xC0, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0x7E, 0x00, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCF,
  0x00, 0x0F, 0x0F, 0x00, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1B, 0x80, 0x1E, 0x00, 0x73,
  0x00, 0x3C, 0x00, 0xE7, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xD8, 0x03, 0x9C,
  0x01, 0xB0, 0x07, 0x38, 0x07, 0x60, 0x0C, 0x70, 0x0C, 0xC0, 0x38, 0x60,
  0x19, 0xC0, 0x70, 0xE0, 0x31, 0x80, 0xE1, 0xC0, 0x63, 0x01, 0xC3, 0x81,
  0xC6, 0x03, 0x07, 0x03, 0x8C, 0x06, 0x0E, 0x06, 0x1C, 0x1C, 0x0C, 0x0C,
  0x18, 0x38, 0x1C, 0x18, 0x30, 0x70, 0x38, 0x70, 0x60, 0xE0, 0x70, 0xE0,
  0xC1, 0x80, 0xE1, 0x81, 0xC3, 0x01, 0xC3, 0x03, 0x8E, 0x01, 0x86, 0x03,
  0x1C, 0x03, 0x8C, 0x06, 0x38, 0x07, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x1C,
  0xC0, 0x1C, 0xC0, 0x3B, 0x80, 0x39, 0x80, 0x77, 0x00, 0x33, 0x00, 0x6E,
  0x00, 0x7E, 0x00, 0xDC, 0x00, 0xFC, 0x01, 0xB8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x80, 0x70,
  0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xCF, 0xF8, 0x00, 0x37, 0xDF, 0x80, 0x0D, 0xC0, 0xE0, 0x03,
  0xE0, 0x1C, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xF0, 0x1F, 0x80, 0x1E,
  0x07, 0xE0, 0x03, 0xF7, 0xB8, 0x00, 0x7F, 0xEE, 0x00, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 7, 45, 37, 15, -45 },
  { 41, 16, 19, 37, 10, -45 },
  { 79, 32, 45, 37, 2, -45 },
  { 259, 26, 62, 37, 5, -53 },
  { 461, 34, 45, 37, 1, -45 },
  { 653, 30, 46, 37, 4, -45 },
  { 826, 4, 19, 37, 16, -45 },
  { 836, 18, 58, 37, 12, -51 },
  { 967, 17, 58, 37, 7, -51 },
  { 1091, 31, 31, 37, 3, -37 },
  { 1212, 27, 28, 37, 5, -34 },
  { 1307, 10, 19, 37, 12, -9 },
  { 1331, 19, 3, 37, 9, -22 },
  { 1339, 9, 9, 37, 14, -8 },
  { 1350, 25, 58, 37, 6, -51 },
  { 1532, 25, 46, 37, 6, -45 },
  { 1676, 26, 45, 37, 6, -45 },
  { 1823, 27, 45, 37, 5, -45 },
  { 1975, 25, 46, 37, 5, -45 },
  { 2119, 24, 44, 37, 6, -44 },
  { 2251, 25, 46, 37, 6, -45 },
  { 2395, 26, 46, 37, 5, -45 },
  { 2545, 27, 45, 37, 5, -45 },
  { 2697, 26, 46, 37, 5, -45 },
  { 2847, 26, 45, 37, 5, -45 },
  { 2994, 9, 35, 37, 14, -34 },
  { 3034, 11, 44, 37, 12, -34 },
  { 3095, 26, 30, 37, 5, -35 },
  { 3193, 25, 16, 37, 6, -28 },
  { 3243, 26, 30, 37, 5, -35 },
  { 3341, 21, 45, 37, 10, -45 },
  { 3460, 29, 56, 37, 4, -45 },
  { 3663, 28, 45, 37, 4, -45 },
  { 3821, 24, 45, 37, 7, -45 },
  { 3956, 25, 46, 37, 6, -45 },
  { 4100, 23, 45, 37, 7, -45 },
  { 4230, 24, 45, 37, 7, -45 },
  { 4365, 25, 45, 37, 7, -45 },
  { 4506, 25, 46, 37, 6, -45 },
  { 4650, 23, 45, 37, 7, -45 },
  { 4780, 22, 45, 37, 7, -45 },
  { 4904, 25, 46, 37, 4, -45 },
  { 5048, 26, 45, 37, 7, -45 },
  { 5195, 25, 45, 37, 7, -45 },
  { 5336, 25, 45, 37, 6, -45 },
  { 5477, 23, 45, 37, 7, -45 },
  { 5607, 24, 46, 37, 6, -45 },
  { 5745, 26, 45, 37, 7, -45 },
  { 5892, 25, 56, 37, 6, -45 },
  { 6067, 25, 45, 37, 7, -45 },
  { 6208, 26, 46, 37, 5, -45 },
  { 6358, 29, 45, 37, 4, -45 },
  { 6522, 23, 46, 37, 7, -45 },
  { 6655, 28, 45, 37, 4, -45 },
  { 6813, 32, 45, 37, 2, -45 },
  { 6993, 30, 45, 37, 3, -45 },
  { 7162, 31, 45, 37, 3, -45 },
  { 7337, 25, 45, 37, 6, -45 },
  { 7478, 14, 58, 37, 13, -51 },
  { 7580, 25, 58, 37, 6, -51 },
  { 7762, 14, 58, 37, 9, -51 },
  { 7864, 25, 24, 37, 6, -45 },
  { 7939, 29, 2, 37, 4, 2 },
  { 7947, 10, 9, 37, 12, -48 },
  { 7959, 25, 35, 37, 5, -34 },
  { 8069, 23, 46, 37, 7, -45 },
  { 8202, 25, 35, 37, 6, -34 },
  { 8312, 24, 46, 37, 6, -45 },
  { 8450, 24, 35, 37, 6, -34 },
  { 8555, 28, 45, 37, 4, -45 },
  { 8713, 24, 45, 37, 6, -34 },
  { 8848, 23, 45, 37, 7, -45 },
  { 8978, 27, 47, 37, 6, -47 },
  { 9137, 22, 58, 37, 6, -47 },
  { 9297, 25, 45, 37, 7, -45 },
  { 9438, 30, 45, 37, 3, -45 },
  { 9607, 27, 34, 37, 5, -34 },
  { 9722, 23, 34, 37, 7, -34 },
  { 9820, 24, 35, 37, 6, -34 },
  { 9925, 23, 45, 37, 7, -34 },
  { 10055, 24, 45, 37, 6, -34 },
  { 10190, 24, 34, 37, 8, -34 },
  { 10292, 25, 35, 37, 6, -34 },
  { 10402, 27, 43, 37, 4, -43 },
  { 10548, 23, 35, 37, 7, -34 },
  { 10649, 27, 34, 37, 5, -34 },
  { 10764, 31, 34, 37, 3, -34 },
  { 10896, 27, 34, 37, 5, -34 },
  { 11011, 27, 45, 37, 5, -34 },
  { 11163, 24, 34, 37, 6, -34 },
  { 11265, 25, 58, 37, 6, -51 },
  { 11447, 3, 58, 37, 17, -51 },
  { 11469, 25, 58, 37, 6, -51 },
  { 11651, 26, 11, 37, 5, -27 },
};

const GFXfont JetBrainsMono_Thin61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_THIN61PT7B_H_
