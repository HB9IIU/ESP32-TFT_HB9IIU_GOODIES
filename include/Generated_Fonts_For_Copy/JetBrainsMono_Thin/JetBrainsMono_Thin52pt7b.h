#ifndef _JETBRAINSMONO_THIN52PT7B_H_
#define _JETBRAINSMONO_THIN52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0x82, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xEF, 0xFF, 0xFD, 0xE0, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x1F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x70, 0x1F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x33, 0xE0,
  0x70, 0x61, 0xE1, 0xC0, 0xC1, 0xC3, 0x81, 0x81, 0xC6, 0x03, 0x03, 0x8C,
  0x06, 0x07, 0x38, 0x0C, 0x0E, 0x70, 0x18, 0x0C, 0x60, 0x30, 0x00, 0xE0,
  0x60, 0x01, 0xC0, 0xC0, 0x03, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x03, 0xC6,
  0x00, 0x03, 0xEC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xDF, 0x00, 0x01, 0x8F, 0x00, 0x03, 0x0F, 0x00, 0x06, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x3F,
  0x00, 0xC0, 0x7E, 0x01, 0x80, 0xEC, 0x03, 0x01, 0xDC, 0x06, 0x03, 0x38,
  0x0C, 0x0E, 0x38, 0x18, 0x1C, 0x78, 0x30, 0x70, 0x7C, 0x63, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x38, 0xFF, 0x80, 0x01, 0x8E, 0x0E, 0x00, 0x18,
  0xE0, 0x30, 0x01, 0xC6, 0x01, 0xC0, 0x0C, 0x30, 0x06, 0x00, 0xC1, 0x80,
  0x30, 0x0E, 0x0C, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x06, 0x03, 0x00, 0x60,
  0x70, 0x18, 0x03, 0x07, 0x00, 0xC0, 0x38, 0x30, 0x06, 0x01, 0xC3, 0x00,
  0x38, 0x0C, 0x38, 0x00, 0xE0, 0xE1, 0x80, 0x03, 0xFE, 0x18, 0x00, 0x0F,
  0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x0F, 0xC0, 0x00, 0x61, 0xFF,
  0x80, 0x07, 0x1E, 0x1C, 0x00, 0x30, 0xC0, 0x70, 0x03, 0x06, 0x01, 0x80,
  0x38, 0x70, 0x0C, 0x03, 0x83, 0x80, 0x60, 0x18, 0x1C, 0x03, 0x01, 0x80,
  0xE0, 0x18, 0x1C, 0x07, 0x00, 0xC0, 0xC0, 0x38, 0x06, 0x0C, 0x01, 0xC0,
  0x30, 0xE0, 0x06, 0x01, 0x86, 0x00, 0x30, 0x1C, 0x60, 0x01, 0xC1, 0xC6,
  0x00, 0x07, 0xFE, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE1, 0xC0, 0x06,
  0x70, 0x38, 0x03, 0x98, 0x07, 0x00, 0xCE, 0x00, 0xE0, 0x73, 0x80, 0x38,
  0x18, 0xE0, 0x07, 0x0E, 0x38, 0x00, 0xE7, 0x0E, 0x00, 0x1D, 0xC3, 0x80,
  0x07, 0xE0, 0xE0, 0x00, 0xF8, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x03, 0xE0, 0x60, 0x01, 0xDC, 0x1C, 0x00, 0xF3, 0x87, 0x80, 0x78,
  0x70, 0xF0, 0x3C, 0x1C, 0x1F, 0xFE, 0x03, 0x83, 0xFE, 0x00, 0x70, 0x08,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x70,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x30,
  0x80, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x40, 0x0E, 0x00, 0x4F, 0x01, 0xC0, 0x3F, 0xF8, 0x38, 0x3F, 0x9F,
  0xE3, 0x3F, 0xC0, 0x7F, 0x4F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xC0,
  0x01, 0x80, 0x08, 0x00, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xF0,
  0x78, 0x03, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x3B, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x70,
  0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x73, 0xC0, 0x03, 0x8F, 0x00, 0x78,
  0x3E, 0x0F, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0xF1,
  0xC0, 0x03, 0xC3, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x1C,
  0x01, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0,
  0x3C, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x31, 0xC0, 0x03, 0x38,
  0x00, 0x33, 0x80, 0x03, 0x70, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x7F, 0x01, 0xCF, 0xFE, 0x0E,
  0xF9, 0xF8, 0x7E, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1C, 0xE0, 0x00,
  0x67, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x8E, 0x00, 0x38, 0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x1F,
  0x80, 0x0D, 0xFF, 0xC0, 0x37, 0xCF, 0xC0, 0xF8, 0x03, 0xC1, 0xE0, 0x03,
  0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x71,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80,
  0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xE0, 0x01,
  0x81, 0xC0, 0x1E, 0x03, 0x80, 0xF0, 0x07, 0x8F, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x03, 0x80,
  0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x80, 0x0F, 0x0F, 0x80,
  0x78, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03,
  0x87, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x78, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0xC0, 0xFC, 0x7B, 0x00, 0xFF,
  0xEE, 0x00, 0x7F, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xC2, 0x00, 0x1F, 0x0F, 0xE3, 0xF8, 0xFF, 0x3F, 0x8F, 0xE1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x03,
  0x81, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x8F, 0x80, 0x3F, 0xF7, 0xC0,
  0x3C, 0x1B, 0xE0, 0x3C, 0x07, 0xF0, 0x1C, 0x01, 0xF8, 0x0E, 0x00, 0xFC,
  0x06, 0x00, 0x3E, 0x03, 0x00, 0x1F, 0x01, 0x80, 0x0F, 0x80, 0xC0, 0x07,
  0xC0, 0x60, 0x03, 0xE0, 0x30, 0x01, 0xF0, 0x18, 0x00, 0xF8, 0x0C, 0x00,
  0x7C, 0x06, 0x00, 0x3E, 0x03, 0x00, 0x1F, 0x01, 0xC0, 0x1F, 0x80, 0xE0,
  0x0F, 0xC0, 0x38, 0x0F, 0xE0, 0x1F, 0x1D, 0xF0, 0x07, 0xFC, 0xF8, 0x01,
  0xFC, 0x6C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC7, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x06, 0x00, 0xC0,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00, 0x18, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x30, 0x0F, 0xE1, 0x80, 0x07, 0x8C, 0x00, 0x1E, 0x60, 0x00,
  0x73, 0x00, 0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0,
  0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x98, 0x00, 0x38, 0xC0, 0x03, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0x0C, 0x00, 0x3C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xD8, 0x00, 0x0E,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x76,
  0x00, 0x07, 0x30, 0x00, 0x71, 0x80, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x3E, 0x0F, 0x00, 0x38,
  0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x7F, 0x0C, 0x00, 0x78, 0xC0,
  0x03, 0xCC, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x6C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC,
  0x00, 0x3C, 0xC0, 0x07, 0x8C, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xE0, 0x3E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x6E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00,
  0x73, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x7C, 0x07, 0x81, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xEC, 0x00,
  0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x30,
  0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x30, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x30, 0x0E, 0x00,
  0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0,
  0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3,
  0x00, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xB0, 0x01, 0xBD, 0x80, 0x0D, 0xE6, 0x00, 0x6F, 0x30, 0x06,
  0x79, 0x80, 0x33, 0xC6, 0x03, 0x9E, 0x30, 0x18, 0xF1, 0xC0, 0xC7, 0x86,
  0x0C, 0x3C, 0x30, 0x61, 0xE1, 0xC3, 0x0F, 0x06, 0x30, 0x78, 0x31, 0x83,
  0xC0, 0xCC, 0x1E, 0x06, 0xC0, 0xF0, 0x36, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3D, 0x80, 0x07, 0xB0, 0x00,
  0xF3, 0x00, 0x1E, 0x60, 0x03, 0xCE, 0x00, 0x78, 0xC0, 0x0F, 0x18, 0x01,
  0xE3, 0x80, 0x3C, 0x30, 0x07, 0x87, 0x00, 0xF0, 0x60, 0x1E, 0x0C, 0x03,
  0xC1, 0xC0, 0x78, 0x18, 0x0F, 0x03, 0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07,
  0x80, 0xE0, 0xF0, 0x0C, 0x1E, 0x01, 0xC3, 0xC0, 0x18, 0x78, 0x03, 0x0F,
  0x00, 0x71, 0xE0, 0x06, 0x3C, 0x00, 0xE7, 0x80, 0x0C, 0xF0, 0x01, 0x9E,
  0x00, 0x3B, 0xC0, 0x03, 0x78, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x80,
  0xF0, 0x78, 0x01, 0xC3, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xCC,
  0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xB0, 0x00, 0x1D,
  0x80, 0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x38, 0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0C, 0x00, 0xFC, 0x30, 0x00, 0x78, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x73, 0x00,
  0x03, 0xCC, 0x00, 0x7E, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x38, 0x00, 0x61, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x60, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00,
  0x0C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0xC0, 0x0E, 0x07, 0x80, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0C, 0x01, 0xFC, 0x30, 0x00, 0x78, 0xC0, 0x00, 0xF3, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03,
  0xB0, 0x00, 0x1C, 0xC0, 0x00, 0xF3, 0x00, 0x07, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x07,
  0x00, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0,
  0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00,
  0x3B, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3C, 0x07,
  0xC0, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x07,
  0x18, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8, 0x00, 0x06,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xF0, 0x00, 0xE0, 0xF8, 0x07, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x1C, 0x78, 0x01, 0xC3,
  0xC0, 0x78, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x38, 0x00,
  0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x18, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x0E, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x83,
  0x80, 0x01, 0x83, 0x80, 0x01, 0x83, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x80,
  0x3C, 0x03, 0xB0, 0x07, 0x80, 0x76, 0x01, 0xB0, 0x0E, 0xC0, 0x36, 0x01,
  0x98, 0x06, 0xC0, 0x33, 0x00, 0xD8, 0x06, 0x70, 0x19, 0x80, 0xCE, 0x03,
  0x30, 0x19, 0xC0, 0x66, 0x07, 0x38, 0x18, 0xC0, 0xE3, 0x03, 0x18, 0x1C,
  0x60, 0x63, 0x03, 0x0C, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x0C, 0x38, 0x30,
  0xC1, 0x87, 0x06, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0x61, 0xC1,
  0x86, 0x0C, 0x38, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x10, 0xC0, 0xC3, 0x03,
  0x18, 0x1C, 0x40, 0x63, 0x03, 0x98, 0x0C, 0x60, 0x73, 0x01, 0x8C, 0x0E,
  0x60, 0x31, 0x80, 0xCC, 0x06, 0x70, 0x19, 0x80, 0xCC, 0x03, 0x30, 0x0D,
  0x80, 0x64, 0x01, 0xB0, 0x0F, 0x80, 0x36, 0x01, 0xF0, 0x06, 0xC0, 0x3E,
  0x00, 0xD8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x8E,
  0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xE0,
  0x38, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x30, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xE7,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xE0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0xFC, 0x7E, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0x70, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0x80, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8,
  0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x03, 0x73, 0xE0, 0x1D, 0xC7, 0xFF,
  0xE7, 0x07, 0xFE, 0x1C, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0xC0, 0xC7, 0xFF, 0x0C, 0xE0,
  0xF8, 0xD8, 0x03, 0xCF, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0xD8, 0x01, 0xCD, 0xC0,
  0x78, 0xCF, 0xFF, 0x0C, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xE1, 0xF0, 0x38, 0x03, 0xC3, 0x80, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x06,
  0x38, 0x00, 0x71, 0xE0, 0x07, 0x07, 0x80, 0xF8, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x3F, 0xC3, 0x0F, 0xFE, 0x31, 0xF0, 0x7B, 0x3C, 0x01,
  0xB3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x07,
  0x70, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xF1, 0xE0, 0x3B, 0x0F, 0xFF,
  0x30, 0x7F, 0xC3, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xC1, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x07, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xFC, 0x30, 0xFF, 0xE3, 0x1F, 0x07, 0x33, 0xC0,
  0x1B, 0x38, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x03, 0x60,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00,
  0xF1, 0xC0, 0x1B, 0x1F, 0x8F, 0x30, 0x7F, 0xE3, 0x01, 0xF8, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x1F, 0xC0, 0xC7, 0xFF, 0x0C, 0xE0, 0xF8, 0xD8, 0x03, 0xCD, 0x00,
  0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x87,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xEC, 0x00, 0x07, 0xB0,
  0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x8C, 0x00, 0x1C, 0x30, 0x00,
  0xE0, 0xC0, 0x07, 0x03, 0x00, 0x3C, 0x0C, 0x00, 0xE0, 0x30, 0x07, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xC0,
  0x78, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x0E,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0x78, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0xC3,
  0x00, 0x07, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x7B, 0x00,
  0x00, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0xC7, 0xC1, 0xF1, 0x9F, 0xC7, 0xFB, 0x63, 0xD8, 0x76, 0x83, 0xA0,
  0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03,
  0xE0, 0x38, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x3E,
  0x03, 0x80, 0x7C, 0x07, 0x00, 0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03, 0xE0,
  0x38, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x3E, 0x03,
  0x80, 0x7C, 0x07, 0x00, 0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x38,
  0x07, 0xC0, 0x70, 0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x3E, 0x03, 0x80,
  0x60, 0xC1, 0xFC, 0x0C, 0x7F, 0xF0, 0xCE, 0x0F, 0x8D, 0x80, 0x3C, 0xD0,
  0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x70, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC1, 0xF0, 0x38, 0x03,
  0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D,
  0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0xC1, 0xFC, 0x0C,
  0x7F, 0xF0, 0xCE, 0x0F, 0x8D, 0x80, 0x3C, 0xF0, 0x01, 0xCE, 0x00, 0x0E,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xF0, 0x00, 0xED,
  0x80, 0x1C, 0xDC, 0x07, 0x8C, 0xFF, 0xF0, 0xC3, 0xFE, 0x0C, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x30, 0xFF,
  0xE3, 0x1F, 0x07, 0xB3, 0xC0, 0x1B, 0x38, 0x00, 0xF7, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xF3, 0x80,
  0x0F, 0x1E, 0x03, 0xB0, 0xFF, 0xF3, 0x07, 0xFC, 0x30, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC1, 0xFC, 0x0C, 0x7F, 0xF0,
  0xCE, 0x0F, 0x8D, 0x80, 0x3C, 0xF0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xFE, 0x07, 0xC0, 0xF8, 0x70, 0x01, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x70,
  0x00, 0x3B, 0x80, 0x03, 0x8F, 0x00, 0x3C, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x01, 0xC7,
  0x80, 0x3C, 0x3C, 0x07, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x67,
  0x00, 0x01, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x18,
  0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x80, 0xE0, 0x03, 0x01,
  0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x30,
  0x00, 0x38, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x80, 0x78,
  0x06, 0xE0, 0x16, 0x03, 0xB8, 0x0D, 0x80, 0xE6, 0x03, 0x60, 0x39, 0x80,
  0xD8, 0x0C, 0x60, 0x33, 0x03, 0x1C, 0x08, 0xC0, 0xC7, 0x06, 0x30, 0x71,
  0xC1, 0x8C, 0x1C, 0x30, 0x63, 0x07, 0x0C, 0x18, 0x61, 0x83, 0x06, 0x18,
  0x60, 0xE3, 0x06, 0x18, 0x38, 0xC1, 0x8E, 0x0E, 0x30, 0x63, 0x81, 0x8C,
  0x18, 0xE0, 0x63, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x07, 0x60, 0x33, 0x01,
  0xD8, 0x0D, 0xC0, 0x36, 0x03, 0x70, 0x0D, 0x80, 0xFC, 0x03, 0x60, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6E, 0x00,
  0x01, 0xCC, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x00,
  0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x18, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x18, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0E, 0x7F, 0x80,
  0x1D, 0xC3, 0x80, 0x3B, 0x03, 0x80, 0x7E, 0x03, 0x80, 0xFC, 0x03, 0x81,
  0xF8, 0x03, 0x83, 0x70, 0x03, 0xFE, 0xE0, 0x03, 0xF8,
};

const GFXglyph JetBrainsMono_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 6, 38, 31, 13, -38 },
  { 30, 14, 16, 31, 9, -38 },
  { 58, 27, 38, 31, 2, -38 },
  { 187, 23, 52, 31, 4, -45 },
  { 337, 29, 38, 31, 1, -38 },
  { 475, 26, 39, 31, 3, -38 },
  { 602, 3, 16, 31, 14, -38 },
  { 608, 14, 50, 31, 11, -44 },
  { 696, 15, 50, 31, 6, -44 },
  { 790, 27, 27, 31, 2, -32 },
  { 882, 23, 24, 31, 4, -29 },
  { 951, 8, 16, 31, 10, -8 },
  { 967, 17, 2, 31, 7, -18 },
  { 972, 7, 8, 31, 12, -7 },
  { 979, 21, 49, 31, 5, -43 },
  { 1108, 21, 39, 31, 5, -38 },
  { 1211, 23, 38, 31, 5, -38 },
  { 1321, 24, 38, 31, 4, -38 },
  { 1435, 20, 39, 31, 5, -38 },
  { 1533, 20, 38, 31, 5, -38 },
  { 1628, 21, 39, 31, 5, -38 },
  { 1731, 23, 39, 31, 4, -38 },
  { 1844, 23, 38, 31, 4, -38 },
  { 1954, 22, 39, 31, 5, -38 },
  { 2062, 23, 38, 31, 4, -38 },
  { 2172, 7, 30, 31, 12, -29 },
  { 2199, 10, 37, 31, 10, -29 },
  { 2246, 22, 26, 31, 5, -30 },
  { 2318, 21, 14, 31, 5, -24 },
  { 2355, 22, 26, 31, 5, -30 },
  { 2427, 17, 38, 31, 9, -38 },
  { 2508, 25, 47, 31, 3, -38 },
  { 2655, 24, 38, 31, 4, -38 },
  { 2769, 21, 38, 31, 6, -38 },
  { 2869, 22, 39, 31, 5, -38 },
  { 2977, 20, 38, 31, 6, -38 },
  { 3072, 21, 38, 31, 6, -38 },
  { 3172, 21, 38, 31, 6, -38 },
  { 3272, 22, 39, 31, 5, -38 },
  { 3380, 19, 38, 31, 6, -38 },
  { 3471, 19, 38, 31, 6, -38 },
  { 3562, 21, 39, 31, 4, -38 },
  { 3665, 22, 38, 31, 6, -38 },
  { 3770, 21, 38, 31, 6, -38 },
  { 3870, 21, 38, 31, 5, -38 },
  { 3970, 19, 38, 31, 6, -38 },
  { 4061, 21, 39, 31, 5, -38 },
  { 4164, 22, 38, 31, 6, -38 },
  { 4269, 22, 47, 31, 5, -38 },
  { 4399, 22, 38, 31, 6, -38 },
  { 4504, 23, 39, 31, 4, -38 },
  { 4617, 25, 38, 31, 3, -38 },
  { 4736, 20, 39, 31, 6, -38 },
  { 4834, 24, 38, 31, 4, -38 },
  { 4948, 27, 38, 31, 2, -38 },
  { 5077, 25, 38, 31, 3, -38 },
  { 5196, 26, 38, 31, 3, -38 },
  { 5320, 21, 38, 31, 5, -38 },
  { 5420, 12, 49, 31, 11, -43 },
  { 5494, 21, 49, 31, 5, -43 },
  { 5623, 12, 49, 31, 8, -43 },
  { 5697, 21, 20, 31, 5, -38 },
  { 5750, 25, 3, 31, 3, 1 },
  { 5760, 9, 7, 31, 10, -41 },
  { 5768, 22, 30, 31, 4, -29 },
  { 5851, 20, 39, 31, 6, -38 },
  { 5949, 21, 30, 31, 5, -29 },
  { 6028, 20, 39, 31, 5, -38 },
  { 6126, 21, 30, 31, 5, -29 },
  { 6205, 23, 38, 31, 4, -38 },
  { 6315, 20, 38, 31, 5, -29 },
  { 6410, 20, 38, 31, 6, -38 },
  { 6505, 23, 40, 31, 5, -40 },
  { 6620, 19, 49, 31, 5, -40 },
  { 6737, 22, 38, 31, 6, -38 },
  { 6842, 25, 38, 31, 3, -38 },
  { 6961, 23, 29, 31, 4, -29 },
  { 7045, 20, 29, 31, 6, -29 },
  { 7118, 21, 30, 31, 5, -29 },
  { 7197, 20, 38, 31, 6, -29 },
  { 7292, 20, 38, 31, 5, -29 },
  { 7387, 20, 29, 31, 7, -29 },
  { 7460, 21, 30, 31, 5, -29 },
  { 7539, 22, 37, 31, 4, -37 },
  { 7641, 20, 30, 31, 6, -29 },
  { 7716, 23, 29, 31, 4, -29 },
  { 7800, 26, 29, 31, 3, -29 },
  { 7895, 23, 29, 31, 4, -29 },
  { 7979, 23, 38, 31, 4, -29 },
  { 8089, 21, 29, 31, 5, -29 },
  { 8166, 21, 49, 31, 5, -43 },
  { 8295, 3, 49, 31, 14, -43 },
  { 8314, 21, 49, 31, 5, -43 },
  { 8443, 23, 9, 31, 4, -23 },
};

const GFXfont JetBrainsMono_Thin52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_THIN52PT7B_H_
