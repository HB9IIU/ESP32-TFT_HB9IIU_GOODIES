#ifndef _JETBRAINSMONO_THIN14PT7B_H_
#define _JETBRAINSMONO_THIN14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x54, 0x30, 0x99, 0x99, 0x12, 0x12, 0x12, 0x6F, 0x24, 0x24,
  0xFE, 0x24, 0x44, 0x48, 0x10, 0x47, 0xA5, 0x91, 0x43, 0x06, 0x16, 0x59,
  0x5E, 0x10, 0x40, 0x71, 0x92, 0x94, 0x54, 0x28, 0x16, 0x19, 0x29, 0x49,
  0x87, 0x78, 0x91, 0x02, 0x06, 0x12, 0x65, 0x44, 0x8D, 0xE4, 0xF0, 0x16,
  0x48, 0x88, 0x88, 0x88, 0x84, 0x61, 0x84, 0x22, 0x11, 0x11, 0x11, 0x22,
  0x48, 0x10, 0x20, 0x47, 0xF1, 0x05, 0x12, 0x22, 0x10, 0x41, 0x3F, 0x10,
  0x41, 0x00, 0x6A, 0xF0, 0xF0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x42, 0x00, 0x7A, 0x18, 0x61, 0xB6, 0x58, 0x61, 0x85, 0xE0,
  0x31, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x7A, 0x18, 0x41, 0x04,
  0x21, 0x08, 0x43, 0xF0, 0x7C, 0x21, 0x0C, 0x08, 0x10, 0x61, 0x85, 0xE0,
  0x08, 0x41, 0x08, 0x45, 0x18, 0x7F, 0x04, 0x10, 0x7E, 0x08, 0x2E, 0x44,
  0x10, 0x41, 0x85, 0xE0, 0x10, 0x82, 0x10, 0x7A, 0x18, 0x61, 0x85, 0xE0,
  0xFE, 0x18, 0x42, 0x08, 0x21, 0x04, 0x20, 0x80, 0x7A, 0x18, 0x51, 0x39,
  0x28, 0x61, 0x85, 0xE0, 0x7A, 0x18, 0x61, 0x85, 0xF0, 0x84, 0x10, 0x80,
  0xF0, 0x0F, 0xF0, 0x06, 0xA0, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC,
  0x00, 0x3F, 0xC0, 0x81, 0x81, 0x19, 0x88, 0x00, 0xF0, 0x42, 0x11, 0x31,
  0x00, 0x03, 0x00, 0x7D, 0x0A, 0x0C, 0xFA, 0x34, 0x68, 0xD1, 0x9F, 0x02,
  0x02, 0x03, 0x80, 0x10, 0xC2, 0x8A, 0x49, 0x27, 0xA1, 0x86, 0x10, 0xF4,
  0x63, 0x1F, 0x46, 0x31, 0x8F, 0x80, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x21,
  0x45, 0xE0, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0x80, 0xFC, 0x21, 0x0F,
  0xC2, 0x10, 0x87, 0xC0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x84, 0x00, 0x7A,
  0x18, 0x60, 0x82, 0x78, 0x61, 0x45, 0xE0, 0x8C, 0x63, 0x1F, 0xC6, 0x31,
  0x8C, 0x40, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x3C, 0x10, 0x41,
  0x04, 0x10, 0x61, 0x85, 0xE0, 0x8A, 0x29, 0x24, 0xE2, 0x49, 0x24, 0x8A,
  0x30, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0xC7, 0x3A, 0xED, 0xB6,
  0x18, 0x61, 0x86, 0x10, 0x8C, 0x73, 0x9A, 0xD6, 0xB3, 0x9C, 0x40, 0x7A,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0xFC, 0x63, 0x18, 0xFA, 0x10,
  0x84, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0x81, 0x04,
  0xFC, 0x63, 0x19, 0xF2, 0x52, 0x8C, 0x40, 0x7A, 0x18, 0x10, 0x30, 0x20,
  0x61, 0x85, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0x80, 0x86, 0x14, 0x51, 0x49, 0x22,
  0x8C, 0x30, 0x40, 0x93, 0x26, 0xCD, 0x9A, 0xD5, 0xAB, 0x66, 0xCC, 0x98,
  0x84, 0x89, 0x21, 0x81, 0x06, 0x0A, 0x24, 0x85, 0x0C, 0x87, 0x09, 0x22,
  0x43, 0x02, 0x04, 0x08, 0x10, 0x20, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10,
  0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x81, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x93,
  0xC0, 0x10, 0xC2, 0x92, 0xC4, 0xFE, 0x90, 0x39, 0x10, 0x4F, 0x46, 0x18,
  0x5F, 0x84, 0x3D, 0x18, 0xC6, 0x31, 0x8F, 0x80, 0x39, 0x18, 0x60, 0x82,
  0x14, 0x5E, 0x04, 0x13, 0xD1, 0x86, 0x18, 0x61, 0x45, 0xF0, 0x39, 0x18,
  0x7F, 0x82, 0x04, 0x5E, 0x1C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80,
  0x3D, 0x18, 0x61, 0x86, 0x14, 0xCD, 0x04, 0x17, 0x80, 0x84, 0x3D, 0x18,
  0xC6, 0x31, 0x8C, 0x40, 0x10, 0x40, 0x1C, 0x10, 0x41, 0x04, 0x10, 0x4F,
  0xC0, 0x08, 0x40, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x11, 0xE0, 0x84, 0x23,
  0x19, 0x72, 0x92, 0x8C, 0x40, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x3C, 0xEE, 0x59, 0x65, 0x96, 0x59, 0x65, 0xF4, 0x63, 0x18, 0xC6,
  0x31, 0x39, 0x18, 0x61, 0x86, 0x14, 0x5E, 0xF4, 0x63, 0x18, 0xC6, 0x3E,
  0x84, 0x20, 0x3D, 0x18, 0x61, 0x86, 0x14, 0x5F, 0x04, 0x10, 0x40, 0xF4,
  0x63, 0x08, 0x42, 0x10, 0x39, 0x18, 0x18, 0x1C, 0x18, 0x5F, 0x20, 0x8F,
  0xC8, 0x20, 0x82, 0x08, 0x20, 0x70, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x86,
  0x14, 0x52, 0x48, 0xA3, 0x04, 0x93, 0x26, 0xD5, 0xAA, 0xD5, 0x93, 0x24,
  0x85, 0x22, 0x8C, 0x30, 0xA4, 0xA1, 0x86, 0x14, 0x52, 0x28, 0xA1, 0x04,
  0x20, 0x82, 0x00, 0x7C, 0x20, 0x84, 0x20, 0x84, 0x3F, 0x0C, 0x41, 0x04,
  0x10, 0x4F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x30, 0xFF, 0xFC, 0xC0, 0x82,
  0x08, 0x20, 0x81, 0xC4, 0x20, 0x82, 0x08, 0x23, 0x00, 0xE6, 0x70,
};

const GFXglyph JetBrainsMono_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 14, 8, 1, -12 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 7, 10, 8, 1, -10 },
  { 46, 1, 4, 8, 4, -10 },
  { 47, 4, 14, 8, 3, -12 },
  { 54, 4, 14, 8, 2, -12 },
  { 61, 7, 8, 8, 1, -9 },
  { 68, 6, 7, 8, 1, -8 },
  { 74, 2, 4, 8, 3, -2 },
  { 75, 4, 1, 8, 2, -5 },
  { 76, 2, 2, 8, 3, -2 },
  { 77, 6, 14, 8, 1, -12 },
  { 88, 6, 10, 8, 1, -10 },
  { 96, 6, 10, 8, 1, -10 },
  { 104, 6, 10, 8, 1, -10 },
  { 112, 6, 10, 8, 1, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 6, 10, 8, 1, -10 },
  { 136, 6, 10, 8, 1, -10 },
  { 144, 6, 10, 8, 1, -10 },
  { 152, 6, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 1, -10 },
  { 168, 2, 8, 8, 3, -8 },
  { 170, 2, 10, 8, 3, -8 },
  { 173, 6, 7, 8, 1, -8 },
  { 179, 6, 4, 8, 1, -7 },
  { 182, 6, 7, 8, 1, -8 },
  { 188, 5, 10, 8, 2, -10 },
  { 195, 7, 13, 8, 1, -10 },
  { 207, 6, 10, 8, 1, -10 },
  { 215, 5, 10, 8, 2, -10 },
  { 222, 6, 10, 8, 1, -10 },
  { 230, 5, 10, 8, 2, -10 },
  { 237, 5, 10, 8, 2, -10 },
  { 244, 5, 10, 8, 2, -10 },
  { 251, 6, 10, 8, 1, -10 },
  { 259, 5, 10, 8, 2, -10 },
  { 266, 5, 10, 8, 2, -10 },
  { 273, 6, 10, 8, 1, -10 },
  { 281, 6, 10, 8, 2, -10 },
  { 289, 5, 10, 8, 2, -10 },
  { 296, 6, 10, 8, 1, -10 },
  { 304, 5, 10, 8, 2, -10 },
  { 311, 6, 10, 8, 1, -10 },
  { 319, 5, 10, 8, 2, -10 },
  { 326, 6, 13, 8, 1, -10 },
  { 336, 5, 10, 8, 2, -10 },
  { 343, 6, 10, 8, 1, -10 },
  { 351, 7, 10, 8, 1, -10 },
  { 360, 5, 10, 8, 2, -10 },
  { 367, 6, 10, 8, 1, -10 },
  { 375, 7, 10, 8, 1, -10 },
  { 384, 7, 10, 8, 1, -10 },
  { 393, 7, 10, 8, 1, -10 },
  { 402, 6, 10, 8, 1, -10 },
  { 410, 3, 14, 8, 3, -12 },
  { 416, 6, 14, 8, 1, -12 },
  { 427, 3, 14, 8, 2, -12 },
  { 433, 6, 5, 8, 1, -10 },
  { 437, 7, 1, 8, 1, 0 },
  { 438, 2, 2, 8, 3, -11 },
  { 439, 6, 8, 8, 1, -8 },
  { 445, 5, 10, 8, 2, -10 },
  { 452, 6, 8, 8, 1, -8 },
  { 458, 6, 10, 8, 1, -10 },
  { 466, 6, 8, 8, 1, -8 },
  { 472, 6, 10, 8, 1, -10 },
  { 480, 6, 11, 8, 1, -8 },
  { 489, 5, 10, 8, 2, -10 },
  { 496, 6, 11, 8, 1, -11 },
  { 505, 5, 14, 8, 1, -11 },
  { 514, 5, 10, 8, 2, -10 },
  { 521, 7, 10, 8, 1, -10 },
  { 530, 6, 8, 8, 1, -8 },
  { 536, 5, 8, 8, 2, -8 },
  { 541, 6, 8, 8, 1, -8 },
  { 547, 5, 11, 8, 2, -8 },
  { 554, 6, 11, 8, 1, -8 },
  { 563, 5, 8, 8, 2, -8 },
  { 568, 6, 8, 8, 1, -8 },
  { 574, 6, 10, 8, 1, -10 },
  { 582, 5, 8, 8, 2, -8 },
  { 587, 6, 8, 8, 1, -8 },
  { 593, 7, 8, 8, 1, -8 },
  { 600, 6, 8, 8, 1, -8 },
  { 606, 6, 11, 8, 1, -8 },
  { 615, 6, 8, 8, 1, -8 },
  { 621, 6, 14, 8, 1, -12 },
  { 632, 1, 14, 8, 4, -12 },
  { 634, 6, 14, 8, 1, -12 },
  { 645, 6, 2, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Thin14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_THIN14PT7B_H_
