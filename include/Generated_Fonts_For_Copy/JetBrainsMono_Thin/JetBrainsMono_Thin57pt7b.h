#ifndef _JETBRAINSMONO_THIN57PT7B_H_
#define _JETBRAINSMONO_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xBF, 0xFF,
  0xFC, 0xF8, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1C, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x01, 0xC0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x1C, 0x78,
  0x3C, 0x1C, 0x3C, 0x38, 0x1C, 0x1E, 0x38, 0x1C, 0x0E, 0x70, 0x1C, 0x0E,
  0x70, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0xDC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0xF8,
  0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0F,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0xE0, 0x1C, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xF0, 0x1C, 0x07,
  0x70, 0x1C, 0x0E, 0x78, 0x1C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1F, 0x9C, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x0F, 0xF8,
  0x00, 0x06, 0x1F, 0xFC, 0x00, 0x0E, 0x38, 0x1C, 0x00, 0x1C, 0x70, 0x0E,
  0x00, 0x18, 0x70, 0x06, 0x00, 0x30, 0x70, 0x06, 0x00, 0x70, 0x60, 0x06,
  0x00, 0xE0, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x60, 0x06,
  0x03, 0x80, 0x60, 0x06, 0x03, 0x00, 0x60, 0x06, 0x07, 0x00, 0x70, 0x06,
  0x0E, 0x00, 0x70, 0x0E, 0x0C, 0x00, 0x38, 0x0E, 0x18, 0x00, 0x3C, 0x3C,
  0x38, 0x00, 0x1F, 0xF8, 0x70, 0x00, 0x07, 0xF0, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x0C,
  0x1F, 0xFC, 0x00, 0x1C, 0x38, 0x1C, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x30,
  0x70, 0x0E, 0x00, 0x70, 0x60, 0x06, 0x00, 0xE0, 0x60, 0x06, 0x00, 0xC0,
  0x60, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0x60, 0x06, 0x07, 0x00,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x0E, 0x00, 0x70, 0x06, 0x1C, 0x00,
  0x70, 0x0E, 0x18, 0x00, 0x30, 0x0E, 0x30, 0x00, 0x3C, 0x3C, 0x70, 0x00,
  0x1F, 0xF8, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x87, 0x80, 0x0E, 0xF0,
  0x38, 0x00, 0xEE, 0x01, 0xC0, 0x1C, 0xE0, 0x0E, 0x01, 0xCE, 0x00, 0xF0,
  0x38, 0xE0, 0x07, 0x03, 0x8E, 0x00, 0x38, 0x70, 0xE0, 0x01, 0xC6, 0x0E,
  0x00, 0x1E, 0xE0, 0xE0, 0x00, 0xFC, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0xE0,
  0xE0, 0x00, 0xE7, 0x0F, 0x00, 0x1C, 0x78, 0x78, 0x07, 0x83, 0x83, 0xC0,
  0xF0, 0x1C, 0x3F, 0xFE, 0x00, 0xE0, 0xFF, 0x80, 0x07, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x0E, 0x00, 0x67, 0xC0, 0x38, 0x07, 0xBF, 0xE0, 0xC0, 0xFF, 0x3F,
  0xE3, 0x1F, 0xF0, 0x1F, 0xEC, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x01,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x0F, 0xC3, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x28, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x3E, 0x1C, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x80, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00,
  0x1E, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70,
  0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0x63, 0xFF, 0xE0, 0xCF, 0x07,
  0xE1, 0xB8, 0x03, 0xC3, 0x40, 0x03, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x03,
  0x9C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x0F, 0x00,
  0x3C, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x1D, 0xFF, 0xE0, 0x1B, 0xE7,
  0xF0, 0x3F, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x2C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xE3, 0xF0, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0x78, 0x07, 0x80, 0xF0, 0x03, 0xE3, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xC3, 0xC0, 0x0F, 0x80, 0xF0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00,
  0x7C, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xB8, 0x03, 0xFF, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x0F, 0x07,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x38, 0x3F, 0x00, 0x3F, 0xE7,
  0xE0, 0x0F, 0xFE, 0xFC, 0x03, 0xE0, 0xFF, 0x80, 0x70, 0x07, 0xF0, 0x1C,
  0x00, 0x7E, 0x03, 0x80, 0x0F, 0xC0, 0x70, 0x01, 0xF8, 0x0E, 0x00, 0x3F,
  0x01, 0xC0, 0x07, 0xE0, 0x38, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0x80, 0xE0,
  0x03, 0xF0, 0x1C, 0x00, 0x7E, 0x03, 0x80, 0x0F, 0xC0, 0x70, 0x01, 0xF8,
  0x0E, 0x00, 0x3F, 0x01, 0xC0, 0x07, 0xE0, 0x38, 0x00, 0xFC, 0x07, 0x00,
  0x3F, 0x80, 0x70, 0x07, 0xF0, 0x0F, 0x01, 0xFE, 0x00, 0xFF, 0xEF, 0xC0,
  0x0F, 0xF9, 0xF8, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80,
  0x07, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x38, 0x00,
  0x7C, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x3E, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0x1F, 0x80, 0xF0, 0x07, 0x83, 0x80, 0x07, 0x8E, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0,
  0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x3E, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0x1F, 0x80, 0xF0, 0x07, 0x83, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xC7, 0x00, 0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xEC, 0x00, 0x37, 0xEC, 0x00,
  0x37, 0xEE, 0x00, 0x37, 0xE6, 0x00, 0x67, 0xE6, 0x00, 0x67, 0xE3, 0x00,
  0xE7, 0xE3, 0x00, 0xC7, 0xE3, 0x80, 0xC7, 0xE1, 0x81, 0xC7, 0xE1, 0x81,
  0x87, 0xE1, 0xC1, 0x87, 0xE0, 0xC3, 0x87, 0xE0, 0xC3, 0x07, 0xE0, 0xE3,
  0x07, 0xE0, 0x66, 0x07, 0xE0, 0x66, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xB0, 0x00, 0x7E, 0xE0, 0x01, 0xFB, 0x80, 0x07, 0xE6,
  0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x30, 0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80,
  0x1F, 0x86, 0x00, 0x7E, 0x1C, 0x01, 0xF8, 0x30, 0x07, 0xE0, 0xE0, 0x1F,
  0x83, 0x80, 0x7E, 0x06, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x30, 0x1F, 0x80,
  0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x06, 0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x30,
  0x7E, 0x00, 0xE1, 0xF8, 0x03, 0x87, 0xE0, 0x06, 0x1F, 0x80, 0x1C, 0x7E,
  0x00, 0x71, 0xF8, 0x00, 0xE7, 0xE0, 0x03, 0x9F, 0x80, 0x06, 0x7E, 0x00,
  0x1D, 0xF8, 0x00, 0x77, 0xE0, 0x00, 0xDF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xF8, 0x7E, 0x07, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0xC0, 0x78, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x05, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00,
  0x0F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0x3F, 0x81, 0xF0, 0x07, 0x83, 0x80, 0x07, 0x0E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x87, 0x00, 0x0F, 0x0F, 0x00, 0x3C,
  0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0,
  0x01, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x78, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0xE3, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x70,
  0x00, 0x38, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0xC0, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x76, 0x00, 0x78, 0x01, 0xD8,
  0x01, 0xF0, 0x07, 0x60, 0x06, 0xC0, 0x19, 0xC0, 0x1B, 0x00, 0x67, 0x00,
  0x6C, 0x01, 0x9C, 0x03, 0xB0, 0x0E, 0x70, 0x0C, 0xC0, 0x39, 0xC0, 0x33,
  0x00, 0xE3, 0x00, 0xCC, 0x03, 0x8C, 0x03, 0x38, 0x0E, 0x30, 0x0C, 0x60,
  0x30, 0xE0, 0x31, 0x80, 0xC3, 0x81, 0xC6, 0x03, 0x0E, 0x06, 0x18, 0x1C,
  0x38, 0x18, 0x60, 0x70, 0xE0, 0x61, 0x81, 0xC1, 0x81, 0x87, 0x07, 0x06,
  0x06, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x60, 0x70, 0xE0, 0xC1, 0x81, 0xC3,
  0x03, 0x06, 0x07, 0x0C, 0x0C, 0x18, 0x1C, 0x30, 0x30, 0xE0, 0x70, 0xC0,
  0xE3, 0x81, 0xC3, 0x03, 0x8E, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x18,
  0xC0, 0x39, 0x80, 0x63, 0x00, 0xE6, 0x01, 0x8C, 0x03, 0x98, 0x06, 0x30,
  0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x77, 0x00, 0xE6, 0x00, 0xDC, 0x01,
  0xB0, 0x03, 0x70, 0x06, 0xC0, 0x0D, 0x80, 0x1F, 0x00, 0x36, 0x00, 0x7C,
  0x00, 0xD8, 0x01, 0xF0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x38, 0x0E,
  0x00, 0x70, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x78, 0x07, 0xC1, 0xE0, 0x03, 0x87, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x78, 0x00, 0x1D,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7B, 0x80, 0x01, 0xF7, 0x80, 0x06, 0xE7, 0xC0, 0x3D, 0xC7, 0xFF,
  0xF3, 0x83, 0xFF, 0x87, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0xE0, 0x38, 0xFF, 0xE0, 0xE7, 0xFF, 0xE3, 0xB8, 0x07, 0xCF, 0xC0, 0x07,
  0x3E, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3B, 0xE0, 0x01, 0xEE, 0xC0, 0x0F, 0x3B, 0xC0, 0x78, 0xE7, 0xFF, 0xC3,
  0x87, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xF0, 0x0F, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF3,
  0xC0, 0x01, 0xC3, 0xC0, 0x0F, 0x03, 0xE0, 0x7E, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x1F, 0xC1, 0xC1,
  0xFF, 0xC7, 0x0F, 0xFF, 0x9C, 0x78, 0x07, 0x73, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0,
  0x01, 0xF3, 0xC0, 0x0D, 0xC7, 0x80, 0xF7, 0x0F, 0xFF, 0x9C, 0x1F, 0xF8,
  0x70, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0x80, 0x7C, 0x38, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x3C, 0x00, 0xF0,
  0x7C, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x50, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x70, 0xFF, 0xF9,
  0xC7, 0x80, 0x77, 0x38, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00,
  0x7C, 0xF0, 0x03, 0x71, 0xE0, 0x1D, 0xC3, 0xFF, 0xE7, 0x07, 0xFE, 0x1C,
  0x03, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0xE0, 0x38, 0xFF, 0xE0, 0xE7, 0xFF, 0xE3,
  0xB8, 0x07, 0xCE, 0xC0, 0x07, 0x3E, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x03, 0xE0, 0x7C, 0x39, 0xFC, 0x3F, 0xCE, 0xFF, 0x9F, 0xF3,
  0xA0, 0xF4, 0x1E, 0xF0, 0x1E, 0x03, 0xBC, 0x07, 0x80, 0x7E, 0x00, 0xE0,
  0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00,
  0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E,
  0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00,
  0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03,
  0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8,
  0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01,
  0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0x00, 0x7E,
  0x03, 0x8F, 0xFE, 0x0E, 0x7F, 0xFE, 0x3B, 0x80, 0x7C, 0xEC, 0x00, 0x73,
  0xE0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0x00, 0x03, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x7C, 0x07,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x58, 0x00, 0x00, 0x7E, 0x03,
  0x8F, 0xFE, 0x0E, 0x7F, 0xFE, 0x3B, 0x80, 0x7C, 0xFC, 0x00, 0x73, 0xE0,
  0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xBE,
  0x00, 0x1E, 0xEC, 0x00, 0xF3, 0xBC, 0x07, 0x8E, 0x7F, 0xFC, 0x38, 0x7F,
  0xE0, 0xE0, 0x10, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x70, 0xFF,
  0xF9, 0xC7, 0x80, 0x77, 0x38, 0x00, 0x7D, 0xC0, 0x01, 0xF7, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x3C, 0x00,
  0xDC, 0x78, 0x0F, 0x70, 0xFF, 0xF9, 0xC0, 0xFF, 0x87, 0x00, 0x20, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x7E, 0x01, 0xC7, 0xFF, 0x83, 0x9F, 0xFF, 0x87, 0x70, 0x0F,
  0x8E, 0xC0, 0x07, 0x9F, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x1E,
  0x1F, 0x00, 0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1F, 0x03,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0x76, 0x00, 0xF0, 0x07, 0x60, 0x0D, 0x80, 0x77, 0x00, 0xD8, 0x06, 0x70,
  0x19, 0x80, 0x67, 0x01, 0x98, 0x0E, 0x70, 0x19, 0x80, 0xE3, 0x01, 0x9C,
  0x0E, 0x30, 0x18, 0xC0, 0xE3, 0x83, 0x8C, 0x0C, 0x38, 0x30, 0xC0, 0xC3,
  0x83, 0x0C, 0x1C, 0x38, 0x30, 0xC1, 0xC1, 0x83, 0x0E, 0x1C, 0x18, 0x70,
  0x61, 0x81, 0xC6, 0x06, 0x18, 0x1C, 0x60, 0x61, 0x81, 0xC6, 0x06, 0x38,
  0x1C, 0x60, 0x73, 0x80, 0xCE, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xEC,
  0x03, 0x30, 0x0E, 0xC0, 0x33, 0x00, 0xEC, 0x03, 0xF0, 0x0E, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x07, 0x80, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x0E, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0x7F, 0xE0, 0x03, 0x70, 0xF0, 0x03, 0xE0,
  0x78, 0x03, 0xE0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x07, 0xC0,
  0x07, 0x8F, 0xC0, 0x03, 0xFE, 0xC0, 0x01, 0xFC,
};

const GFXglyph JetBrainsMono_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 7, 42, 34, 14, -42 },
  { 38, 15, 17, 34, 10, -42 },
  { 70, 30, 42, 34, 2, -42 },
  { 228, 24, 58, 34, 5, -50 },
  { 402, 32, 42, 34, 1, -42 },
  { 570, 28, 43, 34, 4, -42 },
  { 721, 4, 17, 34, 15, -42 },
  { 730, 16, 55, 34, 12, -48 },
  { 840, 16, 55, 34, 7, -48 },
  { 950, 30, 29, 34, 2, -35 },
  { 1059, 26, 26, 34, 4, -32 },
  { 1144, 9, 18, 34, 11, -9 },
  { 1165, 18, 2, 34, 8, -20 },
  { 1170, 8, 9, 34, 13, -8 },
  { 1179, 24, 53, 34, 5, -47 },
  { 1338, 24, 43, 34, 5, -42 },
  { 1467, 24, 42, 34, 6, -42 },
  { 1593, 25, 42, 34, 5, -42 },
  { 1725, 23, 43, 34, 5, -42 },
  { 1849, 22, 42, 34, 6, -42 },
  { 1965, 23, 43, 34, 6, -42 },
  { 2089, 24, 43, 34, 5, -42 },
  { 2218, 25, 42, 34, 5, -42 },
  { 2350, 24, 43, 34, 5, -42 },
  { 2479, 24, 42, 34, 5, -42 },
  { 2605, 8, 33, 34, 13, -32 },
  { 2638, 10, 41, 34, 11, -32 },
  { 2690, 24, 28, 34, 5, -33 },
  { 2774, 24, 16, 34, 5, -27 },
  { 2822, 24, 28, 34, 5, -33 },
  { 2906, 19, 42, 34, 10, -42 },
  { 3006, 27, 52, 34, 4, -42 },
  { 3182, 26, 42, 34, 4, -42 },
  { 3319, 23, 42, 34, 6, -42 },
  { 3440, 23, 43, 34, 6, -42 },
  { 3564, 22, 42, 34, 6, -42 },
  { 3680, 22, 42, 34, 7, -42 },
  { 3796, 23, 42, 34, 7, -42 },
  { 3917, 23, 43, 34, 6, -42 },
  { 4041, 22, 42, 34, 6, -42 },
  { 4157, 20, 42, 34, 7, -42 },
  { 4262, 23, 43, 34, 4, -42 },
  { 4386, 25, 42, 34, 6, -42 },
  { 4518, 23, 42, 34, 7, -42 },
  { 4639, 24, 42, 34, 5, -42 },
  { 4765, 22, 42, 34, 6, -42 },
  { 4881, 22, 43, 34, 6, -42 },
  { 5000, 25, 42, 34, 6, -42 },
  { 5132, 23, 52, 34, 6, -42 },
  { 5282, 24, 42, 34, 6, -42 },
  { 5408, 24, 43, 34, 5, -42 },
  { 5537, 28, 42, 34, 3, -42 },
  { 5684, 22, 43, 34, 6, -42 },
  { 5803, 26, 42, 34, 4, -42 },
  { 5940, 30, 42, 34, 2, -42 },
  { 6098, 28, 42, 34, 3, -42 },
  { 6245, 28, 42, 34, 3, -42 },
  { 6392, 24, 42, 34, 5, -42 },
  { 6518, 12, 53, 34, 13, -47 },
  { 6598, 24, 53, 34, 5, -47 },
  { 6757, 13, 53, 34, 9, -47 },
  { 6844, 23, 23, 34, 6, -42 },
  { 6911, 28, 3, 34, 3, 1 },
  { 6922, 10, 8, 34, 11, -45 },
  { 6932, 23, 33, 34, 5, -32 },
  { 7027, 22, 43, 34, 6, -42 },
  { 7146, 23, 33, 34, 6, -32 },
  { 7241, 22, 43, 34, 6, -42 },
  { 7360, 22, 33, 34, 6, -32 },
  { 7451, 26, 42, 34, 4, -42 },
  { 7588, 22, 42, 34, 6, -32 },
  { 7704, 22, 42, 34, 6, -42 },
  { 7820, 26, 44, 34, 5, -44 },
  { 7963, 21, 54, 34, 5, -44 },
  { 8105, 24, 42, 34, 6, -42 },
  { 8231, 28, 42, 34, 3, -42 },
  { 8378, 26, 32, 34, 4, -32 },
  { 8482, 22, 32, 34, 6, -32 },
  { 8570, 22, 33, 34, 6, -32 },
  { 8661, 22, 42, 34, 6, -32 },
  { 8777, 22, 42, 34, 6, -32 },
  { 8893, 23, 32, 34, 7, -32 },
  { 8985, 24, 33, 34, 5, -32 },
  { 9084, 25, 40, 34, 4, -40 },
  { 9209, 22, 32, 34, 6, -31 },
  { 9297, 26, 31, 34, 4, -31 },
  { 9398, 28, 31, 34, 3, -31 },
  { 9507, 26, 31, 34, 4, -31 },
  { 9608, 26, 41, 34, 4, -31 },
  { 9742, 22, 31, 34, 6, -31 },
  { 9828, 23, 53, 34, 6, -47 },
  { 9981, 3, 53, 34, 16, -47 },
  { 10001, 23, 53, 34, 6, -47 },
  { 10154, 24, 10, 34, 5, -25 },
};

const GFXfont JetBrainsMono_Thin57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_THIN57PT7B_H_
