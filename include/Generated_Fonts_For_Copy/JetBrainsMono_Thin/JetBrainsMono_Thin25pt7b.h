#ifndef _JETBRAINSMONO_THIN25PT7B_H_
#define _JETBRAINSMONO_THIN25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x02, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x04, 0x30, 0x61, 0x02, 0x08, 0x10, 0x40, 0x82, 0x3F,
  0xFC, 0x61, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x21, 0x0F, 0xFF,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x21, 0x83, 0x08, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x03, 0xF8, 0xC9, 0x91, 0x12, 0x23, 0x44, 0x08, 0x81, 0x90,
  0x1A, 0x01, 0xE0, 0x0F, 0x01, 0x30, 0x22, 0x04, 0x70, 0x87, 0x10, 0xA2,
  0x36, 0x4C, 0x7F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x3C, 0x06, 0x84,
  0x11, 0x08, 0x62, 0x10, 0x84, 0x22, 0x08, 0x48, 0x19, 0x90, 0x1E, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x09, 0xE0, 0x24, 0x20, 0xC8, 0x41, 0x10, 0x84,
  0x21, 0x10, 0x42, 0x20, 0x85, 0x80, 0xF0, 0x04, 0x03, 0xF0, 0x61, 0x84,
  0x08, 0x40, 0x86, 0x00, 0x60, 0x02, 0x00, 0x30, 0x07, 0x80, 0x8C, 0x38,
  0x42, 0x82, 0x48, 0x34, 0x81, 0x88, 0x18, 0x81, 0x4C, 0x22, 0x7C, 0x30,
  0xFE, 0x02, 0x18, 0x41, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x02, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x40, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0x60, 0x86, 0x18, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x0E, 0x23, 0x9D, 0x70, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x44, 0x06,
  0x30, 0x60, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x36, 0x66, 0x4C, 0x88,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x04, 0x07, 0xF1, 0x83, 0x20, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x79, 0xCF, 0x39, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1A, 0x03, 0x40,
  0x4E, 0x18, 0x7C, 0x00, 0x0E, 0x03, 0x40, 0x88, 0x21, 0x08, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x1F, 0xFC, 0x04, 0x07, 0xF1, 0x83, 0x60, 0x28, 0x07,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x3E, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x70, 0x1C, 0x05, 0x03, 0x61, 0x8F, 0xC0, 0x01, 0x80, 0x40, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x41, 0x30, 0x48, 0x14, 0x07, 0x01, 0xC0, 0x7F,
  0xF0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x13, 0xC2, 0x8C, 0x60, 0xC8, 0x08, 0x01, 0x00, 0x30, 0x07,
  0x00, 0x90, 0x12, 0x02, 0x60, 0x83, 0xE0, 0x03, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x78, 0x71, 0xC8, 0x0B, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x1A, 0x02, 0x60, 0xC3, 0xE0, 0xFF, 0xF8, 0x07, 0x01,
  0xE0, 0x2C, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x04, 0x07, 0xF1,
  0x83, 0x20, 0x24, 0x06, 0x80, 0xD0, 0x11, 0x06, 0x19, 0x01, 0xC0, 0x6C,
  0x30, 0x64, 0x05, 0x80, 0xF0, 0x1E, 0x03, 0x40, 0x4C, 0x18, 0xFE, 0x00,
  0x04, 0x07, 0xF1, 0x83, 0x20, 0x2C, 0x07, 0x00, 0x60, 0x0E, 0x03, 0xC0,
  0x6C, 0x18, 0xED, 0x0E, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x7F, 0xC0, 0x77, 0x72, 0x00,
  0x00, 0x00, 0x36, 0x66, 0x4C, 0x88, 0x00, 0x20, 0x0C, 0x06, 0x03, 0x81,
  0xC0, 0xE0, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x02,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x06, 0x03, 0x81, 0xC0,
  0xE0, 0x30, 0x08, 0x00, 0xFC, 0x01, 0x00, 0x40, 0x20, 0x18, 0x08, 0x04,
  0x06, 0x0E, 0x1C, 0x08, 0x04, 0x02, 0x00, 0x00, 0x00, 0x40, 0x70, 0x38,
  0x00, 0x04, 0x03, 0xF8, 0x60, 0x44, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38,
  0x7F, 0x8C, 0x78, 0xC3, 0x88, 0x38, 0x83, 0x88, 0x38, 0x83, 0x88, 0x38,
  0xC3, 0x87, 0xF8, 0x18, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x1F, 0x00,
  0x04, 0x01, 0x40, 0x28, 0x05, 0x01, 0xB0, 0x22, 0x04, 0x40, 0x88, 0x31,
  0x84, 0x10, 0x82, 0x30, 0x67, 0xFC, 0x80, 0x90, 0x16, 0x03, 0x80, 0x30,
  0x04, 0xFE, 0x20, 0x68, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0xFE,
  0x20, 0xC8, 0x0A, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x02, 0x83, 0xBF, 0x80,
  0x08, 0x1F, 0xCC, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0E, 0x03, 0x80, 0x90, 0x63, 0xF0,
  0xFE, 0x41, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x83, 0x7E, 0x00, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x08, 0x1F, 0xCC, 0x1A, 0x02,
  0x80, 0xE0, 0x38, 0x02, 0x00, 0x80, 0x20, 0x08, 0xFE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x90, 0x63, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x7F,
  0xC0, 0x0F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x07, 0x03, 0x61, 0x8F, 0xC0,
  0x80, 0xD0, 0x12, 0x06, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x20, 0xFC,
  0x10, 0x82, 0x18, 0x41, 0x08, 0x31, 0x02, 0x20, 0x64, 0x04, 0x80, 0xD0,
  0x0C, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0,
  0xC0, 0x74, 0x16, 0x82, 0xC8, 0xB9, 0x17, 0xA2, 0xF2, 0x9E, 0x53, 0xCA,
  0x78, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0C, 0xC0, 0xE0, 0x78, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x31, 0x88, 0xC4,
  0x61, 0x30, 0x98, 0x6C, 0x16, 0x0B, 0x03, 0x81, 0xC0, 0xC0, 0x08, 0x3F,
  0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x8F, 0x80, 0xFF, 0x20, 0x68, 0x0E,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x81, 0xBF, 0x88, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x08, 0x1F, 0xCC, 0x1A, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0xFF, 0x20, 0x68, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x83,
  0xBF, 0x88, 0x42, 0x18, 0x82, 0x20, 0xC8, 0x12, 0x06, 0x80, 0xA0, 0x30,
  0x04, 0x07, 0xF1, 0x83, 0x20, 0x24, 0x06, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0xC0, 0x0E, 0x00, 0x60, 0x04, 0x00, 0xE0, 0x0E, 0x01, 0x40, 0x4C,
  0x18, 0xFE, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x41, 0x1F, 0x00, 0x80, 0x38, 0x07, 0x01, 0xA0, 0x24,
  0x04, 0xC0, 0x88, 0x21, 0x04, 0x20, 0x86, 0x30, 0x44, 0x08, 0x81, 0x10,
  0x36, 0x02, 0x80, 0x50, 0x0A, 0x00, 0x80, 0x82, 0x0C, 0x28, 0x71, 0x43,
  0x8A, 0x34, 0x51, 0x22, 0x89, 0x14, 0x48, 0xA2, 0x48, 0x92, 0x44, 0x9A,
  0x24, 0xD1, 0x62, 0x8A, 0x14, 0x50, 0xA2, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x00, 0x60, 0x11, 0x01, 0x0C, 0x18, 0x20, 0x81, 0x8C, 0x04, 0x40, 0x14,
  0x00, 0xA0, 0x02, 0x00, 0x28, 0x01, 0x40, 0x11, 0x01, 0x8C, 0x08, 0x20,
  0xC1, 0x84, 0x04, 0x60, 0x36, 0x00, 0xC0, 0xC0, 0x1A, 0x00, 0x88, 0x08,
  0x40, 0x41, 0x04, 0x08, 0x20, 0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xC0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0,
  0x1F, 0xFC, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x10, 0x03, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x06,
  0x01, 0x40, 0x28, 0x0C, 0x81, 0x10, 0x63, 0x08, 0x23, 0x06, 0x40, 0x58,
  0x0C, 0xFF, 0xF8, 0xC4, 0x21, 0x1F, 0x0C, 0x66, 0x0D, 0x01, 0x00, 0x40,
  0x11, 0xFD, 0x81, 0xC0, 0x60, 0x18, 0x07, 0x01, 0x60, 0xCF, 0xD0, 0x80,
  0x40, 0x20, 0x10, 0x09, 0xE7, 0x1B, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x81, 0xC1, 0x5F, 0x00, 0x3E, 0x18, 0xCC, 0x0A,
  0x02, 0x80, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x38, 0x0A, 0x02, 0x41,
  0x8F, 0x80, 0x00, 0x80, 0x40, 0x20, 0x13, 0xCB, 0x1F, 0x07, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x41, 0x9F, 0x40, 0x3E,
  0x31, 0xB0, 0x70, 0x18, 0x0C, 0x07, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x14, 0x11, 0xF0, 0x07, 0xE1, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x3F,
  0xF8, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x3C, 0xB1, 0x70, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x6C, 0x53, 0xC8, 0x04, 0x02, 0x01, 0x01, 0xBF,
  0x9E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xE7, 0x1B, 0x07, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x06,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC3,
  0xFF, 0x80, 0x01, 0x81, 0xC0, 0x40, 0x00, 0x03, 0xFC, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x1B, 0xF9, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xE0,
  0x28, 0x1A, 0x0C, 0x82, 0x21, 0x0F, 0xC2, 0x30, 0x86, 0x20, 0x88, 0x32,
  0x06, 0x80, 0xA0, 0x30, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x1F, 0xC0, 0xB9, 0xD9,
  0xCE, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x40, 0x9E, 0x51, 0xB0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x3E, 0x31,
  0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14,
  0x11, 0xF0, 0x9E, 0x71, 0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x38, 0x1C, 0x15, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00,
  0x3C, 0xB1, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x34, 0x19, 0xF4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x9F, 0x28,
  0x6C, 0x0B, 0x03, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x1F, 0x8C, 0x19, 0x01, 0x20, 0x14, 0x00, 0xC0,
  0x0F, 0x80, 0x3C, 0x00, 0x40, 0x0E, 0x01, 0xA0, 0x36, 0x04, 0x7F, 0x00,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0xF8, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x34, 0x11, 0xF0, 0x80, 0x38, 0x0D, 0x01, 0x20, 0x26, 0x0C,
  0x41, 0x08, 0x21, 0x8C, 0x11, 0x02, 0x20, 0x6C, 0x05, 0x00, 0xA0, 0x08,
  0x00, 0xC2, 0x0E, 0x10, 0xD1, 0x44, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x94,
  0x4D, 0x16, 0x28, 0xA1, 0x45, 0x0A, 0x28, 0x51, 0x42, 0x8A, 0x18, 0x30,
  0xC0, 0x68, 0x08, 0x82, 0x18, 0xC1, 0x10, 0x14, 0x03, 0x80, 0x70, 0x0A,
  0x02, 0x20, 0xC6, 0x10, 0x44, 0x05, 0x80, 0xC0, 0x80, 0x38, 0x0D, 0x01,
  0x30, 0x22, 0x0C, 0x41, 0x0C, 0x60, 0x88, 0x19, 0x01, 0x60, 0x28, 0x07,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x00, 0xFF,
  0x80, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08,
  0x08, 0x07, 0xFC, 0x01, 0xE0, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x7E, 0x0F, 0xC0, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x03, 0xF0, 0x7E, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x07, 0x80,
  0x78, 0x39, 0x86, 0x18, 0xC1, 0xE8, 0x08,
};

const GFXglyph JetBrainsMono_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 7, 15, 4, -18 },
  { 15, 13, 18, 15, 1, -18 },
  { 45, 11, 26, 15, 2, -22 },
  { 81, 15, 18, 15, 0, -18 },
  { 115, 12, 19, 15, 2, -19 },
  { 144, 1, 7, 15, 7, -18 },
  { 145, 7, 24, 15, 5, -21 },
  { 166, 7, 24, 15, 3, -21 },
  { 187, 13, 12, 15, 1, -15 },
  { 207, 11, 12, 15, 2, -14 },
  { 224, 4, 8, 15, 5, -4 },
  { 228, 9, 1, 15, 3, -9 },
  { 230, 3, 3, 15, 6, -3 },
  { 232, 11, 24, 15, 2, -21 },
  { 265, 11, 19, 15, 2, -19 },
  { 292, 11, 18, 15, 2, -18 },
  { 317, 11, 19, 15, 2, -19 },
  { 344, 10, 18, 15, 2, -18 },
  { 367, 10, 18, 15, 2, -18 },
  { 390, 11, 18, 15, 2, -18 },
  { 415, 11, 18, 15, 2, -18 },
  { 440, 11, 18, 15, 2, -18 },
  { 465, 11, 19, 15, 2, -19 },
  { 492, 11, 19, 15, 2, -19 },
  { 519, 3, 14, 15, 6, -14 },
  { 525, 4, 18, 15, 5, -14 },
  { 534, 11, 13, 15, 2, -15 },
  { 552, 11, 7, 15, 2, -12 },
  { 562, 11, 13, 15, 2, -15 },
  { 580, 9, 18, 15, 4, -18 },
  { 601, 12, 23, 15, 2, -19 },
  { 636, 11, 18, 15, 2, -18 },
  { 661, 10, 18, 15, 3, -18 },
  { 684, 10, 19, 15, 3, -19 },
  { 708, 9, 18, 15, 3, -18 },
  { 729, 10, 18, 15, 3, -18 },
  { 752, 10, 18, 15, 3, -18 },
  { 775, 10, 19, 15, 3, -19 },
  { 799, 9, 18, 15, 3, -18 },
  { 820, 9, 18, 15, 3, -18 },
  { 841, 10, 18, 15, 2, -18 },
  { 864, 11, 18, 15, 3, -18 },
  { 889, 10, 18, 15, 3, -18 },
  { 912, 11, 18, 15, 2, -18 },
  { 937, 9, 18, 15, 3, -18 },
  { 958, 9, 19, 15, 3, -19 },
  { 980, 10, 18, 15, 3, -18 },
  { 1003, 10, 24, 15, 3, -19 },
  { 1033, 10, 18, 15, 3, -18 },
  { 1056, 11, 19, 15, 2, -19 },
  { 1083, 13, 18, 15, 1, -18 },
  { 1113, 9, 18, 15, 3, -18 },
  { 1134, 11, 18, 15, 2, -18 },
  { 1159, 13, 18, 15, 1, -18 },
  { 1189, 13, 18, 15, 1, -18 },
  { 1219, 13, 18, 15, 1, -18 },
  { 1249, 11, 18, 15, 2, -18 },
  { 1274, 6, 24, 15, 5, -21 },
  { 1292, 11, 24, 15, 2, -21 },
  { 1325, 6, 24, 15, 4, -21 },
  { 1343, 11, 10, 15, 2, -18 },
  { 1357, 13, 1, 15, 1, 1 },
  { 1359, 4, 4, 15, 5, -20 },
  { 1361, 10, 14, 15, 2, -14 },
  { 1379, 9, 18, 15, 3, -18 },
  { 1400, 10, 14, 15, 3, -14 },
  { 1418, 9, 18, 15, 3, -18 },
  { 1439, 9, 14, 15, 3, -14 },
  { 1455, 11, 18, 15, 2, -18 },
  { 1480, 9, 19, 15, 3, -14 },
  { 1502, 9, 18, 15, 3, -18 },
  { 1523, 11, 19, 15, 2, -19 },
  { 1550, 9, 24, 15, 2, -19 },
  { 1577, 10, 18, 15, 3, -18 },
  { 1600, 13, 18, 15, 1, -18 },
  { 1630, 11, 14, 15, 2, -14 },
  { 1650, 9, 14, 15, 3, -14 },
  { 1666, 9, 14, 15, 3, -14 },
  { 1682, 9, 19, 15, 3, -14 },
  { 1704, 9, 19, 15, 3, -14 },
  { 1726, 10, 14, 15, 3, -14 },
  { 1744, 11, 14, 15, 2, -14 },
  { 1764, 11, 18, 15, 2, -18 },
  { 1789, 9, 14, 15, 3, -14 },
  { 1805, 11, 14, 15, 2, -14 },
  { 1825, 13, 14, 15, 1, -14 },
  { 1848, 11, 14, 15, 2, -14 },
  { 1868, 11, 19, 15, 2, -14 },
  { 1895, 9, 14, 15, 3, -14 },
  { 1911, 11, 24, 15, 2, -21 },
  { 1944, 1, 24, 15, 7, -21 },
  { 1947, 11, 24, 15, 2, -21 },
  { 1980, 11, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_Thin25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_THIN25PT7B_H_
