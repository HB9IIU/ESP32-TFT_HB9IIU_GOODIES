#ifndef _JETBRAINSMONO_THIN54PT7B_H_
#define _JETBRAINSMONO_THIN54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x71, 0xF7, 0xEF, 0xFF, 0x9F, 0x00,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xD8, 0x07, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38,
  0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38,
  0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x38, 0x07, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18,
  0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x78, 0xE3, 0xC1, 0xC1, 0xC3,
  0xC7, 0x83, 0x83, 0x8E, 0x07, 0x03, 0x9C, 0x0E, 0x07, 0x30, 0x1C, 0x0E,
  0x60, 0x38, 0x0C, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0xB8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0x3E, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0xF8, 0x07, 0x01, 0xF0, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0D,
  0xE0, 0x70, 0x39, 0xC0, 0xE0, 0xF1, 0xE1, 0xC3, 0xC1, 0xF3, 0x9F, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x73, 0xFF, 0x80, 0x01, 0x8E, 0x07, 0x00, 0x0C, 0x70, 0x1C, 0x00, 0x71,
  0x80, 0x30, 0x03, 0x86, 0x00, 0xC0, 0x0C, 0x18, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x03, 0x81, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03,
  0x03, 0x80, 0x60, 0x0C, 0x1C, 0x01, 0xC0, 0x30, 0x60, 0x07, 0x01, 0xC3,
  0x80, 0x0E, 0x0E, 0x1C, 0x00, 0x1F, 0xF8, 0x60, 0x00, 0x3F, 0x83, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x03, 0x0F, 0xF8, 0x00,
  0x18, 0x7D, 0xF0, 0x00, 0xE1, 0xC0, 0xE0, 0x03, 0x0E, 0x01, 0x80, 0x18,
  0x38, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x07, 0x03, 0x00, 0x70, 0x18, 0x0C,
  0x01, 0xC0, 0xE0, 0x30, 0x07, 0x07, 0x00, 0xC0, 0x1C, 0x18, 0x03, 0x00,
  0x70, 0xC0, 0x0C, 0x01, 0x87, 0x00, 0x38, 0x06, 0x18, 0x00, 0x60, 0x38,
  0xC0, 0x01, 0xC1, 0xC7, 0x00, 0x03, 0xFF, 0x38, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x3C, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x00,
  0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x78, 0x1E, 0x00, 0xEE, 0x03,
  0x80, 0x3B, 0x80, 0x70, 0x1C, 0xC0, 0x0E, 0x06, 0x30, 0x03, 0x83, 0x8C,
  0x00, 0x70, 0xC3, 0x00, 0x0E, 0x70, 0xC0, 0x01, 0xD8, 0x30, 0x00, 0x7E,
  0x0C, 0x00, 0x0F, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xF8, 0x30, 0x00,
  0x3E, 0x0E, 0x00, 0x1D, 0xC3, 0x80, 0x0E, 0x38, 0x70, 0x07, 0x07, 0x1E,
  0x07, 0x81, 0xC3, 0xFF, 0xC0, 0x38, 0x7F, 0xE0, 0x07, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x00, 0x0E, 0x00,
  0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x40, 0x07, 0x00, 0x27, 0x80, 0x70, 0x0F, 0xFE, 0x06, 0x07, 0xF3,
  0xFC, 0x61, 0xFE, 0x0F, 0xF6, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0x71, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xC0, 0x7E, 0x07, 0x81,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x8E, 0x00, 0x1E, 0x3C,
  0x00, 0xF0, 0x7E, 0x0F, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xEC, 0x00, 0x07, 0xCC,
  0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x78, 0x0C, 0x00, 0x70, 0x0C,
  0x00, 0x60, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0x70, 0x01, 0xC1, 0xE0, 0x3E, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71,
  0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC1, 0xFC, 0x07, 0x1F, 0xFC, 0x1C, 0xFF, 0xF8, 0x76, 0x01,
  0xF1, 0xF0, 0x01, 0xC7, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3,
  0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1F, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x1E, 0x00, 0x1D, 0xFF, 0x80, 0x77, 0xFF, 0xC0, 0xF8, 0x07, 0xC3, 0xE0,
  0x03, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xE0, 0x07, 0x81,
  0xF0, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x8F, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0xF0, 0x03, 0xC0, 0x70, 0x0E, 0x00,
  0x78, 0x38, 0x00, 0x78, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC3,
  0x80, 0x07, 0x83, 0xC0, 0x3E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0xF0,
  0x07, 0x83, 0xC0, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xC3,
  0xC0, 0x0F, 0x83, 0xE0, 0x76, 0x03, 0xFF, 0xDC, 0x01, 0xFE, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0x1F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0xFE, 0x01, 0xE0, 0x07,
  0x81, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC7, 0x80,
  0x3F, 0xF3, 0xC0, 0x1E, 0x1D, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x00, 0xF8,
  0x0E, 0x00, 0x7C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07,
  0x80, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00,
  0x78, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x07, 0xC0, 0x38, 0x03, 0xE0, 0x1E, 0x02, 0xF0, 0x07,
  0xEF, 0x78, 0x01, 0xFF, 0x3C, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x30, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x0E, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0x7C, 0x38,
  0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xE3, 0x80, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xE0, 0x03,
  0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x07, 0x38, 0x00, 0x78, 0xE0, 0x3F, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFD, 0xFC, 0x0F,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x78, 0x0F, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x38, 0x03, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x38, 0x00, 0x71, 0xC0, 0x0F, 0x8E, 0x07, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFD, 0xFC, 0x0F,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x78, 0x0F, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80, 0x07,
  0x0F, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFD, 0x80, 0x07, 0xF6, 0x00, 0x1B, 0xCC, 0x00, 0x6F, 0x30, 0x03, 0x3C,
  0xE0, 0x0C, 0xF9, 0x80, 0x33, 0xE6, 0x01, 0x8F, 0x9C, 0x06, 0x3E, 0x30,
  0x38, 0xF8, 0xC0, 0xC3, 0xE1, 0x83, 0x0F, 0x86, 0x1C, 0x3E, 0x18, 0x60,
  0xF8, 0x31, 0x83, 0xE0, 0xCC, 0x0F, 0x83, 0xB0, 0x3E, 0x06, 0xC0, 0xF8,
  0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3D, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xC0, 0x03, 0xEC, 0x00,
  0x3E, 0xE0, 0x03, 0xE6, 0x00, 0x3E, 0x70, 0x03, 0xE3, 0x00, 0x3E, 0x30,
  0x03, 0xE3, 0x80, 0x3E, 0x18, 0x03, 0xE1, 0xC0, 0x3E, 0x0C, 0x03, 0xE0,
  0xC0, 0x3E, 0x0E, 0x03, 0xE0, 0x60, 0x3E, 0x07, 0x03, 0xE0, 0x70, 0x3E,
  0x03, 0x03, 0xE0, 0x38, 0x3E, 0x01, 0x83, 0xE0, 0x1C, 0x3E, 0x01, 0xC3,
  0xE0, 0x0C, 0x3E, 0x00, 0xE3, 0xE0, 0x06, 0x3E, 0x00, 0x63, 0xE0, 0x07,
  0x3E, 0x00, 0x33, 0xE0, 0x03, 0xBE, 0x00, 0x1B, 0xE0, 0x01, 0xBE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xE7, 0xE0, 0x78, 0x03, 0x87, 0x80, 0x0E, 0x38, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x37,
  0x00, 0x03, 0x98, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x80, 0x1E, 0x1F, 0x01,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0x80, 0x07, 0xC7, 0x00, 0x03, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0xF3, 0x80, 0x07, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFD, 0xF8, 0x0F, 0x00,
  0xF0, 0x78, 0x00, 0xE1, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00,
  0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B,
  0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0xEC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xC6,
  0x00, 0x07, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xF8, 0x0F, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x27, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0x80, 0x0F, 0x87, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3,
  0x80, 0x1F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0xF0, 0x07,
  0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x60, 0x00, 0x1C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE3, 0xC0, 0x07, 0x83,
  0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x38, 0x70, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xB8, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x06, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x07, 0x00,
  0x0E, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07,
  0x60, 0x0F, 0x00, 0x76, 0x00, 0xD8, 0x07, 0x60, 0x0D, 0x80, 0x76, 0x00,
  0xD8, 0x07, 0x70, 0x0D, 0x80, 0x67, 0x01, 0xD8, 0x06, 0x70, 0x19, 0x80,
  0x67, 0x01, 0x98, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x01, 0x8C, 0x0E, 0x30,
  0x18, 0xC0, 0xE3, 0x01, 0x8C, 0x0E, 0x38, 0x38, 0xC0, 0xC3, 0x83, 0x0C,
  0x0C, 0x38, 0x30, 0xC0, 0xC3, 0x83, 0x0E, 0x0C, 0x38, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x1C, 0x18, 0x30, 0x61, 0xC1, 0x86, 0x06, 0x1C, 0x1C, 0x60,
  0x61, 0x81, 0xC6, 0x06, 0x18, 0x1C, 0x60, 0x71, 0x81, 0xC6, 0x03, 0x18,
  0x1C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x80, 0xCC,
  0x03, 0x38, 0x0E, 0xC0, 0x33, 0x00, 0xEC, 0x03, 0x30, 0x0E, 0xC0, 0x1B,
  0x00, 0xEC, 0x01, 0xB0, 0x0E, 0x80, 0x1B, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x01, 0xEC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01,
  0x80, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x18,
  0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0x87, 0xC0,
  0x78, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xB8, 0xF0, 0x0F, 0x70,
  0xFF, 0xFC, 0xE0, 0xFF, 0xE1, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x0F, 0xF0, 0x39,
  0xFF, 0xE1, 0xDE, 0x0F, 0x8F, 0xC0, 0x1E, 0x78, 0x00, 0x73, 0xC0, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x77,
  0x80, 0x03, 0xBC, 0x00, 0x39, 0xF0, 0x03, 0xCE, 0xE0, 0x3C, 0x73, 0xFF,
  0xC3, 0x8F, 0xFC, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xC1, 0xF0, 0x78, 0x03, 0xC7, 0x00, 0x0F, 0x38, 0x00, 0x3B, 0x80, 0x00,
  0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x73,
  0x80, 0x03, 0x8E, 0x00, 0x38, 0x7C, 0x07, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x3F, 0x83, 0x0F, 0xFE, 0x31, 0xE0, 0x73, 0x38, 0x01,
  0xB7, 0x00, 0x0F, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x1B, 0x3C, 0x03,
  0xB1, 0xFF, 0xF3, 0x07, 0xFC, 0x30, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xC1, 0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x78, 0x7C, 0x07, 0x81, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF8, 0x30, 0xFF, 0xE3, 0x1E, 0x07, 0x33, 0x80,
  0x1B, 0x70, 0x00, 0xF7, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00,
  0xF7, 0x80, 0x0B, 0x3C, 0x03, 0xB1, 0xFF, 0xF3, 0x0F, 0xFE, 0x30, 0x1F,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x0F, 0xF0, 0x39, 0xFF, 0xE1,
  0xDE, 0x0F, 0x8F, 0xC0, 0x1E, 0x7C, 0x00, 0x73, 0xC0, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0xF7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x80,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xE7, 0xE0, 0xF8, 0xEF, 0xF1,
  0xFE, 0xF8, 0x7B, 0x1E, 0xF0, 0x3A, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C,
  0x07, 0xE1, 0xFE, 0x07, 0x3F, 0xFC, 0x3B, 0xC1, 0xF1, 0xF8, 0x03, 0xCF,
  0x80, 0x0E, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xC1, 0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0x60,
  0x00, 0x73, 0x80, 0x07, 0x0E, 0x00, 0x78, 0x7C, 0x07, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xE1, 0xFE, 0x07, 0x3F, 0xFC, 0x3B,
  0xC1, 0xF1, 0xF8, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x80, 0x07, 0x3E, 0x00, 0x79, 0xDC, 0x07, 0x8E, 0x7F, 0xF8, 0x71, 0xFF,
  0x83, 0x80, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xF8, 0x30, 0xFF, 0xE3, 0x1E, 0x07, 0x33, 0x80,
  0x1B, 0x70, 0x00, 0xF7, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0F, 0x78, 0x01, 0xB3, 0xE0,
  0x3B, 0x1F, 0xFF, 0x30, 0x7F, 0xC3, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE1, 0xFE, 0x07, 0x3F, 0xFC,
  0x3B, 0xC1, 0xF1, 0xF8, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xF0, 0x1F, 0x0F, 0x00,
  0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0x80, 0x03, 0x8F, 0x80, 0x3E, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x07, 0x0E, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0xE3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x0E,
  0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x80, 0x78, 0x03, 0x70, 0x0F, 0x00, 0x6E,
  0x01, 0xA0, 0x1C, 0xC0, 0x36, 0x03, 0x98, 0x06, 0xC0, 0x73, 0x01, 0x98,
  0x0C, 0x70, 0x33, 0x01, 0x8E, 0x06, 0x60, 0x31, 0xC0, 0xC6, 0x0E, 0x18,
  0x18, 0xC1, 0xC3, 0x03, 0x18, 0x38, 0x60, 0xC3, 0x06, 0x0E, 0x18, 0x60,
  0xC1, 0xC3, 0x0E, 0x18, 0x38, 0x60, 0xC7, 0x03, 0x0C, 0x18, 0xE0, 0x63,
  0x03, 0x1C, 0x0C, 0x60, 0x63, 0x01, 0xCC, 0x0E, 0x60, 0x39, 0x80, 0xCC,
  0x07, 0x30, 0x1B, 0x80, 0x6C, 0x03, 0x70, 0x0D, 0x80, 0x6E, 0x01, 0xB0,
  0x0D, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0xE7, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7,
  0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x63, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x0E, 0xFF, 0x80,
  0x1F, 0xC7, 0x80, 0x3F, 0x07, 0x80, 0x7C, 0x07, 0x00, 0xF8, 0x07, 0x01,
  0xF0, 0x07, 0x03, 0x60, 0x07, 0x9E, 0xC0, 0x07, 0xF9, 0x80, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 7, 39, 32, 13, -39 },
  { 36, 14, 16, 32, 9, -39 },
  { 64, 29, 39, 32, 2, -39 },
  { 206, 23, 55, 32, 5, -47 },
  { 365, 30, 40, 32, 1, -40 },
  { 515, 26, 41, 32, 4, -40 },
  { 649, 4, 16, 32, 14, -39 },
  { 657, 15, 51, 32, 11, -45 },
  { 753, 15, 51, 32, 6, -45 },
  { 849, 28, 27, 32, 2, -33 },
  { 944, 24, 26, 32, 4, -31 },
  { 1022, 9, 17, 32, 10, -8 },
  { 1042, 17, 2, 32, 8, -19 },
  { 1047, 8, 8, 32, 12, -7 },
  { 1055, 22, 51, 32, 5, -45 },
  { 1196, 22, 41, 32, 5, -40 },
  { 1309, 24, 39, 32, 5, -39 },
  { 1426, 24, 40, 32, 5, -40 },
  { 1546, 21, 40, 32, 5, -39 },
  { 1651, 21, 39, 32, 5, -39 },
  { 1754, 22, 40, 32, 5, -39 },
  { 1864, 23, 40, 32, 5, -39 },
  { 1979, 23, 39, 32, 5, -39 },
  { 2092, 23, 41, 32, 5, -40 },
  { 2210, 23, 40, 32, 5, -40 },
  { 2325, 8, 31, 32, 12, -30 },
  { 2356, 10, 39, 32, 10, -30 },
  { 2405, 23, 27, 32, 5, -31 },
  { 2483, 22, 14, 32, 5, -25 },
  { 2522, 23, 27, 32, 5, -31 },
  { 2600, 18, 39, 32, 9, -39 },
  { 2688, 25, 50, 32, 4, -40 },
  { 2845, 25, 39, 32, 4, -39 },
  { 2967, 22, 39, 32, 6, -39 },
  { 3075, 22, 41, 32, 6, -40 },
  { 3188, 21, 39, 32, 6, -39 },
  { 3291, 22, 39, 32, 6, -39 },
  { 3399, 22, 39, 32, 6, -39 },
  { 3507, 22, 41, 32, 6, -40 },
  { 3620, 20, 39, 32, 6, -39 },
  { 3718, 20, 39, 32, 6, -39 },
  { 3816, 22, 40, 32, 4, -39 },
  { 3926, 23, 39, 32, 6, -39 },
  { 4039, 22, 39, 32, 6, -39 },
  { 4147, 22, 39, 32, 5, -39 },
  { 4255, 20, 39, 32, 6, -39 },
  { 4353, 21, 41, 32, 6, -40 },
  { 4461, 23, 39, 32, 6, -39 },
  { 4574, 22, 50, 32, 6, -40 },
  { 4712, 23, 39, 32, 6, -39 },
  { 4825, 23, 41, 32, 5, -40 },
  { 4943, 26, 39, 32, 3, -39 },
  { 5070, 21, 40, 32, 6, -39 },
  { 5175, 25, 39, 32, 4, -39 },
  { 5297, 28, 39, 32, 2, -39 },
  { 5434, 27, 39, 32, 3, -39 },
  { 5566, 27, 39, 32, 3, -39 },
  { 5698, 22, 39, 32, 5, -39 },
  { 5806, 12, 51, 32, 12, -45 },
  { 5883, 22, 51, 32, 5, -45 },
  { 6024, 13, 51, 32, 8, -45 },
  { 6107, 22, 21, 32, 5, -39 },
  { 6165, 26, 3, 32, 3, 1 },
  { 6175, 9, 7, 32, 11, -42 },
  { 6183, 23, 31, 32, 4, -30 },
  { 6273, 21, 40, 32, 6, -39 },
  { 6378, 21, 31, 32, 6, -30 },
  { 6460, 20, 40, 32, 6, -39 },
  { 6560, 21, 31, 32, 6, -30 },
  { 6642, 24, 39, 32, 4, -39 },
  { 6759, 20, 40, 32, 6, -30 },
  { 6859, 21, 39, 32, 6, -39 },
  { 6962, 24, 41, 32, 5, -41 },
  { 7085, 19, 51, 32, 5, -41 },
  { 7207, 23, 39, 32, 6, -39 },
  { 7320, 26, 39, 32, 3, -39 },
  { 7447, 24, 30, 32, 4, -30 },
  { 7537, 21, 30, 32, 6, -30 },
  { 7616, 21, 31, 32, 6, -30 },
  { 7698, 21, 40, 32, 6, -30 },
  { 7803, 20, 40, 32, 6, -30 },
  { 7903, 21, 30, 32, 7, -30 },
  { 7982, 22, 31, 32, 5, -30 },
  { 8068, 23, 38, 32, 4, -38 },
  { 8178, 21, 31, 32, 6, -30 },
  { 8260, 24, 30, 32, 4, -30 },
  { 8350, 27, 30, 32, 3, -30 },
  { 8452, 24, 30, 32, 4, -30 },
  { 8542, 24, 40, 32, 4, -30 },
  { 8662, 21, 30, 32, 6, -30 },
  { 8741, 22, 51, 32, 5, -45 },
  { 8882, 3, 51, 32, 15, -45 },
  { 8902, 22, 51, 32, 5, -45 },
  { 9043, 23, 10, 32, 5, -24 },
};

const GFXfont JetBrainsMono_Thin54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_THIN54PT7B_H_
