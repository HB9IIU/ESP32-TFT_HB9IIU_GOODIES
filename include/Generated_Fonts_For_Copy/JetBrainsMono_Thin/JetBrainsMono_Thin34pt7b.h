#ifndef _JETBRAINSMONO_THIN34PT7B_H_
#define _JETBRAINSMONO_THIN34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x22, 0x22, 0x00, 0x02,
  0xFF, 0x70, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x80, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03,
  0x02, 0x00, 0x80, 0x80, 0x20, 0x21, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0x81,
  0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x30, 0x20, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x10, 0x04, 0x04, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x01, 0xFC, 0x0F, 0x7C,
  0x18, 0x8C, 0x61, 0x0C, 0xC2, 0x19, 0x04, 0x32, 0x08, 0x04, 0x10, 0x0C,
  0x20, 0x1C, 0x40, 0x1C, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x05, 0xC0, 0x08,
  0xC0, 0x10, 0xC0, 0x21, 0x80, 0x41, 0x00, 0x82, 0xC1, 0x07, 0x82, 0x0B,
  0x04, 0x33, 0x08, 0xE3, 0x97, 0x83, 0xFC, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x6E, 0xE0, 0x1B, 0x04, 0x02,
  0x60, 0xC0, 0x8C, 0x18, 0x31, 0x83, 0x0C, 0x30, 0x61, 0x06, 0x0C, 0x60,
  0xC1, 0x98, 0x0C, 0x62, 0x00, 0xF8, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x67, 0xE0, 0x19, 0xCE, 0x02, 0x20, 0xC0, 0xC4, 0x08,
  0x30, 0x81, 0x04, 0x10, 0x21, 0x02, 0x04, 0x60, 0x40, 0x98, 0x0C, 0x32,
  0x01, 0xCC, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0x38, 0x06, 0x0E, 0x06,
  0x03, 0x03, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x06, 0x30, 0x0B, 0x1C, 0x1B, 0x06,
  0x0D, 0x81, 0x8C, 0xC0, 0x66, 0x60, 0x16, 0x30, 0x0F, 0x18, 0x03, 0x0C,
  0x01, 0xC6, 0x01, 0xA1, 0x81, 0x98, 0xE3, 0x86, 0x3F, 0x81, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0x80, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x00, 0x80, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0xE1, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x30, 0x17, 0x0C, 0x1F, 0xF9, 0x3E,
  0x0F, 0x7C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01,
  0x86, 0x00, 0xE0, 0xC0, 0x30, 0x38, 0x18, 0x06, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x7F, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x63, 0x8E, 0x30, 0xC6, 0x18, 0x63,
  0x00, 0xFF, 0xFF, 0xFC, 0x67, 0xBF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0xE3, 0xC7, 0x8F, 0x0E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x77, 0x01, 0x8F, 0x3C, 0x1F, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x36, 0x01, 0xCC, 0x07, 0x18, 0x08, 0x30, 0x20,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xE0, 0x79, 0xE1, 0x80, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xB0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xC0, 0x09, 0x00,
  0x66, 0x03, 0x8E, 0x1C, 0x1F, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x11, 0x00, 0x98, 0x05, 0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00, 0x7F,
  0xFE, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x7F,
  0xF9, 0xFF, 0xE6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x9F, 0x87, 0x87, 0x1C, 0x06, 0x60, 0x09, 0x80, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x40, 0x0D,
  0x80, 0x66, 0x01, 0x8E, 0x1C, 0x1F, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xDF, 0x01, 0x7F, 0x87, 0x03, 0x8C, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x16, 0x00, 0x2C, 0x00, 0xCC, 0x01,
  0x98, 0x06, 0x1E, 0x38, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x73, 0xC3, 0x01, 0x98, 0x03,
  0x60, 0x0D, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x60, 0x08, 0xC0, 0x61, 0xC6,
  0x01, 0xF0, 0x07, 0x80, 0x73, 0x83, 0x03, 0x18, 0x06, 0x40, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x36, 0x01, 0x8E, 0x1E, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7D, 0xE1, 0xC0, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0xB0, 0x01, 0x60, 0x03, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x33, 0x00, 0x67,
  0x01, 0x87, 0x9F, 0x03, 0xE4, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x77, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9E, 0xFF, 0xFC,
  0x3C, 0x7C, 0xF9, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0C, 0x38, 0x70, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0x00, 0x04, 0x00,
  0x30, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x00, 0xFC, 0x1F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0xE3, 0xF0, 0x78, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1E, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0xF0, 0x0F, 0x1E, 0x0E, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x19, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x7E, 0xF0, 0x61, 0xF8,
  0x20, 0x7C, 0x30, 0x1E, 0x18, 0x0F, 0x0C, 0x07, 0x86, 0x03, 0xC3, 0x01,
  0xE1, 0x80, 0xF0, 0xC0, 0x78, 0x60, 0x3C, 0x18, 0x3E, 0x0F, 0x6F, 0x03,
  0xE7, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x30,
  0x04, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x18, 0x08, 0x1F, 0xFC, 0x3F, 0xFC, 0x30, 0x04, 0x20, 0x06, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x88,
  0x07, 0x20, 0x0C, 0x80, 0x1A, 0x00, 0x68, 0x01, 0xA0, 0x06, 0x80, 0x1A,
  0x00, 0xC8, 0x03, 0x3F, 0xF8, 0xFF, 0xC2, 0x01, 0xC8, 0x03, 0xA0, 0x06,
  0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x1A, 0x00, 0x68, 0x03,
  0x3F, 0xF8, 0xFF, 0x80, 0x1F, 0xC1, 0xEF, 0x18, 0x0D, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x1C, 0x01, 0xE0, 0x0D, 0x80, 0xCF, 0x1C, 0x1F, 0xC0, 0xFF, 0x07, 0xFE,
  0x20, 0x39, 0x00, 0x68, 0x03, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x40, 0x1A, 0x01, 0x9F, 0xF8,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xEF, 0xFF, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x1F, 0xC1, 0xEF, 0x18, 0x0D, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x41, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x01, 0xE0, 0x0D, 0x80, 0xCF, 0x1C, 0x1F, 0xC0, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x40, 0x0D, 0x80, 0x37, 0x01, 0x8F, 0x1C, 0x0F, 0xE0, 0x80,
  0x0E, 0x00, 0x68, 0x01, 0xA0, 0x0C, 0x80, 0x32, 0x00, 0x88, 0x06, 0x20,
  0x10, 0x80, 0xC2, 0x02, 0x08, 0x18, 0x3F, 0xC0, 0xFF, 0x02, 0x06, 0x08,
  0x18, 0x20, 0x30, 0x80, 0xC2, 0x01, 0x88, 0x06, 0x20, 0x0C, 0x80, 0x32,
  0x00, 0x68, 0x01, 0xA0, 0x03, 0x80, 0x0C, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0x7C, 0x05, 0xD0, 0x37,
  0x60, 0x9C, 0x86, 0x72, 0x11, 0xCC, 0x47, 0x13, 0x1C, 0x48, 0x71, 0xA1,
  0xC3, 0x87, 0x0C, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x04, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0x40, 0x3B, 0x01, 0xC8, 0x0E, 0x60, 0x73, 0x03,
  0x88, 0x1C, 0x60, 0xE1, 0x07, 0x0C, 0x38, 0x61, 0xC1, 0x0E, 0x0C, 0x70,
  0x23, 0x81, 0x9C, 0x0C, 0xE0, 0x27, 0x01, 0xB8, 0x05, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x38, 0x1F, 0x81, 0xCF, 0x18, 0x0D, 0x80, 0x6C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x19, 0x80, 0xCE, 0x1C, 0x1F, 0xC0, 0xFF, 0x83, 0xFF,
  0xC8, 0x03, 0xA0, 0x06, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xA0, 0x0E, 0xFF, 0xF3, 0xFF, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x1F, 0x81, 0xCF, 0x18, 0x0D, 0x80, 0x6C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x19, 0x80, 0xCE, 0x1C, 0x1F, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0xFF, 0x83, 0xFF, 0x88,
  0x03, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x28, 0x01, 0xA0, 0x0C, 0xFF, 0xE3, 0xFE, 0x08, 0x18, 0x20, 0x60,
  0x80, 0xC2, 0x03, 0x08, 0x06, 0x20, 0x18, 0x80, 0x32, 0x00, 0xC8, 0x01,
  0xA0, 0x06, 0x80, 0x0C, 0x0F, 0xE0, 0x79, 0xE0, 0xC0, 0x63, 0x00, 0x64,
  0x00, 0xC8, 0x01, 0x90, 0x00, 0x20, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x58, 0x01, 0x98, 0x07, 0x1C,
  0x1C, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x19, 0x80, 0xCE, 0x1C, 0x1F, 0xC0, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x02, 0x60, 0x02, 0x60, 0x06, 0x30, 0x06, 0x30, 0x04,
  0x30, 0x0C, 0x10, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x08, 0x18,
  0x0C, 0x10, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x60,
  0x02, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0xC0, 0xC0, 0xD0, 0x38, 0x34, 0x0E, 0x0D, 0x02, 0x83, 0x40, 0xA0, 0xD8,
  0x68, 0x26, 0x1A, 0x09, 0x84, 0x82, 0x61, 0x31, 0x88, 0x4C, 0x62, 0x13,
  0x18, 0x84, 0x46, 0x23, 0x11, 0x8C, 0xC4, 0x43, 0x21, 0x10, 0xC8, 0x44,
  0x32, 0x19, 0x0C, 0x86, 0xC1, 0x20, 0xB0, 0x58, 0x2C, 0x14, 0x0B, 0x07,
  0x02, 0x81, 0xC0, 0xA0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0xC0, 0x03, 0x30,
  0x03, 0x08, 0x01, 0x86, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x30, 0x40,
  0x08, 0x60, 0x06, 0x20, 0x01, 0x30, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0D, 0x80, 0x0C, 0x40, 0x04, 0x30, 0x06, 0x08, 0x06,
  0x06, 0x03, 0x01, 0x03, 0x00, 0xC1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x06,
  0xC0, 0x03, 0x80, 0xC0, 0x01, 0xE0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x60, 0x60, 0x30, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x18,
  0x01, 0x8C, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xB0,
  0x0C, 0xC0, 0x31, 0x80, 0x86, 0x06, 0x08, 0x18, 0x30, 0xC0, 0xC3, 0x01,
  0x98, 0x06, 0xE0, 0x0C, 0xFF, 0xFF, 0xC1, 0x83, 0x0C, 0x1C, 0x0F, 0xC0,
  0x7F, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x07, 0xFC, 0xFF, 0xF6, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xE0, 0x1D, 0xC1, 0xB3, 0xFC, 0xC0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x3E, 0x17, 0xBC, 0xA0, 0x76, 0x01,
  0xB0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1A, 0x80, 0xD6, 0x1C, 0x9F,
  0xC0, 0x1F, 0x81, 0xFF, 0x18, 0x0D, 0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0F,
  0x00, 0x78, 0x03, 0x60, 0x33, 0xC7, 0x07, 0xF0, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x7C, 0x67, 0xBB, 0x60, 0x7E, 0x01,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1D, 0x80, 0xEE, 0x1B, 0x3F,
  0x98, 0x1F, 0x81, 0xEF, 0x18, 0x1D, 0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x78, 0x02, 0x60, 0x33, 0x87, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x1F, 0x19,
  0xEE, 0xD8, 0x1F, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x00, 0xEC, 0x0B,
  0x3F, 0x98, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x3C, 0x3F, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x3E, 0x13, 0xBC, 0xA0, 0x76, 0x01, 0xB0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x07, 0xCF, 0xF0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x06, 0xC0,
  0x33, 0x00, 0xCC, 0x06, 0x30, 0x30, 0xC1, 0xC3, 0x06, 0x0F, 0xF0, 0x3F,
  0xC0, 0xC3, 0x03, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x00, 0xCC,
  0x03, 0x30, 0x06, 0xC0, 0x0C, 0xFE, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x9C, 0x79, 0x5D, 0xBB, 0x0E,
  0x16, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07,
  0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC1, 0xC1,
  0x83, 0x83, 0x07, 0x06, 0x0E, 0x0C, 0x18, 0x8F, 0x84, 0xEF, 0x28, 0x1D,
  0x80, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x1F, 0x81, 0xFF, 0x18, 0x1D, 0x80, 0x6C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x06, 0x60, 0x33, 0x87, 0x07, 0xF0, 0x8F, 0x85, 0xEF,
  0x28, 0x1D, 0x80, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x06, 0xA0,
  0x35, 0x87, 0x27, 0xF1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x00, 0x1F, 0x19, 0xEE, 0xD8, 0x1F, 0x80, 0x7C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x07, 0x60, 0x3B, 0x86, 0xCF, 0xE6, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xC7, 0xC3, 0x77, 0xCF, 0x03,
  0x38, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0xF3, 0xE6, 0x01, 0x98, 0x03,
  0x40, 0x0D, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x60, 0x0C, 0xC0,
  0xE1, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x06, 0x60, 0x33, 0x87, 0x07, 0xF0, 0x80, 0x07, 0x80, 0x0B, 0x00,
  0x32, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x08, 0x06, 0x18, 0x08, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC6, 0x01, 0x88, 0x01, 0x30, 0x03,
  0x40, 0x06, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x81, 0x81, 0xE0, 0xC0, 0xF0,
  0x70, 0x58, 0x28, 0x2C, 0x14, 0x32, 0x1A, 0x19, 0x09, 0x0C, 0xC4, 0x84,
  0x62, 0x62, 0x31, 0x11, 0x19, 0x89, 0x84, 0xC4, 0xC2, 0x42, 0x61, 0xA1,
  0xA0, 0xD0, 0xD0, 0x78, 0x28, 0x3C, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x00,
  0xC0, 0x0C, 0xC0, 0x19, 0x80, 0x61, 0x81, 0x81, 0x83, 0x01, 0x0C, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x36, 0x00, 0xC4,
  0x03, 0x0C, 0x06, 0x0C, 0x18, 0x08, 0x60, 0x18, 0xC0, 0x1B, 0x00, 0x18,
  0xC0, 0x07, 0x80, 0x0B, 0x00, 0x33, 0x00, 0x66, 0x01, 0x86, 0x03, 0x0C,
  0x04, 0x18, 0x18, 0x18, 0x30, 0x30, 0x40, 0x21, 0x80, 0x63, 0x00, 0xCC,
  0x00, 0xD8, 0x01, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x03,
  0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x3F,
  0x80, 0xFF, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x7F, 0x03, 0xFC, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x38, 0x0F, 0xC0, 0x3C, 0x00, 0x7C, 0x07, 0xDC,
  0x0F, 0x0C, 0x1C, 0x0C, 0x28, 0x0C, 0xD0, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 25, 20, 8, -25 },
  { 14, 9, 10, 20, 6, -25 },
  { 26, 18, 25, 20, 1, -25 },
  { 83, 15, 35, 20, 3, -30 },
  { 149, 19, 25, 20, 1, -25 },
  { 209, 17, 25, 20, 2, -25 },
  { 263, 2, 10, 20, 9, -25 },
  { 266, 9, 33, 20, 7, -29 },
  { 304, 9, 33, 20, 4, -29 },
  { 342, 18, 18, 20, 1, -21 },
  { 383, 15, 16, 20, 3, -19 },
  { 413, 6, 10, 20, 6, -5 },
  { 421, 11, 2, 20, 5, -12 },
  { 424, 5, 5, 20, 8, -5 },
  { 428, 14, 32, 20, 3, -28 },
  { 484, 14, 25, 20, 3, -25 },
  { 528, 15, 25, 20, 3, -25 },
  { 575, 15, 25, 20, 3, -25 },
  { 622, 14, 25, 20, 3, -25 },
  { 666, 13, 25, 20, 3, -25 },
  { 707, 14, 25, 20, 3, -25 },
  { 751, 15, 25, 20, 3, -25 },
  { 798, 15, 25, 20, 3, -25 },
  { 845, 14, 25, 20, 3, -25 },
  { 889, 15, 25, 20, 3, -25 },
  { 936, 5, 19, 20, 8, -19 },
  { 948, 7, 24, 20, 6, -19 },
  { 969, 14, 17, 20, 3, -20 },
  { 999, 14, 9, 20, 3, -16 },
  { 1015, 14, 17, 20, 3, -20 },
  { 1045, 11, 25, 20, 6, -25 },
  { 1080, 17, 31, 20, 2, -25 },
  { 1146, 16, 25, 20, 2, -25 },
  { 1196, 14, 25, 20, 4, -25 },
  { 1240, 13, 25, 20, 4, -25 },
  { 1281, 13, 25, 20, 4, -25 },
  { 1322, 13, 25, 20, 4, -25 },
  { 1363, 14, 25, 20, 4, -25 },
  { 1407, 13, 25, 20, 4, -25 },
  { 1448, 13, 25, 20, 4, -25 },
  { 1489, 12, 25, 20, 4, -25 },
  { 1527, 14, 25, 20, 2, -25 },
  { 1571, 14, 25, 20, 4, -25 },
  { 1615, 14, 25, 20, 4, -25 },
  { 1659, 14, 25, 20, 3, -25 },
  { 1703, 13, 25, 20, 4, -25 },
  { 1744, 13, 25, 20, 4, -25 },
  { 1785, 14, 25, 20, 4, -25 },
  { 1829, 13, 31, 20, 4, -25 },
  { 1880, 14, 25, 20, 4, -25 },
  { 1924, 15, 25, 20, 3, -25 },
  { 1971, 16, 25, 20, 2, -25 },
  { 2021, 13, 25, 20, 4, -25 },
  { 2062, 16, 25, 20, 2, -25 },
  { 2112, 18, 25, 20, 1, -25 },
  { 2169, 17, 25, 20, 2, -25 },
  { 2223, 17, 25, 20, 2, -25 },
  { 2277, 14, 25, 20, 3, -25 },
  { 2321, 8, 32, 20, 7, -28 },
  { 2353, 14, 32, 20, 3, -28 },
  { 2409, 8, 32, 20, 5, -28 },
  { 2441, 14, 13, 20, 3, -25 },
  { 2464, 16, 1, 20, 2, 1 },
  { 2466, 6, 5, 20, 7, -27 },
  { 2470, 14, 19, 20, 3, -19 },
  { 2504, 13, 25, 20, 4, -25 },
  { 2545, 13, 19, 20, 4, -19 },
  { 2576, 13, 25, 20, 4, -25 },
  { 2617, 13, 19, 20, 4, -19 },
  { 2648, 16, 25, 20, 2, -25 },
  { 2698, 13, 25, 20, 4, -19 },
  { 2739, 13, 25, 20, 4, -25 },
  { 2780, 15, 26, 20, 3, -26 },
  { 2829, 12, 32, 20, 3, -26 },
  { 2877, 14, 25, 20, 4, -25 },
  { 2921, 16, 25, 20, 2, -25 },
  { 2971, 15, 19, 20, 3, -19 },
  { 3007, 13, 19, 20, 4, -19 },
  { 3038, 13, 19, 20, 4, -19 },
  { 3069, 13, 25, 20, 4, -19 },
  { 3110, 13, 25, 20, 4, -19 },
  { 3151, 14, 19, 20, 4, -19 },
  { 3185, 14, 19, 20, 3, -19 },
  { 3219, 15, 24, 20, 2, -24 },
  { 3264, 13, 19, 20, 4, -19 },
  { 3295, 15, 19, 20, 3, -19 },
  { 3331, 17, 19, 20, 2, -19 },
  { 3372, 15, 19, 20, 3, -19 },
  { 3408, 15, 25, 20, 3, -19 },
  { 3455, 14, 19, 20, 3, -19 },
  { 3489, 14, 32, 20, 3, -28 },
  { 3545, 2, 32, 20, 9, -28 },
  { 3553, 14, 32, 20, 3, -28 },
  { 3609, 15, 6, 20, 3, -15 },
};

const GFXfont JetBrainsMono_Thin34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_THIN34PT7B_H_
