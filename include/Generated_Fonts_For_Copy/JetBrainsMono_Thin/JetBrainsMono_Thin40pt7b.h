#ifndef _JETBRAINSMONO_THIN40PT7B_H_
#define _JETBRAINSMONO_THIN40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x00, 0x0F, 0xFF, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x20, 0x18, 0x01, 0x80, 0x40, 0x06, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x08, 0x06, 0x00, 0x60, 0x18,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x08, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x7B, 0x78, 0x38, 0xC7, 0x0C,
  0x30, 0xC7, 0x0C, 0x19, 0x83, 0x06, 0x60, 0xC1, 0x98, 0x30, 0x07, 0x0C,
  0x00, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x37, 0x80, 0x0C, 0x70, 0x03, 0x0C, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x0C, 0x18, 0x03, 0x03, 0xC0, 0xC0, 0xD8, 0x30, 0x66, 0x0C,
  0x19, 0xC3, 0x0E, 0x38, 0xC7, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x80, 0x0D, 0xC6, 0x00, 0x66, 0x0C, 0x03, 0x30, 0x10, 0x0C, 0xC0,
  0x40, 0x63, 0x01, 0x03, 0x0C, 0x04, 0x08, 0x30, 0x10, 0x60, 0xC0, 0x43,
  0x01, 0x03, 0x08, 0x06, 0x0C, 0x60, 0x0F, 0xE3, 0x00, 0x1F, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x43, 0xE0, 0x03,
  0x1F, 0xE0, 0x18, 0xC1, 0x80, 0xC3, 0x02, 0x03, 0x08, 0x0C, 0x18, 0x20,
  0x30, 0xC0, 0x80, 0xC2, 0x02, 0x03, 0x18, 0x08, 0x0C, 0xC0, 0x30, 0x22,
  0x00, 0xC1, 0x98, 0x01, 0xDE, 0xC0, 0x03, 0xE0, 0x00, 0x80, 0x00, 0xFE,
  0x00, 0x78, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0x1C, 0x01, 0xC1, 0x80,
  0xD8, 0x18, 0x1B, 0x01, 0x86, 0x60, 0x38, 0xCC, 0x03, 0x31, 0x80, 0x36,
  0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0E, 0x18, 0x03, 0xE3, 0x00, 0xE6,
  0x70, 0x38, 0xE7, 0xDE, 0x0C, 0x7F, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0x20, 0x1C, 0x0F, 0x83, 0xC0, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x08, 0x80, 0x1C, 0x03, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xE0, 0x60, 0x7F, 0x86, 0x1F, 0x3F, 0x6F, 0xC0, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x0C,
  0x00, 0x70, 0xE0, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x80, 0x80,
  0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3C, 0xF3, 0x8E, 0x71,
  0xC7, 0x18, 0x63, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0x21, 0xEF, 0xFF, 0xFD,
  0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0x7C, 0x70, 0x0E, 0x60,
  0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0x83, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x78, 0x1E, 0x3F,
  0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x03, 0x98, 0x07,
  0x0C, 0x07, 0x06, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0xFF, 0x01, 0xE1, 0xE0,
  0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF0, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3E, 0xF8, 0x1F, 0xF0, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x63,
  0x00, 0xCE, 0x01, 0x98, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFE, 0x7F, 0xFE, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x67, 0xF0, 0x6F, 0xFC, 0x78, 0x1E, 0x70, 0x06, 0x60, 0x06,
  0x60, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0C,
  0x3E, 0x78, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x61, 0x80, 0x1B, 0xFC, 0x0F, 0x87, 0x83,
  0x80, 0x71, 0xC0, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x8C, 0x00, 0xC3, 0x80, 0x70, 0x7C, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x6E,
  0x00, 0x33, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3C, 0x3C, 0x70, 0x0E,
  0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x06, 0x30, 0x0E, 0x18, 0x1C, 0x0E, 0x70, 0x03, 0xE0, 0x07, 0xE0,
  0x1C, 0x38, 0x38, 0x1C, 0x70, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x70, 0x0E,
  0x3E, 0x7C, 0x0F, 0xF8, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xE1, 0xE0, 0xE0,
  0x1C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x63,
  0x00, 0x38, 0xE0, 0x1C, 0x1F, 0x3B, 0x03, 0xFD, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xE1, 0xC7, 0x0E,
  0x1C, 0x30, 0x61, 0x83, 0x06, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x7F,
  0x03, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0x80, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x78, 0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x18,
  0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x3F, 0x3C, 0x0F, 0x77, 0x83, 0x81, 0xF0, 0x60, 0x3E,
  0x0C, 0x03, 0xC1, 0x80, 0x78, 0x30, 0x0F, 0x06, 0x01, 0xE0, 0xC0, 0x3C,
  0x18, 0x07, 0x83, 0x00, 0xF0, 0x60, 0x1E, 0x0C, 0x07, 0xC1, 0xC0, 0xF8,
  0x1C, 0x3F, 0x03, 0xFD, 0xE0, 0x1E, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x10, 0x20, 0x0C, 0x0C, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x01, 0xCC,
  0x01, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0x80, 0x38, 0xC0, 0x06, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x07, 0x9F, 0xFF, 0x8F, 0xFF, 0x00,
  0x01, 0x80, 0x0F, 0xF8, 0x3C, 0x3C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x0E, 0x1F, 0x7C, 0x0F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xC0, 0x3C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xBF, 0xFF, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xF8, 0x3C, 0x3C, 0x30, 0x0E, 0x60,
  0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x0E, 0x1F,
  0x7C, 0x0F, 0xF0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x3E, 0x7C,
  0x0F, 0xF0, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x30, 0x0C, 0x0C, 0x03, 0x83, 0x00, 0x60, 0xC0,
  0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xA0, 0x05, 0xB0, 0x0F,
  0xB0, 0x0F, 0xD0, 0x0B, 0xD8, 0x1B, 0xD8, 0x1B, 0xC8, 0x13, 0xCC, 0x33,
  0xC4, 0x23, 0xC6, 0x63, 0xC6, 0x63, 0xC2, 0x43, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC1, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03,
  0xD8, 0x03, 0xC8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6, 0x03, 0xC6, 0x03,
  0xC2, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x83,
  0xC0, 0xC3, 0xC0, 0xC3, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33,
  0xC0, 0x33, 0xC0, 0x1B, 0xC0, 0x1B, 0xC0, 0x1B, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0x01, 0x80, 0x0F, 0xF0, 0x3C, 0x3C, 0x30, 0x0C, 0x60, 0x06,
  0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1E, 0x78,
  0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0x30, 0x01, 0xD8, 0x00, 0x6C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x73, 0xFF, 0xF1, 0xFF, 0xE0,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3C, 0x3C, 0x30, 0x0C,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C,
  0x1E, 0x78, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x30, 0x03,
  0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x06,
  0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xFF,
  0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x03, 0x60, 0x01, 0x98, 0x00, 0x67, 0x00, 0x38, 0xE0, 0x1C, 0x1F,
  0xBE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1F,
  0x78, 0x0F, 0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x07, 0x01, 0x80, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x3C,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD0, 0x3C, 0x0D, 0x03,
  0xC0, 0x90, 0x34, 0x09, 0x02, 0x60, 0x98, 0x26, 0x19, 0x86, 0x61, 0x98,
  0x66, 0x19, 0x86, 0x61, 0x88, 0x66, 0x10, 0x86, 0x61, 0x08, 0x62, 0x10,
  0xC4, 0x33, 0x0C, 0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x20, 0x4C, 0x32,
  0x04, 0xC3, 0x20, 0x4C, 0x32, 0x06, 0xC1, 0x60, 0x68, 0x1E, 0x06, 0x81,
  0xE0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0x60, 0x00,
  0x63, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x80, 0xC0,
  0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x98, 0x00, 0x1B, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x40,
  0x06, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00, 0x70, 0xC0,
  0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0xC1,
  0x80, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x19, 0x80, 0x01, 0x98,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0F, 0xF8, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xF8,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70,
  0x0C, 0x30, 0x0C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C,
  0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x60, 0xE0, 0xC0, 0xE0, 0x07, 0xF8, 0x07, 0xDE, 0x06, 0x01, 0x86, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC7, 0xFF, 0xE7, 0x80, 0x37, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xD8, 0x00, 0xEE, 0x01, 0xB3, 0xE7,
  0x98, 0x7F, 0x8C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCE, 0x7C, 0xD0, 0x0C, 0xF0,
  0x06, 0xE0, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x06, 0xE0, 0x06, 0xD0, 0x0C, 0xCE, 0x7C, 0xC7,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x07, 0x60, 0x06, 0x30, 0x0E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x0F,
  0xE3, 0x3E, 0x73, 0x30, 0x0B, 0x60, 0x0F, 0x60, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x07, 0x60,
  0x0F, 0x30, 0x0B, 0x3E, 0x73, 0x0F, 0xE3, 0x0F, 0xF0, 0x1E, 0x78, 0x30,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x60, 0x06, 0x30, 0x0C, 0x1E,
  0x7C, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xE3, 0x3E,
  0x73, 0x30, 0x0B, 0x60, 0x0F, 0x60, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x0F, 0x30, 0x0B, 0x3E, 0x73, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x1F, 0xFC, 0x1F, 0xF8, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCE,
  0x7C, 0xD0, 0x0C, 0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x18, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0xFF, 0xE3, 0xFE, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xE0,
  0xC0, 0xC0, 0xC1, 0x80, 0xFF, 0x80, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xE0,
  0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0xDF, 0x1F, 0x3C, 0xEC, 0xEE, 0x1E, 0x1F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x30, 0xC7, 0xF0, 0xCE, 0x7C, 0xD0,
  0x0C, 0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x0F, 0xF0, 0x1E, 0x78, 0x30, 0x0C, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1E, 0x78, 0x0F, 0xF0, 0xC7,
  0xF0, 0xCE, 0x7C, 0xD0, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xE0,
  0x06, 0xD0, 0x0C, 0xCE, 0x78, 0xC7, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xE3, 0x3E,
  0x73, 0x30, 0x0B, 0x60, 0x0F, 0x60, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x07, 0x60, 0x0F, 0x30,
  0x0B, 0x3E, 0x73, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7, 0xF0, 0xDE, 0x78, 0xD0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x3E, 0x3C, 0x70, 0x06, 0x60, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x06, 0x3C, 0x3E, 0x1F, 0xF8, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x0E, 0x30, 0x0C, 0x1E, 0xF8, 0x0F, 0xF0, 0xC0, 0x00, 0xD8, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x60,
  0x18, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x12, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x70, 0x34, 0x0F, 0x02, 0x60, 0xD0, 0x66, 0x09, 0x06,
  0x60, 0x90, 0x66, 0x09, 0x86, 0x61, 0x98, 0x63, 0x19, 0x84, 0x31, 0x08,
  0xC3, 0x10, 0x8C, 0x31, 0x08, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC1, 0x30,
  0xC8, 0x1A, 0x05, 0x81, 0xA0, 0x58, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xC0, 0x70, 0xE0, 0x01, 0xCC, 0x00, 0xE3, 0x80, 0x30, 0x60,
  0x18, 0x0C, 0x0C, 0x03, 0x83, 0x00, 0x61, 0x80, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xCC, 0x00,
  0x61, 0x80, 0x38, 0x70, 0x0C, 0x0C, 0x06, 0x01, 0x83, 0x80, 0x70, 0xC0,
  0x0C, 0x60, 0x01, 0xB8, 0x00, 0x70, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00,
  0x19, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x70, 0x60, 0x18,
  0x1C, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x01,
  0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0xDF, 0xC0, 0x36, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xB0, 0x1C, 0x6C,
  0x03, 0xF3, 0x00, 0x10,
};

const GFXglyph JetBrainsMono_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 4, 29, 24, 10, -29 },
  { 16, 10, 12, 24, 7, -29 },
  { 31, 22, 29, 24, 1, -29 },
  { 111, 18, 41, 24, 3, -35 },
  { 204, 22, 29, 24, 1, -29 },
  { 284, 19, 30, 24, 3, -30 },
  { 356, 2, 12, 24, 11, -29 },
  { 359, 11, 39, 24, 8, -34 },
  { 413, 11, 39, 24, 5, -34 },
  { 467, 20, 20, 24, 2, -24 },
  { 517, 18, 19, 24, 3, -23 },
  { 560, 6, 12, 24, 8, -6 },
  { 569, 12, 2, 24, 6, -14 },
  { 572, 6, 6, 24, 9, -6 },
  { 577, 16, 37, 24, 4, -33 },
  { 651, 16, 30, 24, 4, -30 },
  { 711, 17, 29, 24, 4, -29 },
  { 773, 18, 30, 24, 3, -30 },
  { 841, 16, 29, 24, 4, -29 },
  { 899, 15, 29, 24, 4, -29 },
  { 954, 16, 29, 24, 4, -29 },
  { 1012, 18, 29, 24, 3, -29 },
  { 1078, 18, 29, 24, 3, -29 },
  { 1144, 16, 30, 24, 4, -30 },
  { 1204, 18, 30, 24, 3, -30 },
  { 1272, 6, 22, 24, 9, -22 },
  { 1289, 7, 28, 24, 8, -22 },
  { 1314, 16, 20, 24, 4, -23 },
  { 1354, 16, 11, 24, 4, -19 },
  { 1376, 16, 20, 24, 4, -23 },
  { 1416, 13, 29, 24, 7, -29 },
  { 1464, 19, 37, 24, 3, -30 },
  { 1552, 18, 29, 24, 3, -29 },
  { 1618, 17, 29, 24, 4, -29 },
  { 1680, 16, 30, 24, 4, -30 },
  { 1740, 16, 29, 24, 4, -29 },
  { 1798, 15, 29, 24, 5, -29 },
  { 1853, 16, 29, 24, 5, -29 },
  { 1911, 16, 30, 24, 4, -30 },
  { 1971, 16, 29, 24, 4, -29 },
  { 2029, 14, 29, 24, 5, -29 },
  { 2080, 16, 29, 24, 3, -29 },
  { 2138, 18, 29, 24, 4, -29 },
  { 2204, 16, 29, 24, 5, -29 },
  { 2262, 16, 29, 24, 4, -29 },
  { 2320, 16, 29, 24, 4, -29 },
  { 2378, 16, 30, 24, 4, -30 },
  { 2438, 17, 29, 24, 4, -29 },
  { 2500, 16, 37, 24, 4, -30 },
  { 2574, 17, 29, 24, 4, -29 },
  { 2636, 18, 30, 24, 3, -30 },
  { 2704, 20, 29, 24, 2, -29 },
  { 2777, 16, 29, 24, 4, -29 },
  { 2835, 18, 29, 24, 3, -29 },
  { 2901, 20, 29, 24, 2, -29 },
  { 2974, 20, 29, 24, 2, -29 },
  { 3047, 20, 29, 24, 2, -29 },
  { 3120, 16, 29, 24, 4, -29 },
  { 3178, 9, 37, 24, 9, -33 },
  { 3220, 16, 37, 24, 4, -33 },
  { 3294, 9, 37, 24, 6, -33 },
  { 3336, 16, 15, 24, 4, -29 },
  { 3366, 20, 2, 24, 2, 1 },
  { 3371, 7, 5, 24, 8, -31 },
  { 3376, 17, 22, 24, 3, -22 },
  { 3423, 16, 29, 24, 4, -29 },
  { 3481, 16, 22, 24, 4, -22 },
  { 3525, 16, 29, 24, 4, -29 },
  { 3583, 16, 22, 24, 4, -22 },
  { 3627, 18, 29, 24, 3, -29 },
  { 3693, 16, 29, 24, 4, -22 },
  { 3751, 16, 29, 24, 4, -29 },
  { 3809, 17, 31, 24, 4, -31 },
  { 3875, 14, 38, 24, 4, -31 },
  { 3942, 16, 29, 24, 5, -29 },
  { 4000, 20, 29, 24, 2, -29 },
  { 4073, 18, 22, 24, 3, -22 },
  { 4123, 16, 22, 24, 4, -22 },
  { 4167, 16, 22, 24, 4, -22 },
  { 4211, 16, 29, 24, 4, -22 },
  { 4269, 16, 29, 24, 4, -22 },
  { 4327, 16, 22, 24, 5, -22 },
  { 4371, 16, 22, 24, 4, -22 },
  { 4415, 17, 28, 24, 3, -28 },
  { 4475, 16, 22, 24, 4, -22 },
  { 4519, 18, 22, 24, 3, -22 },
  { 4569, 20, 22, 24, 2, -22 },
  { 4624, 18, 22, 24, 3, -22 },
  { 4674, 18, 29, 24, 3, -22 },
  { 4740, 16, 22, 24, 4, -22 },
  { 4784, 16, 37, 24, 4, -33 },
  { 4858, 2, 37, 24, 11, -33 },
  { 4868, 16, 37, 24, 4, -33 },
  { 4942, 18, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_Thin40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_THIN40PT7B_H_
