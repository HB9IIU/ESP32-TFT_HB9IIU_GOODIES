#ifndef _JETBRAINSMONO_THIN26PT7B_H_
#define _JETBRAINSMONO_THIN26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDA, 0x49, 0x24, 0x80, 0x7D, 0x80, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x50, 0xA1, 0x04, 0x10, 0x10, 0x40, 0x41, 0x03, 0x0C, 0x08,
  0x21, 0xFF, 0xF7, 0xFF, 0xC2, 0x08, 0x18, 0x60, 0x41, 0x01, 0x04, 0x04,
  0x10, 0xFF, 0xFB, 0xFF, 0xE2, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x06,
  0x18, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x01, 0xF8, 0x69, 0x99, 0x1A,
  0x21, 0x44, 0x28, 0x81, 0x90, 0x1A, 0x01, 0xC0, 0x1E, 0x01, 0x30, 0x23,
  0x04, 0x20, 0x87, 0x10, 0xE2, 0x14, 0x42, 0xC9, 0x87, 0xE0, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x78, 0x07, 0x10, 0x28, 0x41, 0x21, 0x0C, 0x84,
  0x22, 0x11, 0x08, 0x4C, 0x1F, 0x20, 0x11, 0x00, 0x08, 0x00, 0x22, 0x01,
  0x3E, 0x09, 0x8C, 0x64, 0x11, 0x10, 0x48, 0x41, 0x41, 0x0D, 0x02, 0x28,
  0x0F, 0x80, 0x1F, 0x01, 0x8C, 0x18, 0x30, 0x81, 0x84, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x78, 0x06, 0x60, 0x21, 0x0D, 0x0C, 0x48, 0x36, 0x40,
  0xA2, 0x03, 0x10, 0x18, 0x81, 0xE6, 0x19, 0x1F, 0x06, 0xFF, 0xFE, 0x03,
  0x0E, 0x18, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x18, 0x0E, 0x03,
  0x81, 0xC0, 0xC0, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x18, 0x30, 0x41, 0x86, 0x38, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC2, 0x0B, 0xC9, 0xF1, 0xFE, 0x00, 0xC0,
  0x05, 0x00, 0x32, 0x00, 0x8C, 0x06, 0x18, 0x30, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x33, 0x66, 0x44, 0xC8, 0xFF, 0x4F, 0xFE, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x1F, 0x86, 0x19,
  0x81, 0xA0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC6, 0x39, 0xC7, 0x10,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0A, 0x03, 0x60, 0x66, 0x18, 0x7E, 0x00,
  0x0C, 0x03, 0x81, 0x90, 0x62, 0x08, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x83, 0xFF, 0x80, 0x1F, 0x86, 0x0C, 0x40, 0x6C, 0x02, 0xC0, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x78, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xF0, 0x1E, 0x03, 0x40, 0x4C, 0x18, 0x7E, 0x00, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0xD8, 0x34,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xFF,
  0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0xFC, 0xC1, 0xB0, 0x38,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x03, 0x80, 0x90, 0x63, 0xF0, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x3F, 0x8C,
  0x19, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0A, 0x01, 0x40, 0x66, 0x18,
  0x7E, 0x00, 0xFF, 0xFC, 0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x1F, 0x86, 0x19, 0x81, 0xA0,
  0x14, 0x02, 0x80, 0x58, 0x11, 0x86, 0x1F, 0x01, 0xE0, 0xC6, 0x30, 0x24,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x6C, 0x18, 0x7E, 0x00, 0x1F, 0x86,
  0x19, 0x01, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x6C, 0x1C,
  0xFD, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20,
  0x00, 0x4F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0x23, 0xDE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x63, 0x31, 0x88, 0x46, 0x20, 0x00, 0x20, 0x1C,
  0x0E, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x02, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x08, 0x00, 0xFC, 0x03, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x02, 0x03, 0x03, 0x1F, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x38, 0x0C, 0x00, 0x1F, 0x83, 0x06, 0x40, 0x2C, 0x03, 0x80,
  0x18, 0x01, 0x81, 0x98, 0x7D, 0x84, 0x38, 0xC1, 0x8C, 0x18, 0xC1, 0x8C,
  0x18, 0xC1, 0x8C, 0x18, 0x43, 0x87, 0xD8, 0x10, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x3F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0A, 0x00, 0xB0, 0x09,
  0x01, 0x90, 0x11, 0x01, 0x18, 0x10, 0x83, 0x08, 0x20, 0x82, 0x0C, 0x3F,
  0xC7, 0xFC, 0x40, 0x64, 0x02, 0xC0, 0x28, 0x02, 0x80, 0x30, 0xFE, 0x20,
  0xE8, 0x0A, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x02, 0x83, 0xBF, 0xC8, 0x1A,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x6F, 0xE0, 0x3F, 0x18,
  0x6C, 0x0E, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0xC0, 0xD8, 0x63, 0xF0, 0xFE, 0x20,
  0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x81, 0xA0, 0xCF, 0xE0, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xF0,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x00, 0x3F, 0x18, 0x6C, 0x0E, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xD8, 0x63,
  0xF0, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x3F, 0xE0, 0x0F,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0xC0, 0xD8, 0x63, 0xF0, 0x80,
  0x70, 0x0A, 0x03, 0x40, 0x48, 0x19, 0x02, 0x20, 0xC4, 0x10, 0x86, 0x1F,
  0xC2, 0x18, 0x41, 0x08, 0x31, 0x02, 0x20, 0x64, 0x04, 0x80, 0xD0, 0x0A,
  0x01, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0xFF, 0x80, 0xE0, 0x7C, 0x0F, 0x82, 0xE8, 0x5D, 0x0B,
  0xA2, 0x72, 0x4E, 0x49, 0xCA, 0x38, 0xC7, 0x18, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x80, 0xC0, 0xF0, 0x3E, 0x0E,
  0x83, 0xA0, 0xE4, 0x39, 0x0E, 0x63, 0x88, 0xE2, 0x38, 0x4E, 0x13, 0x86,
  0xE0, 0xB8, 0x2E, 0x07, 0x81, 0x60, 0x78, 0x0C, 0x3F, 0x18, 0x6C, 0x0A,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0xC0, 0x98, 0x63, 0xF0, 0xFF, 0x10, 0x32, 0x01,
  0x40, 0x38, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0xDF, 0xF3, 0xF0, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x3F,
  0x18, 0x6C, 0x0A, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xC0, 0x98, 0x63, 0xF0, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x28, 0x07,
  0x00, 0xE0, 0x1C, 0x02, 0x80, 0xDF, 0xF2, 0x10, 0x43, 0x08, 0x21, 0x06,
  0x20, 0x44, 0x0C, 0x80, 0xD0, 0x1A, 0x01, 0x80, 0x1F, 0x86, 0x19, 0x81,
  0xA0, 0x14, 0x02, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x70, 0x0E, 0x01, 0x40, 0x6C, 0x18, 0x7E, 0x00, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0x98, 0x63, 0xF0, 0x80, 0x3C, 0x02, 0xC0, 0x24, 0x02, 0x40, 0x66,
  0x04, 0x20, 0x42, 0x04, 0x20, 0xC3, 0x08, 0x10, 0x81, 0x18, 0x19, 0x01,
  0x90, 0x09, 0x00, 0xB0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x83, 0x0E, 0x0C,
  0x2C, 0x30, 0xB0, 0xC2, 0x45, 0x09, 0x14, 0x24, 0x48, 0x91, 0x26, 0x44,
  0x99, 0x12, 0x46, 0x49, 0x1A, 0x24, 0x28, 0x90, 0xA1, 0x42, 0x85, 0x0A,
  0x14, 0x28, 0x70, 0xC1, 0x83, 0x06, 0x00, 0x40, 0x19, 0x00, 0x8C, 0x08,
  0x20, 0xC1, 0x84, 0x04, 0x60, 0x32, 0x00, 0xB0, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x09, 0x00, 0x8C, 0x0C, 0x20, 0x41, 0x86, 0x04, 0x20, 0x33, 0x00,
  0xB0, 0x06, 0xC0, 0x0A, 0x00, 0xC8, 0x04, 0x40, 0x61, 0x02, 0x08, 0x30,
  0x21, 0x01, 0x18, 0x04, 0x80, 0x2C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFF, 0xE0, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0xFC, 0x0C, 0x07, 0x01, 0x60, 0x48, 0x33, 0x08, 0x46, 0x11, 0x06, 0xC0,
  0xA0, 0x30, 0xFF, 0xF0, 0xE1, 0x06, 0x04, 0x03, 0xF0, 0x83, 0x20, 0x30,
  0x06, 0x00, 0xC0, 0x19, 0xFF, 0x60, 0x78, 0x0E, 0x01, 0xC0, 0x3C, 0x06,
  0xC1, 0xCF, 0xD8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x8C, 0x2F, 0xCC, 0x1B,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xC0,
  0xB8, 0x6B, 0xF0, 0x08, 0x0F, 0xC4, 0x0A, 0x03, 0x80, 0x60, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0xC0, 0xD8, 0x63, 0xF0, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x08, 0xDF, 0xF4, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xD8, 0x73, 0xEC, 0x08, 0x1F,
  0xC4, 0x1A, 0x03, 0x80, 0xE0, 0x18, 0x07, 0xFF, 0x80, 0x20, 0x08, 0x02,
  0x01, 0xC0, 0xD8, 0x63, 0xF0, 0x03, 0xF0, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x1F,
  0xB4, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x03, 0x63, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x78, 0xF8, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x8C, 0x2F, 0xCC, 0x1B, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x06,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0xFF, 0x01, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x3C, 0xF8,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0xA0, 0x24, 0x0C,
  0x83, 0x10, 0x42, 0x18, 0x7E, 0x08, 0x61, 0x04, 0x20, 0xC4, 0x0C, 0x80,
  0x90, 0x1A, 0x01, 0x80, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFE, 0x10,
  0x8B, 0xDE, 0xC6, 0x28, 0x43, 0x84, 0x38, 0x43, 0x84, 0x38, 0x43, 0x84,
  0x38, 0x43, 0x84, 0x38, 0x43, 0x84, 0x38, 0x43, 0x84, 0x30, 0x0C, 0x2F,
  0xCC, 0x1B, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x08, 0x0F, 0xC4, 0x1A, 0x03, 0x80, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xC0, 0x98, 0x63, 0xF0,
  0x0C, 0x2F, 0xCC, 0x1B, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0xC0, 0xB8, 0x6B, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x08, 0x1F, 0xF4, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xD8, 0x73, 0xEC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x04, 0x37, 0xEE, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0E, 0x07, 0xF9,
  0x81, 0xA0, 0x14, 0x00, 0x80, 0x1C, 0x00, 0xF8, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x14, 0x02, 0xC0, 0xCF, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F,
  0xFE, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFC, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x02, 0x61, 0x8F,
  0xC0, 0xC0, 0x34, 0x02, 0x40, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0x81,
  0x08, 0x11, 0x81, 0x90, 0x09, 0x00, 0xB0, 0x0E, 0x00, 0x60, 0xC3, 0x0A,
  0x18, 0x50, 0xC2, 0x8A, 0x34, 0x51, 0x32, 0x49, 0x92, 0x44, 0x92, 0x28,
  0x91, 0x45, 0x8A, 0x18, 0x50, 0xC3, 0x86, 0x0C, 0x30, 0xC0, 0x66, 0x04,
  0x30, 0x81, 0x18, 0x09, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0B, 0x01, 0x18,
  0x30, 0x82, 0x0C, 0x40, 0x6C, 0x03, 0xC0, 0x34, 0x02, 0x60, 0x66, 0x04,
  0x20, 0xC3, 0x08, 0x10, 0x81, 0x18, 0x19, 0x00, 0x90, 0x0F, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x00, 0xFF,
  0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x3F, 0xF0, 0x00, 0xC0, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xF8, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x3C, 0x01, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x07, 0xC3, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0xC0, 0xE0,
  0x00, 0x20, 0x2F, 0x07, 0x10, 0xC1, 0x18, 0x1E,
};

const GFXglyph JetBrainsMono_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 19, 16, 6, -19 },
  { 9, 7, 8, 16, 4, -19 },
  { 16, 14, 19, 16, 1, -19 },
  { 50, 11, 27, 16, 2, -23 },
  { 88, 14, 19, 16, 1, -19 },
  { 122, 13, 19, 16, 2, -19 },
  { 153, 2, 8, 16, 7, -19 },
  { 155, 8, 25, 16, 5, -22 },
  { 180, 7, 25, 16, 3, -22 },
  { 202, 14, 13, 16, 1, -16 },
  { 225, 12, 12, 16, 2, -15 },
  { 243, 4, 8, 16, 5, -4 },
  { 247, 8, 1, 16, 4, -9 },
  { 248, 4, 4, 16, 6, -4 },
  { 250, 11, 25, 16, 2, -22 },
  { 285, 11, 19, 16, 2, -19 },
  { 312, 11, 19, 16, 3, -19 },
  { 339, 12, 19, 16, 2, -19 },
  { 368, 11, 19, 16, 2, -19 },
  { 395, 10, 19, 16, 3, -19 },
  { 419, 10, 19, 16, 3, -19 },
  { 443, 11, 19, 16, 2, -19 },
  { 470, 12, 19, 16, 2, -19 },
  { 499, 11, 19, 16, 2, -19 },
  { 526, 11, 19, 16, 2, -19 },
  { 553, 4, 15, 16, 6, -15 },
  { 561, 5, 19, 16, 5, -15 },
  { 573, 11, 13, 16, 2, -15 },
  { 591, 11, 7, 16, 2, -12 },
  { 601, 11, 13, 16, 2, -15 },
  { 619, 9, 19, 16, 4, -19 },
  { 641, 12, 24, 16, 2, -19 },
  { 677, 12, 19, 16, 2, -19 },
  { 706, 10, 19, 16, 3, -19 },
  { 730, 10, 19, 16, 3, -19 },
  { 754, 10, 19, 16, 3, -19 },
  { 778, 10, 19, 16, 3, -19 },
  { 802, 11, 19, 16, 3, -19 },
  { 829, 10, 19, 16, 3, -19 },
  { 853, 10, 19, 16, 3, -19 },
  { 877, 9, 19, 16, 3, -19 },
  { 899, 10, 19, 16, 2, -19 },
  { 923, 11, 19, 16, 3, -19 },
  { 950, 11, 19, 16, 3, -19 },
  { 977, 11, 19, 16, 2, -19 },
  { 1004, 10, 19, 16, 3, -19 },
  { 1028, 10, 19, 16, 3, -19 },
  { 1052, 11, 19, 16, 3, -19 },
  { 1079, 10, 24, 16, 3, -19 },
  { 1109, 11, 19, 16, 3, -19 },
  { 1136, 11, 19, 16, 2, -19 },
  { 1163, 12, 19, 16, 2, -19 },
  { 1192, 10, 19, 16, 3, -19 },
  { 1216, 12, 19, 16, 2, -19 },
  { 1245, 14, 19, 16, 1, -19 },
  { 1279, 13, 19, 16, 1, -19 },
  { 1310, 13, 19, 16, 1, -19 },
  { 1341, 11, 19, 16, 2, -19 },
  { 1368, 6, 25, 16, 6, -22 },
  { 1387, 11, 25, 16, 2, -22 },
  { 1422, 6, 25, 16, 4, -22 },
  { 1441, 10, 10, 16, 3, -19 },
  { 1454, 12, 1, 16, 2, 1 },
  { 1456, 5, 3, 16, 5, -20 },
  { 1458, 11, 15, 16, 2, -15 },
  { 1479, 10, 19, 16, 3, -19 },
  { 1503, 10, 15, 16, 3, -15 },
  { 1522, 10, 19, 16, 3, -19 },
  { 1546, 10, 15, 16, 3, -15 },
  { 1565, 12, 19, 16, 2, -19 },
  { 1594, 10, 20, 16, 3, -15 },
  { 1619, 10, 19, 16, 3, -19 },
  { 1643, 12, 20, 16, 2, -20 },
  { 1673, 10, 25, 16, 2, -20 },
  { 1705, 11, 19, 16, 3, -19 },
  { 1732, 13, 19, 16, 1, -19 },
  { 1763, 12, 15, 16, 2, -15 },
  { 1786, 10, 15, 16, 3, -15 },
  { 1805, 10, 15, 16, 3, -15 },
  { 1824, 10, 20, 16, 3, -15 },
  { 1849, 10, 20, 16, 3, -15 },
  { 1874, 10, 15, 16, 3, -15 },
  { 1893, 11, 15, 16, 2, -15 },
  { 1914, 11, 18, 16, 2, -18 },
  { 1939, 10, 14, 16, 3, -14 },
  { 1957, 12, 14, 16, 2, -14 },
  { 1978, 13, 14, 16, 1, -14 },
  { 2001, 12, 14, 16, 2, -14 },
  { 2022, 12, 19, 16, 2, -14 },
  { 2051, 10, 14, 16, 3, -14 },
  { 2069, 10, 25, 16, 3, -22 },
  { 2101, 1, 25, 16, 7, -22 },
  { 2105, 10, 25, 16, 3, -22 },
  { 2137, 11, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Thin26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Thin26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Thin26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_THIN26PT7B_H_
