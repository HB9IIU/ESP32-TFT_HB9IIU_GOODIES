#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC23PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xC7, 0x00, 0x01, 0x8F,
  0x3C, 0x60, 0x66, 0xCD, 0xBB, 0x6C, 0xD9, 0x80, 0x03, 0x60, 0x66, 0x06,
  0xC0, 0x6C, 0x06, 0xC3, 0xFF, 0x3F, 0xE0, 0xD8, 0x19, 0x81, 0xB0, 0x7F,
  0xCF, 0xFC, 0x36, 0x03, 0x60, 0x36, 0x06, 0xE0, 0x6C, 0x00, 0x03, 0x00,
  0xC0, 0xF0, 0x7E, 0x3F, 0xCE, 0x77, 0x9D, 0xE0, 0x78, 0x0F, 0x01, 0xF0,
  0x3C, 0x07, 0x80, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0xC3, 0xC0, 0x40, 0x10,
  0x00, 0x38, 0x0F, 0x83, 0xB3, 0x66, 0x6C, 0xD9, 0x9F, 0x3E, 0xC3, 0xF0,
  0x0E, 0x01, 0xF8, 0x7F, 0x1F, 0x33, 0x66, 0xCC, 0xF1, 0xB8, 0x3E, 0x03,
  0x80, 0x07, 0x80, 0xFC, 0x1F, 0xC1, 0xDC, 0x1D, 0xC1, 0xDC, 0x1F, 0x81,
  0xF0, 0x1E, 0x03, 0xF7, 0x77, 0x7F, 0x7E, 0xF3, 0xEF, 0x3C, 0x7F, 0xC7,
  0xFE, 0x3E, 0xE0, 0x76, 0x66, 0xEC, 0x02, 0x0C, 0x30, 0xE3, 0x87, 0x0C,
  0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x06,
  0x06, 0x04, 0x00, 0x08, 0x30, 0x30, 0x70, 0xE0, 0xC1, 0x83, 0x06, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0xE3, 0x87, 0x1C, 0x20, 0x00,
  0x06, 0x01, 0x80, 0x41, 0xB7, 0xFF, 0xC7, 0x83, 0xE1, 0xD8, 0x63, 0x08,
  0x80, 0x0E, 0x07, 0x07, 0x83, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x00, 0x39, 0x9C, 0xE7, 0x73, 0x00, 0x7D, 0xFF, 0xC0, 0x27,
  0xF7, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x00, 0x0F, 0x07, 0xE3, 0xF9, 0xE7, 0x71, 0xDC, 0x77, 0x1F, 0xCF,
  0xF3, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xCF, 0xF1, 0xF8, 0x3C, 0x00,
  0x03, 0x1E, 0x7E, 0x7E, 0x6E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF3, 0x9E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xF7, 0xFE, 0xFF, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF0, 0x0E,
  0x03, 0xC0, 0x78, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0x00, 0xEF, 0x1D, 0xE7,
  0x9F, 0xE3, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x87, 0x70, 0xDE, 0x3B, 0xCE, 0x71, 0xFF, 0x7F, 0xEF, 0xFC, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xE0, 0x70, 0x1C,
  0x07, 0xE1, 0xFC, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0xE3, 0xB9, 0xEF, 0xF1,
  0xF8, 0x3C, 0x00, 0x03, 0x87, 0xC7, 0xE7, 0x83, 0x83, 0x81, 0xFD, 0xFF,
  0xFF, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0xFC, 0xFE, 0x3C, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x0F,
  0x07, 0xE3, 0xFD, 0xE7, 0x79, 0xDC, 0x77, 0xBC, 0xFE, 0x3F, 0x1F, 0xCF,
  0x7B, 0x8E, 0xE3, 0xB9, 0xEF, 0xF3, 0xFC, 0x3C, 0x00, 0x0F, 0x0F, 0xE3,
  0xF9, 0xEF, 0x71, 0xDC, 0x77, 0x3D, 0xCF, 0x7F, 0xDF, 0xE3, 0xF8, 0x1E,
  0x07, 0x03, 0xC7, 0xE1, 0xF0, 0x70, 0x00, 0x18, 0xF3, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x87, 0x1C, 0x70, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0x40, 0x00, 0x40, 0xE0, 0xF9,
  0xFC, 0x7C, 0x1E, 0x07, 0xE0, 0x7C, 0x07, 0x00, 0x40, 0x7F, 0xDF, 0xE7,
  0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xFB, 0xFC, 0x20, 0x0E, 0x03, 0xE0, 0xFE,
  0x07, 0xC0, 0xE1, 0xF9, 0xFC, 0x7C, 0x1C, 0x08, 0x00, 0x1E, 0x1F, 0x9F,
  0xEE, 0x77, 0x38, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x00, 0x01,
  0x81, 0xE0, 0xF0, 0x30, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0x06, 0x0C,
  0x03, 0x18, 0x03, 0x38, 0xF3, 0x31, 0xFB, 0x73, 0xB3, 0x67, 0x33, 0x66,
  0x33, 0x66, 0x73, 0xEE, 0x63, 0xEE, 0x66, 0xCE, 0xE6, 0xE7, 0xFC, 0xE7,
  0x38, 0x60, 0x00, 0x60, 0x00, 0x38, 0x40, 0x3F, 0xC0, 0x0F, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xB8, 0x1D, 0xC1, 0xEE,
  0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x7F, 0xE3, 0xFF, 0x1F, 0xFD, 0xE1, 0xEE,
  0x0F, 0xF0, 0x78, 0x1F, 0xC1, 0xFE, 0x3F, 0xF3, 0xC7, 0x3C, 0x73, 0x87,
  0x38, 0xF3, 0x9E, 0x7F, 0xC7, 0xFE, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E,
  0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0x8F, 0x70,
  0xF7, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x1E, 0xE1,
  0xEF, 0x1C, 0x7F, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xFE, 0x3F, 0xE3,
  0xCF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x0E, 0x71, 0xE7, 0x1C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x3F, 0xF3, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x7F, 0xC7, 0xFC,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x3F, 0xE3, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x7F,
  0xC7, 0xFC, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE3, 0x8F, 0x78, 0x77, 0x07, 0x70, 0x0F,
  0x00, 0xF3, 0xEF, 0x3E, 0xE3, 0xEE, 0x1E, 0xE1, 0xEF, 0x1E, 0x7F, 0xE7,
  0xFC, 0x1F, 0x00, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38,
  0xE0, 0xE3, 0x83, 0x8F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0x87, 0x1C, 0x1C,
  0x70, 0x71, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE0, 0x1C, 0x71, 0xCF,
  0x3C, 0xF3, 0x8E, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xF0, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xEF, 0x39, 0xE7, 0x3F, 0xE3, 0xF8, 0x3C, 0x00, 0x1C, 0x3C,
  0x71, 0xE3, 0xCF, 0x0F, 0x3C, 0x3D, 0xE0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE0, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x80,
  0x1E, 0x07, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x7F, 0x77, 0x3F, 0xBF, 0x9C, 0xDB, 0xCE,
  0x7D, 0xC7, 0x3C, 0xE3, 0x9E, 0x73, 0xCF, 0x39, 0xE7, 0x3C, 0xF3, 0x9E,
  0x00, 0x1C, 0x1C, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0x3E, 0x38, 0xFC, 0xE3,
  0xF3, 0x8E, 0xDE, 0x7B, 0x79, 0xED, 0xE7, 0xBF, 0x1C, 0x7C, 0x71, 0xF1,
  0xC7, 0xCF, 0x1F, 0x3C, 0x3C, 0xF0, 0xE0, 0x07, 0x81, 0xFE, 0x3F, 0xE3,
  0x8F, 0x78, 0x77, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xEE,
  0x0E, 0xE1, 0xEF, 0x1C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x1F, 0xC0, 0xFF,
  0x0F, 0xFC, 0x78, 0xE3, 0xC7, 0x9C, 0x3C, 0xE1, 0xC7, 0x1E, 0x7F, 0xF3,
  0xFF, 0x1F, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x8F, 0x78, 0x77, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF, 0x1C, 0x7F, 0xC7,
  0xF8, 0x1F, 0x80, 0x3C, 0x01, 0xC0, 0x10, 0x1F, 0xC1, 0xFE, 0x3F, 0xF3,
  0xC7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x7F, 0xE7, 0xFC, 0x7F, 0x87,
  0x3C, 0x73, 0xC7, 0x3C, 0xF1, 0xCF, 0x1E, 0xF1, 0xE0, 0x07, 0xC0, 0xFE,
  0x1F, 0xF3, 0xC7, 0x3C, 0x73, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x01, 0xE0, 0x1E, 0xF1, 0xE7, 0x1E, 0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x38,
  0x73, 0x87, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xF0,
  0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x3E,
  0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xC7,
  0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x3C, 0x00, 0xE3, 0x8F, 0xE3, 0x8E, 0xE3, 0x8E, 0xE7, 0x9E, 0xE7,
  0x9C, 0xE7, 0x9C, 0xEF, 0xBC, 0xEF, 0xB8, 0xED, 0xB8, 0xFD, 0xB8, 0xFD,
  0xF0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF1,
  0xE0, 0x1E, 0x3C, 0x3C, 0x78, 0x39, 0xE0, 0x73, 0xC0, 0xFF, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x01,
  0xFE, 0x07, 0x9C, 0x0F, 0x38, 0x3C, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0x1E,
  0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x00, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC0, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x78,
  0x78, 0x78, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x9E, 0x78,
  0xE3, 0x8E, 0x38, 0xE0, 0x1F, 0x1E, 0x1E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78,
  0xF0, 0xF0, 0xF0, 0x0C, 0x1E, 0x1E, 0x36, 0x76, 0x66, 0xE6, 0xE6, 0xFF,
  0xFF, 0xFF, 0x71, 0xCE, 0x0F, 0x0F, 0xE3, 0xFD, 0xEF, 0x03, 0xC7, 0xE7,
  0xFB, 0xCE, 0xF3, 0xBF, 0xEF, 0xF9, 0xFE, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0xF8, 0xFF, 0x7F, 0xDE, 0x77, 0x1D, 0xC7, 0x71, 0xDC,
  0x7F, 0x3F, 0xFE, 0xFF, 0xBB, 0xC0, 0x0F, 0x0F, 0xE3, 0xFD, 0xC7, 0x71,
  0xDC, 0x0F, 0x03, 0xCE, 0x73, 0x9F, 0xE7, 0xF0, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1F, 0xE3, 0xFE, 0x7F, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0x87, 0xF8, 0x7F, 0x83, 0xB8,
  0x0F, 0x0F, 0xE3, 0xFD, 0xE7, 0x71, 0xDF, 0xF7, 0xFD, 0xC0, 0x70, 0x1F,
  0xE7, 0xF8, 0x7C, 0x0F, 0x1F, 0x3F, 0x3C, 0x38, 0x38, 0xFE, 0xFE, 0xFC,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0xE7, 0xFD,
  0xFF, 0xBC, 0xF7, 0x1C, 0xE3, 0x9C, 0x77, 0x8E, 0x73, 0xCF, 0xF9, 0xFE,
  0x1F, 0xC0, 0x38, 0x0F, 0x3F, 0xC7, 0xF8, 0x7C, 0x00, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0xB8, 0xFF, 0x7F, 0xDE, 0x77, 0x1D, 0xC7,
  0x73, 0xDC, 0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0xE0, 0x08, 0x71, 0xC7, 0x00,
  0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0x71, 0xCF, 0x3C, 0xE0, 0x01, 0x01, 0xC0,
  0xE0, 0x70, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x0F, 0x87, 0x87, 0x80, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x39, 0xE3, 0xBC, 0x7B, 0xC7,
  0xF8, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xF7, 0x0F, 0x78, 0xE3, 0x8E,
  0x3C, 0x1C, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0x71, 0xC7,
  0x3C, 0xF3, 0x80, 0x3B, 0x9E, 0x3F, 0xFE, 0x3F, 0xFF, 0x79, 0xCF, 0x79,
  0xCF, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0x8E, 0xF3, 0x9E, 0xE3,
  0x9E, 0xE7, 0x9C, 0x3B, 0x8F, 0xF7, 0xFD, 0xE7, 0x71, 0xDC, 0x77, 0x3D,
  0xCF, 0xF3, 0xBC, 0xEE, 0x3B, 0x8E, 0x0F, 0x0F, 0xE3, 0xFD, 0xE7, 0x71,
  0xDC, 0x77, 0x1F, 0xC7, 0x73, 0xDF, 0xE7, 0xF0, 0xF8, 0x1F, 0xC3, 0xFC,
  0x7F, 0x9E, 0x73, 0xCE, 0x71, 0xCE, 0x39, 0xC7, 0x39, 0xEF, 0xF9, 0xFF,
  0x3B, 0xC7, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0xE7, 0xFD,
  0xFF, 0xB8, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9E, 0xF3, 0x8F, 0xF1, 0xFE,
  0x1D, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3B, 0x3F, 0x3F,
  0x7C, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x1F, 0x0F, 0xE7,
  0xBD, 0xCF, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0xE3, 0xBD, 0xE7, 0xF0, 0xF8,
  0x38, 0xE3, 0xBF, 0xFF, 0xF7, 0x1C, 0x73, 0xCE, 0x38, 0xFB, 0xE7, 0x00,
  0x71, 0xDC, 0xFF, 0x3F, 0xCE, 0xE3, 0xB8, 0xEE, 0x7B, 0x9E, 0xE7, 0x3F,
  0xCF, 0xF1, 0xDC, 0xF3, 0xFC, 0xEF, 0x7B, 0xDC, 0x77, 0x1F, 0x87, 0xE1,
  0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xE3, 0x3B, 0x9C, 0xEE, 0x73, 0xBB,
  0xDC, 0xEF, 0x73, 0xBD, 0xCF, 0xFE, 0x3E, 0xF8, 0xFB, 0xE1, 0xCF, 0x07,
  0x3C, 0x1C, 0xE0, 0x3C, 0xE1, 0xDE, 0x1D, 0xC1, 0xFC, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xF8, 0x3F, 0x83, 0xB8, 0x7B, 0x8F, 0x3C, 0x3C, 0xF3, 0xCE,
  0x3D, 0xE3, 0xDC, 0x1D, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x00, 0x3F,
  0xCF, 0xF7, 0xFC, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3F, 0xEF,
  0xF3, 0xFC, 0x02, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0xF1, 0xC7,
  0x87, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x02, 0x00, 0x18, 0xC6,
  0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x8C, 0x63, 0x19, 0x80, 0x08,
  0x38, 0x30, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x1C, 0x18, 0xF1, 0xC7, 0x0E,
  0x1C, 0x38, 0x71, 0xC3, 0x8E, 0x08, 0x00, 0x38, 0xDF, 0x3F, 0xFF, 0xBE,
  0xC7, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 7, 6, 7, 1, -17 },
  { 20, 12, 17, 12, 0, -17 },
  { 46, 10, 21, 11, 1, -19 },
  { 73, 11, 17, 14, 2, -17 },
  { 97, 12, 17, 13, 0, -17 },
  { 123, 4, 6, 4, 1, -17 },
  { 126, 7, 23, 7, 1, -18 },
  { 147, 7, 23, 7, -1, -18 },
  { 168, 10, 10, 10, 1, -17 },
  { 181, 9, 12, 10, 1, -13 },
  { 195, 5, 7, 6, -1, -3 },
  { 200, 6, 3, 9, 1, -9 },
  { 203, 4, 4, 7, 0, -4 },
  { 205, 11, 18, 7, -2, -17 },
  { 230, 10, 17, 11, 1, -17 },
  { 252, 8, 17, 11, 2, -17 },
  { 269, 11, 17, 11, 0, -17 },
  { 293, 11, 17, 11, 0, -17 },
  { 317, 11, 17, 11, 0, -17 },
  { 341, 10, 17, 11, 1, -17 },
  { 363, 9, 17, 11, 1, -17 },
  { 383, 11, 17, 11, 1, -17 },
  { 407, 10, 17, 11, 1, -17 },
  { 429, 10, 17, 11, 1, -17 },
  { 451, 6, 13, 6, 0, -13 },
  { 461, 7, 17, 6, -1, -13 },
  { 476, 10, 10, 10, 0, -12 },
  { 489, 10, 8, 11, 1, -11 },
  { 499, 10, 11, 10, 0, -12 },
  { 513, 9, 17, 10, 1, -17 },
  { 533, 16, 21, 17, 0, -16 },
  { 575, 13, 17, 13, -1, -17 },
  { 603, 12, 17, 13, 0, -17 },
  { 629, 12, 17, 13, 1, -17 },
  { 655, 12, 17, 13, 0, -17 },
  { 681, 12, 17, 11, 0, -17 },
  { 707, 12, 17, 11, 0, -17 },
  { 733, 12, 17, 13, 1, -17 },
  { 759, 14, 17, 14, 0, -17 },
  { 789, 6, 17, 6, 0, -17 },
  { 802, 11, 17, 11, 0, -17 },
  { 826, 14, 17, 12, 0, -17 },
  { 856, 9, 17, 11, 0, -17 },
  { 876, 17, 17, 17, 0, -17 },
  { 913, 14, 17, 14, 0, -17 },
  { 943, 12, 17, 13, 1, -17 },
  { 969, 13, 17, 13, 0, -17 },
  { 997, 12, 20, 13, 1, -17 },
  { 1027, 12, 17, 12, 0, -17 },
  { 1053, 12, 17, 12, 0, -17 },
  { 1079, 11, 17, 12, 2, -17 },
  { 1103, 12, 17, 13, 1, -17 },
  { 1129, 12, 17, 13, 2, -17 },
  { 1155, 16, 17, 17, 2, -17 },
  { 1189, 15, 17, 13, -1, -17 },
  { 1221, 12, 17, 12, 2, -17 },
  { 1247, 13, 17, 12, 0, -17 },
  { 1275, 8, 23, 6, -1, -19 },
  { 1298, 6, 18, 9, 2, -17 },
  { 1312, 8, 23, 6, -1, -19 },
  { 1335, 8, 8, 9, 1, -17 },
  { 1343, 8, 3, 9, -1, 0 },
  { 1346, 5, 3, 7, 2, -17 },
  { 1348, 10, 12, 10, 0, -12 },
  { 1363, 10, 18, 11, 0, -18 },
  { 1386, 10, 12, 10, 0, -12 },
  { 1401, 12, 18, 11, 0, -18 },
  { 1428, 10, 12, 11, 0, -12 },
  { 1443, 8, 18, 7, 1, -18 },
  { 1461, 11, 17, 11, 0, -12 },
  { 1485, 10, 18, 11, 0, -18 },
  { 1508, 6, 17, 6, 0, -17 },
  { 1521, 9, 22, 6, -3, -17 },
  { 1546, 12, 18, 11, 0, -18 },
  { 1573, 6, 18, 6, 0, -18 },
  { 1587, 16, 12, 17, 0, -12 },
  { 1611, 10, 12, 11, 0, -12 },
  { 1626, 10, 12, 11, 0, -12 },
  { 1641, 11, 17, 11, -1, -12 },
  { 1665, 11, 17, 11, 0, -12 },
  { 1689, 8, 12, 8, 0, -12 },
  { 1701, 10, 12, 10, 0, -12 },
  { 1716, 6, 15, 7, 1, -15 },
  { 1728, 10, 12, 11, 1, -12 },
  { 1743, 10, 12, 10, 1, -12 },
  { 1758, 14, 12, 14, 1, -12 },
  { 1779, 12, 12, 10, -1, -12 },
  { 1797, 12, 17, 10, -1, -12 },
  { 1823, 10, 12, 10, 0, -12 },
  { 1838, 7, 22, 7, 0, -18 },
  { 1858, 5, 20, 6, 0, -17 },
  { 1871, 7, 22, 7, -1, -18 },
  { 1891, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC23PT7B_H_
