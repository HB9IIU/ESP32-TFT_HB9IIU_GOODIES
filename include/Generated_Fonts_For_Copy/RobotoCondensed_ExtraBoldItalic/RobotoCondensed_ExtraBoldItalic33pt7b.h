#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC33PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x0F,
  0xC3, 0xC1, 0xE0, 0x73, 0xDC, 0xF7, 0x3B, 0xCE, 0xF3, 0xB9, 0xEE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x81, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01,
  0xDC, 0x01, 0xCE, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0x80,
  0x7F, 0x81, 0xFF, 0x87, 0xFF, 0x0F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF9, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF3, 0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9F, 0x1F, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xBC, 0x6E, 0x39, 0xDC, 0x77, 0xB9, 0xEE,
  0x73, 0xB8, 0xFF, 0xE0, 0xFD, 0xC0, 0xF7, 0x00, 0x1C, 0x00, 0x7F, 0x80,
  0xFF, 0xC3, 0xFF, 0x8E, 0xE7, 0x3D, 0xCE, 0x73, 0x9D, 0xC7, 0x3F, 0x0E,
  0x72, 0x1F, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0xF1, 0xFE, 0x79, 0xFF,
  0x3D, 0xF7, 0xFC, 0xFB, 0xFE, 0xF8, 0xFF, 0x7C, 0x7F, 0x1F, 0x1F, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0x7C, 0x7B, 0xDC, 0xEF, 0x7B,
  0x9C, 0xE0, 0x00, 0x40, 0x18, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x08, 0x00,
  0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78,
  0x3E, 0x0F, 0x03, 0x80, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x63, 0x9B, 0xEF, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0x80, 0x7E, 0x03,
  0x9C, 0x1E, 0x78, 0x70, 0xE0, 0x82, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x3C, 0x78, 0xF3, 0xE7, 0x9F, 0x3C, 0xF0, 0x40, 0x7F, 0xFF, 0xBF, 0xDF,
  0xE0, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xC7, 0xC7,
  0xCF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xE3, 0xE7,
  0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF1, 0xE3,
  0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xC1, 0xF1,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEC, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3F, 0x1E, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C,
  0x7C, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xBC, 0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0x7C,
  0x3C, 0x78, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3D,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xC1, 0x87, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xFF, 0x87, 0xFE, 0x07,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3D, 0xE1, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFF, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7,
  0x8F, 0x9F, 0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C,
  0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0x0F, 0x9F, 0x3E, 0x3E, 0x7C,
  0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xFF, 0x87, 0xFF, 0x07, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFE, 0x7C, 0xF9,
  0xF1, 0xE7, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x8F, 0xBE, 0x3E,
  0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0xFC,
  0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x7C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0x7C, 0xF8, 0xE0,
  0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x87,
  0x83, 0xC0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x0F, 0xE1, 0xFF, 0x3F,
  0xF3, 0xFE, 0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFE,
  0x01, 0xF0, 0x07, 0x00, 0x08, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xDF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF,
  0x00, 0x10, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x01,
  0xF0, 0x07, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7,
  0xCF, 0xFC, 0x7F, 0xE3, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0xE0, 0x01,
  0xC3, 0xC0, 0x03, 0x8F, 0x07, 0x87, 0x1C, 0x3F, 0xCE, 0x78, 0xFF, 0x8C,
  0xE3, 0xC7, 0x19, 0xC7, 0x1E, 0x37, 0x9E, 0x38, 0xEE, 0x3C, 0x71, 0xDC,
  0x70, 0xE3, 0xB9, 0xE3, 0xC7, 0x73, 0xC7, 0x0F, 0xE7, 0x8E, 0x3B, 0xCF,
  0x3C, 0x77, 0x9E, 0x79, 0xCF, 0x1F, 0xFF, 0x8E, 0x3F, 0xFE, 0x1C, 0x38,
  0xF8, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x10,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9F,
  0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0xFC, 0x07, 0xDF, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x87,
  0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x1E,
  0xF8, 0x0F, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x1F,
  0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x1F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xE3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC7, 0xF9, 0xF1, 0xFE, 0x7C, 0x7F, 0xBE, 0x3F, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x1F, 0x07, 0xC7, 0xE3, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFC, 0xF8, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x03,
  0xE3, 0xF0, 0x3E, 0x1F, 0x81, 0xF1, 0xF8, 0x0F, 0x9F, 0x80, 0x7C, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0x7C, 0x0F, 0x83,
  0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xF1, 0xEF, 0x0F, 0xB8, 0xFF, 0x87, 0xDC,
  0x77, 0xC3, 0xEE, 0x7B, 0xE1, 0xF7, 0x3D, 0xF0, 0xF3, 0xBC, 0xF0, 0xF9,
  0xFE, 0xF8, 0x7C, 0xFE, 0x7C, 0x3E, 0x7F, 0x3E, 0x1F, 0x3F, 0x1F, 0x0F,
  0x9F, 0x8F, 0x8F, 0x87, 0x8F, 0x87, 0xC3, 0xC7, 0xC3, 0xE1, 0xC3, 0xE0,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xC1, 0xF1, 0xFC, 0x1F, 0x1F, 0xC3,
  0xE1, 0xFC, 0x3E, 0x1F, 0xE3, 0xE1, 0xFE, 0x3E, 0x1F, 0xE3, 0xE3, 0xEE,
  0x3E, 0x3E, 0xF7, 0xC3, 0xEF, 0x7C, 0x3E, 0x77, 0xC3, 0xE7, 0x7C, 0x3E,
  0x7F, 0xC7, 0xC7, 0xFC, 0x7C, 0x3F, 0x87, 0xC3, 0xF8, 0x7C, 0x3F, 0x87,
  0xC3, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0x8F, 0x83, 0xE3,
  0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F,
  0x1F, 0x07, 0xC7, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x83,
  0xF3, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x81,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0x8F, 0x83, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x1F, 0x07, 0xC7, 0xC7,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xE1, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xF0, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0x78,
  0xF8, 0x3E, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x3F, 0x3F, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3F,
  0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x78, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x3E, 0xF9,
  0xF8, 0xFB, 0xE7, 0xE3, 0xEF, 0x9F, 0x9F, 0x3E, 0xFE, 0x7C, 0xFB, 0xF9,
  0xF3, 0xEF, 0xE7, 0x8F, 0xFF, 0xBE, 0x3F, 0xFE, 0xF8, 0xFF, 0xFB, 0xC3,
  0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xF8,
  0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0xFD, 0xF0, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F, 0x8F,
  0x07, 0xC7, 0x87, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x00, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78,
  0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x80, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x71, 0xEF, 0x39, 0xEF, 0x1D,
  0xC3, 0xF8, 0x70, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x7C, 0x7C,
  0x3E, 0x1E, 0x0E, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C,
  0xF9, 0xF0, 0x07, 0xC3, 0xFF, 0x3F, 0xF9, 0xFF, 0xE7, 0xCF, 0xBE, 0x3E,
  0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xFC, 0x3C, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7,
  0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xF3, 0xE0, 0x07, 0xC0, 0xFF, 0x8F,
  0xFC, 0xFF, 0xF7, 0xCF, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE1, 0xEF, 0x1F, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x3E, 0x3F, 0xBC, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF8,
  0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3D, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x79, 0xE1,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8,
  0x63, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0xC7, 0xFC, 0xFF,
  0xCF, 0xFC, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xDF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x7C, 0x7C,
  0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x61, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xE3, 0xE7, 0x87,
  0xDF, 0x0F, 0xBE, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF,
  0x87, 0xDF, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x07, 0x07, 0xC3,
  0xE1, 0xF0, 0x70, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0,
  0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x3F, 0x1F, 0x1F,
  0x0F, 0x9F, 0x87, 0xDF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0x9F, 0x07,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0,
  0xF8, 0x00, 0x1E, 0x78, 0xF0, 0x7F, 0xF7, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3E, 0x3E, 0x7C, 0xF8, 0xF8, 0xF3, 0xE3, 0xC7, 0xCF, 0x1F, 0x1F,
  0x7C, 0x7C, 0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xC7, 0xDF, 0x1F, 0x1E, 0x78,
  0x78, 0xFB, 0xE3, 0xE3, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0xF8, 0xF8,
  0xF8, 0x1E, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7,
  0xCF, 0x0F, 0xBE, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF,
  0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x07, 0xE0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x07, 0xBC, 0x3E, 0xF8, 0xFB, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x1F, 0x80, 0x0F, 0x7C, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D,
  0xF0, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0x3E, 0x7F, 0x78, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF8, 0xF9, 0xE1, 0xF3, 0xC3, 0xE7,
  0x87, 0xCF, 0x9F, 0x9F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x1E, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3C, 0x7C, 0xF1,
  0xF3, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x3C, 0x3E, 0xF8,
  0xFB, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1E, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0x80,
  0x3C, 0x3E, 0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1F, 0x7C, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F,
  0x9F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF0, 0xF8, 0xFF, 0xC7, 0xFE,
  0x7D, 0xF3, 0xEF, 0x9F, 0x7D, 0xF3, 0xEF, 0x9F, 0x78, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x00,
  0xF1, 0xE3, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x79, 0xF3, 0xEF, 0x3E, 0x79,
  0xEF, 0xCF, 0x3D, 0xFB, 0xE7, 0xBF, 0x78, 0xFF, 0xEF, 0x1F, 0xDF, 0xC3,
  0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xC0, 0xF0, 0x78, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x0F, 0x3E, 0x0F,
  0x7C, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C,
  0x78, 0xF8, 0x7C, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC1,
  0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x80, 0xE0, 0x7C, 0x3E, 0x0F, 0x03, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x0F, 0xC3, 0xE0,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0x20, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x04,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x07, 0xC3, 0xF1, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3C,
  0x0E, 0x03, 0x00, 0x1E, 0x00, 0x7E, 0x1D, 0xFE, 0x7B, 0xFF, 0xFF, 0x3F,
  0xDE, 0x3F, 0x80, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 10, 9, 10, 2, -25 },
  { 39, 17, 23, 17, 0, -23 },
  { 88, 15, 29, 16, 1, -26 },
  { 143, 15, 23, 21, 3, -23 },
  { 187, 17, 23, 19, 0, -23 },
  { 236, 5, 9, 5, 2, -25 },
  { 242, 11, 33, 10, 1, -26 },
  { 288, 10, 33, 10, -1, -26 },
  { 330, 14, 14, 15, 2, -23 },
  { 355, 14, 16, 15, 1, -19 },
  { 383, 7, 10, 8, -2, -4 },
  { 392, 9, 4, 13, 2, -12 },
  { 397, 5, 5, 10, 1, -5 },
  { 401, 14, 25, 10, -2, -23 },
  { 445, 15, 23, 16, 1, -23 },
  { 489, 10, 23, 16, 4, -23 },
  { 518, 16, 23, 16, 0, -23 },
  { 564, 16, 23, 16, 0, -23 },
  { 610, 16, 23, 16, 0, -23 },
  { 656, 15, 23, 16, 1, -23 },
  { 700, 14, 23, 16, 1, -23 },
  { 741, 16, 23, 16, 1, -23 },
  { 787, 15, 23, 16, 1, -23 },
  { 831, 14, 23, 16, 2, -23 },
  { 872, 7, 18, 9, 1, -18 },
  { 888, 9, 24, 9, -1, -18 },
  { 915, 13, 16, 14, 1, -18 },
  { 941, 14, 11, 16, 1, -16 },
  { 961, 14, 16, 14, 0, -18 },
  { 989, 13, 23, 15, 2, -23 },
  { 1027, 23, 30, 25, 0, -23 },
  { 1114, 19, 23, 19, -2, -23 },
  { 1169, 18, 23, 18, 0, -23 },
  { 1221, 17, 23, 18, 1, -23 },
  { 1270, 18, 23, 18, 0, -23 },
  { 1322, 17, 23, 16, 0, -23 },
  { 1371, 17, 23, 15, 0, -23 },
  { 1420, 18, 23, 19, 1, -23 },
  { 1472, 20, 23, 20, 0, -23 },
  { 1530, 9, 23, 9, 0, -23 },
  { 1556, 16, 23, 16, 0, -23 },
  { 1602, 21, 23, 18, 0, -23 },
  { 1663, 14, 23, 15, 0, -23 },
  { 1704, 25, 23, 24, 0, -23 },
  { 1776, 20, 23, 20, 0, -23 },
  { 1834, 18, 23, 19, 1, -23 },
  { 1886, 18, 23, 18, 0, -23 },
  { 1938, 18, 27, 19, 1, -23 },
  { 1999, 18, 23, 18, 0, -23 },
  { 2051, 17, 23, 17, 1, -23 },
  { 2100, 17, 23, 18, 2, -23 },
  { 2149, 18, 23, 18, 1, -23 },
  { 2201, 19, 23, 19, 2, -23 },
  { 2256, 22, 23, 24, 3, -23 },
  { 2320, 21, 23, 18, -1, -23 },
  { 2381, 17, 23, 18, 3, -23 },
  { 2430, 19, 23, 17, -1, -23 },
  { 2485, 12, 33, 9, -1, -27 },
  { 2535, 9, 25, 12, 2, -23 },
  { 2564, 12, 33, 9, -2, -27 },
  { 2614, 11, 12, 13, 1, -23 },
  { 2631, 13, 4, 13, -2, 0 },
  { 2638, 8, 5, 11, 3, -25 },
  { 2643, 14, 17, 15, 0, -17 },
  { 2673, 15, 25, 16, 0, -25 },
  { 2720, 13, 17, 15, 1, -17 },
  { 2748, 16, 25, 16, 1, -25 },
  { 2798, 14, 17, 15, 1, -17 },
  { 2828, 12, 25, 11, 1, -25 },
  { 2866, 16, 24, 16, 0, -17 },
  { 2914, 15, 25, 16, 0, -25 },
  { 2961, 9, 24, 8, 0, -24 },
  { 2988, 13, 31, 8, -4, -24 },
  { 3039, 17, 25, 16, 0, -25 },
  { 3093, 9, 25, 8, 0, -25 },
  { 3122, 22, 17, 24, 0, -17 },
  { 3169, 15, 17, 16, 0, -17 },
  { 3201, 14, 17, 16, 1, -17 },
  { 3231, 16, 24, 16, -1, -17 },
  { 3279, 15, 24, 16, 1, -17 },
  { 3324, 12, 17, 11, 0, -17 },
  { 3350, 14, 17, 15, 0, -17 },
  { 3380, 10, 22, 10, 1, -22 },
  { 3408, 15, 17, 16, 1, -17 },
  { 3440, 13, 17, 15, 2, -17 },
  { 3468, 19, 17, 20, 2, -17 },
  { 3509, 16, 17, 15, -1, -17 },
  { 3543, 17, 24, 15, -1, -17 },
  { 3594, 16, 17, 15, -1, -17 },
  { 3628, 10, 32, 9, 1, -26 },
  { 3668, 8, 27, 8, 0, -23 },
  { 3695, 10, 32, 9, -1, -26 },
  { 3735, 15, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC33PT7B_H_
