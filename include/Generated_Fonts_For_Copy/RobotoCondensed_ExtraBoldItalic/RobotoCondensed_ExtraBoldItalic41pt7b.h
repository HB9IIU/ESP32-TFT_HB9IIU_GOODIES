#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC41PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x07, 0x00, 0x3C, 0xF9, 0xE7, 0x9F, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0x70, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x38, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x1C, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x38, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0x1C, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0,
  0x03, 0x9E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xF9, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFE, 0x3F, 0x1F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x8F, 0x1C, 0x3D, 0xE3, 0xC7, 0xBC, 0x79,
  0xE7, 0x8E, 0x78, 0xE3, 0xCF, 0x1E, 0x7B, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xF7, 0x80, 0x7D, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x78, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x3D, 0xFF, 0x87, 0xF8, 0xF1, 0xEF, 0x1E, 0x79, 0xE3,
  0xCF, 0x3C, 0x7B, 0xC7, 0x8F, 0xF0, 0xF3, 0xCC, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE3, 0xE1, 0xFF, 0x1F, 0x1F,
  0xFC, 0xF9, 0xFF, 0xEF, 0xDF, 0x9F, 0xFC, 0xFC, 0xFF, 0xE7, 0xE3, 0xFF,
  0x3F, 0x1F, 0xF1, 0xF8, 0x7F, 0x8F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7E, 0x3F, 0x00, 0x3C, 0xF3,
  0xDF, 0x7D, 0xE7, 0x9E, 0x7B, 0xCF, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3C,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0x80,
  0x04, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x38, 0x67, 0xCE,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0x9E, 0x07, 0xC7, 0x81, 0xF0, 0xF0, 0x38, 0x38, 0x00,
  0x04, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E,
  0x3E, 0x1E, 0x02, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0x00,
  0xFB, 0xF7, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E,
  0x7E, 0x0F, 0x9F, 0x83, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0xBF,
  0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC3,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xF1, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x18, 0x07, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x63, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xF1, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE3,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7D,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x70,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF3, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0xDF, 0x83,
  0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0x7C, 0x1F, 0x9F, 0x07, 0xE7, 0xE1, 0xF9,
  0xF8, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0x9F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xE7, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x02, 0x07, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x3E, 0x3F, 0x1F, 0xCF, 0xE7, 0xE1, 0xE0, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x10, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0x1C, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x0E, 0x0F, 0x03, 0xE0, 0xF1,
  0xE0, 0xFF, 0x8F, 0x1E, 0x1F, 0xFC, 0xF3, 0xC3, 0xFF, 0x87, 0x3C, 0x7C,
  0x78, 0x77, 0x87, 0x87, 0x87, 0x78, 0xF8, 0x78, 0xF7, 0x8F, 0x0F, 0x0F,
  0xF0, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0, 0xEF, 0x1E,
  0x1E, 0x0E, 0xF1, 0xE1, 0xE1, 0xEF, 0x1E, 0x1E, 0x1E, 0xE1, 0xE3, 0xE1,
  0xCE, 0x1E, 0x3E, 0x3C, 0xE1, 0xFF, 0xE7, 0x8E, 0x1F, 0xFF, 0xF0, 0xF0,
  0xFC, 0xFE, 0x0F, 0x07, 0x87, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0x3F,
  0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F,
  0x8F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F,
  0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0xE7, 0xE1, 0xFF, 0x9F, 0x87, 0xFE, 0x7E,
  0x1F, 0xF9, 0xF8, 0x7F, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x07,
  0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0xC0, 0xFC, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F,
  0xC0, 0x1F, 0x9F, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xEF,
  0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x01,
  0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xBF, 0x07, 0xCF, 0x1F, 0x7E, 0x1F, 0x9E,
  0x7D, 0xF8, 0x3F, 0x3C, 0xFB, 0xF0, 0x7E, 0x79, 0xE7, 0xE0, 0xFC, 0xF7,
  0xCF, 0xC1, 0xF9, 0xEF, 0x1F, 0x87, 0xF3, 0xFE, 0x7E, 0x0F, 0xC7, 0xFC,
  0xFC, 0x1F, 0x8F, 0xF1, 0xF8, 0x3F, 0x1F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF8, 0x7C, 0x3F, 0x07, 0xE0, 0xF8, 0x7E,
  0x0F, 0xC1, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xFC, 0x07, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0x81, 0xF8,
  0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x7E, 0x0F, 0xF8, 0x7F, 0x0F, 0xFC, 0x3F,
  0x87, 0xEF, 0x1F, 0x83, 0xF7, 0x8F, 0xC1, 0xFB, 0xC7, 0xE0, 0xFD, 0xE3,
  0xF0, 0x7E, 0x7B, 0xF8, 0x7F, 0x3D, 0xF8, 0x3F, 0x1E, 0xFC, 0x1F, 0x8F,
  0x7E, 0x0F, 0xC3, 0xFF, 0x07, 0xE1, 0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xF8,
  0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFC, 0x0F, 0xF0, 0x7E, 0x07, 0xF8, 0x3F,
  0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD,
  0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x7F,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F,
  0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F,
  0xC3, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xF1, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F,
  0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x1F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x03, 0xE1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0x83, 0xFF, 0xF0, 0xFC, 0x1F, 0x9F, 0x87, 0xE0, 0xFC, 0xF8,
  0x3F, 0x0F, 0xE7, 0xC3, 0xF8, 0x7E, 0x3E, 0x1F, 0xC3, 0xF1, 0xF0, 0xFE,
  0x3F, 0x8F, 0x8F, 0xF1, 0xF8, 0x7C, 0x7F, 0x8F, 0xC3, 0xE3, 0xFC, 0x7E,
  0x1F, 0x3F, 0xE7, 0xE0, 0xF9, 0xFF, 0x3F, 0x07, 0xCF, 0xF9, 0xF8, 0x3E,
  0xFF, 0xDF, 0x81, 0xF7, 0xFE, 0xFC, 0x0F, 0xBF, 0xF7, 0xE0, 0x7F, 0xEF,
  0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0x87, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xEF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E,
  0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x83, 0xDE, 0x1F, 0x78, 0x79, 0xE3, 0xE3, 0xCF, 0x8F,
  0x7C, 0x3D, 0xF0, 0xFF, 0x83, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF9, 0xFC, 0xFC,
  0xFC, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFB, 0xE0, 0xF9, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF7, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xE3, 0xF1, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFB, 0xFC, 0x3E, 0x3E, 0x00,
  0x03, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0,
  0xF9, 0xF8, 0x7C, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0xFC,
  0x0F, 0xEF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFB, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x20, 0x7E, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE7, 0x81, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF0, 0x03, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x87, 0xE3, 0xFC, 0x3F, 0x1F, 0xC1, 0xF9, 0xFC,
  0x0F, 0xDF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x1F, 0x9F, 0x0F, 0x81, 0xFF,
  0xF9, 0xFC, 0x1F, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF1, 0xF8, 0xFE, 0x3F, 0x3F, 0x0F, 0xC3, 0xF3, 0xF0, 0xFC, 0x3F, 0x3F,
  0x0F, 0xC3, 0xF3, 0xF0, 0xFC, 0x3F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87, 0xE7,
  0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF0, 0xFC, 0xFC, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0xFC,
  0x1F, 0x9F, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xBF, 0x07,
  0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF7, 0xF8, 0x1F,
  0x9F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC7, 0xC1, 0xFC, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE,
  0x3F, 0x9F, 0x87, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3E, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F,
  0xBC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xFC, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xFD, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7F, 0x7F, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x87,
  0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3E, 0xFC, 0x00, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xE3, 0xE3, 0xF1,
  0xF1, 0xF8, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x3C,
  0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3E, 0xFC, 0x7C, 0x7E, 0xFC, 0xFC,
  0x7E, 0xFC, 0xFC, 0x7C, 0xFD, 0xFC, 0xFC, 0xFD, 0xFE, 0xF8, 0x7D, 0xFE,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xDF, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xDF,
  0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x00, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE0,
  0xFC, 0xFC, 0x07, 0xDF, 0xC0, 0x7D, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xBE, 0x03, 0xF3,
  0xF0, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE,
  0x07, 0xC7, 0xE0, 0x3E, 0x7F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7D,
  0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x00,
  0x30, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x07, 0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x04, 0x00, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x00, 0x02, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xC0, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x3C, 0xFF, 0x87, 0xBF, 0xF9, 0xF7, 0xFF, 0xFE,
  0xF9, 0xFF, 0x9E, 0x1F, 0xF7, 0xC1, 0xFC, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 29, 10, 1, -29 },
  { 41, 13, 11, 13, 2, -31 },
  { 59, 21, 29, 21, 0, -29 },
  { 136, 19, 37, 20, 1, -33 },
  { 224, 19, 29, 25, 4, -29 },
  { 293, 21, 29, 23, 0, -29 },
  { 370, 6, 11, 6, 2, -31 },
  { 379, 13, 41, 13, 2, -32 },
  { 446, 13, 41, 13, -2, -32 },
  { 513, 18, 18, 18, 2, -29 },
  { 554, 17, 22, 19, 1, -25 },
  { 601, 9, 13, 10, -2, -5 },
  { 616, 11, 5, 16, 2, -15 },
  { 623, 7, 7, 12, 1, -7 },
  { 630, 18, 32, 13, -3, -29 },
  { 702, 18, 29, 20, 2, -29 },
  { 768, 13, 29, 20, 4, -29 },
  { 816, 20, 29, 20, 0, -29 },
  { 889, 20, 29, 20, 0, -29 },
  { 962, 19, 29, 20, 1, -29 },
  { 1031, 19, 29, 20, 1, -29 },
  { 1100, 18, 29, 20, 1, -29 },
  { 1166, 19, 29, 20, 2, -29 },
  { 1235, 19, 29, 20, 1, -29 },
  { 1304, 16, 29, 20, 3, -29 },
  { 1362, 9, 23, 11, 1, -23 },
  { 1388, 12, 31, 11, -2, -23 },
  { 1435, 16, 19, 18, 1, -22 },
  { 1473, 18, 14, 20, 1, -20 },
  { 1505, 16, 20, 18, 1, -22 },
  { 1545, 15, 29, 18, 3, -29 },
  { 1600, 28, 37, 30, 1, -28 },
  { 1730, 23, 29, 24, -2, -29 },
  { 1814, 22, 29, 22, 0, -29 },
  { 1894, 22, 29, 23, 1, -29 },
  { 1974, 22, 29, 22, 0, -29 },
  { 2054, 22, 29, 19, 0, -29 },
  { 2134, 21, 29, 19, 0, -29 },
  { 2211, 22, 29, 23, 1, -29 },
  { 2291, 25, 29, 24, 0, -29 },
  { 2382, 12, 29, 11, 0, -29 },
  { 2426, 20, 29, 20, 0, -29 },
  { 2499, 25, 29, 22, 0, -29 },
  { 2590, 17, 29, 19, 0, -29 },
  { 2652, 31, 29, 30, 0, -29 },
  { 2765, 25, 29, 24, 0, -29 },
  { 2856, 22, 29, 24, 1, -29 },
  { 2936, 23, 29, 23, 0, -29 },
  { 3020, 22, 34, 24, 1, -29 },
  { 3114, 22, 29, 22, 0, -29 },
  { 3194, 21, 29, 22, 1, -29 },
  { 3271, 21, 29, 22, 3, -29 },
  { 3348, 23, 29, 23, 1, -29 },
  { 3432, 23, 29, 23, 3, -29 },
  { 3516, 29, 29, 30, 3, -29 },
  { 3622, 27, 29, 22, -2, -29 },
  { 3720, 22, 29, 22, 3, -29 },
  { 3800, 24, 29, 21, -1, -29 },
  { 3887, 14, 41, 11, -1, -34 },
  { 3959, 10, 32, 15, 3, -29 },
  { 3999, 14, 41, 11, -2, -34 },
  { 4071, 14, 15, 16, 1, -29 },
  { 4098, 16, 5, 16, -3, 0 },
  { 4108, 9, 6, 13, 4, -31 },
  { 4115, 17, 22, 19, 0, -22 },
  { 4162, 19, 31, 20, 0, -31 },
  { 4236, 17, 22, 18, 1, -22 },
  { 4283, 20, 31, 20, 1, -31 },
  { 4361, 17, 22, 19, 1, -22 },
  { 4408, 15, 31, 13, 1, -31 },
  { 4467, 20, 30, 20, 0, -22 },
  { 4542, 18, 31, 20, 0, -31 },
  { 4612, 11, 30, 10, 0, -30 },
  { 4654, 16, 38, 10, -5, -30 },
  { 4730, 21, 31, 19, 0, -31 },
  { 4812, 11, 31, 10, 0, -31 },
  { 4855, 28, 22, 29, 0, -22 },
  { 4932, 18, 22, 20, 0, -22 },
  { 4982, 18, 22, 20, 1, -22 },
  { 5032, 21, 30, 20, -2, -22 },
  { 5111, 19, 30, 20, 1, -22 },
  { 5183, 14, 22, 13, 0, -22 },
  { 5222, 17, 22, 18, 0, -22 },
  { 5269, 12, 27, 12, 1, -27 },
  { 5310, 19, 22, 20, 1, -22 },
  { 5363, 17, 22, 18, 2, -22 },
  { 5410, 24, 22, 25, 2, -22 },
  { 5476, 20, 22, 18, -1, -22 },
  { 5531, 21, 30, 18, -1, -22 },
  { 5610, 19, 22, 18, -1, -22 },
  { 5663, 12, 39, 12, 1, -32 },
  { 5722, 9, 34, 10, 1, -29 },
  { 5761, 12, 39, 12, -1, -32 },
  { 5820, 19, 9, 22, 1, -16 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC41PT7B_H_
