#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC35PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0x38, 0x00, 0x79, 0xDE, 0x77,
  0x3D, 0xCF, 0x73, 0xFC, 0xEF, 0x3B, 0x8E, 0xE3, 0xB9, 0xC0, 0x00, 0x73,
  0x80, 0x3D, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x39, 0xC0, 0x1E,
  0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF7, 0x81, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x81, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x70, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xBF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0E, 0x70, 0xCF, 0x38, 0xF7, 0x9C, 0x73,
  0x8E, 0x71, 0xC7, 0x78, 0xF7, 0xF8, 0x3F, 0xB8, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0x1C, 0x00, 0x1D, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0E, 0xE7, 0x0F,
  0xF3, 0x8F, 0x79, 0xC7, 0x38, 0xE7, 0x1C, 0x73, 0x8F, 0x78, 0x83, 0xFC,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F,
  0xBE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE3, 0xC7, 0xF8,
  0xF3, 0xFF, 0x7D, 0xF7, 0xDF, 0x7C, 0xFF, 0x9F, 0x3F, 0xEF, 0xC7, 0xF1,
  0xF1, 0xFC, 0x7C, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xCF, 0x80, 0x7B, 0xDE, 0xF7, 0x3B, 0xDE, 0xE7, 0x00, 0x00, 0x40, 0x70,
  0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0x80, 0x20, 0x02, 0x00, 0x30, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x04, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x06, 0x38, 0xDF, 0x77, 0xBF,
  0xFF, 0x9F, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x01, 0xEF, 0x07, 0x8E,
  0x0E, 0x1C, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C,
  0x7C, 0x78, 0xF0, 0x20, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0xEF, 0xBE,
  0xF9, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0x3E, 0x3E, 0x1E, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC,
  0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x78, 0x7C, 0x7C, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x60, 0x78, 0x7F, 0x3F,
  0xEF, 0xFD, 0xFF, 0xBD, 0xF4, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xE1, 0xF9, 0xF0, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8,
  0xFC, 0x7C, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x3E, 0x0F, 0x9F, 0x8F, 0xC7, 0xEF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xE7, 0xC1, 0xF7, 0xE0, 0xF3, 0xE0,
  0xF9, 0xF0, 0xF8, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC,
  0x1C, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF,
  0xE7, 0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xF3, 0xC3, 0xE7, 0xCF, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F,
  0x80, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0x3F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E,
  0x3E, 0x1F, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C,
  0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFC,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x0F, 0x3E, 0x1E,
  0xFC, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xE3, 0xE7, 0xCF, 0xCF, 0xFF, 0x9F,
  0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0x0C, 0x1E, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xF8,
  0xF8, 0xFC, 0xF8, 0x70, 0x01, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x60, 0x0F, 0x80,
  0xFE, 0x0F, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xC0, 0xF8, 0x03, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x20,
  0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xC0, 0x10,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7E, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9F, 0xFE, 0x7E, 0xFB, 0xF3, 0xFF, 0x8F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x1F, 0x0E, 0x1E, 0x1F, 0xE3, 0x8E, 0x1F, 0xF1, 0xCF, 0x1F,
  0x78, 0xE7, 0x9E, 0x3C, 0x73, 0x8F, 0x1C, 0x3B, 0xC7, 0x0E, 0x1D, 0xE7,
  0x87, 0x1E, 0xE3, 0xC7, 0x8E, 0x71, 0xE3, 0xC7, 0x38, 0xF1, 0xC3, 0x9C,
  0x71, 0xE1, 0xDE, 0x38, 0xF1, 0xCF, 0x1E, 0xF9, 0xE7, 0x8F, 0xFF, 0xE1,
  0xC7, 0xEF, 0xE0, 0xE1, 0xE3, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x60, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xC0, 0x1F,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x01, 0xF3,
  0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC7, 0xF0,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFD, 0xFC, 0x3E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0x9F, 0x03, 0xF3, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE7, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xF9, 0xFC, 0x3F, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E,
  0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x7E, 0x3E, 0x1F, 0x87, 0xC7, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFC, 0xFC, 0x3E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xFC, 0xF8,
  0xFF, 0x9F, 0x1F, 0xF7, 0xE3, 0xFC, 0xFC, 0x0F, 0x9F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x0F, 0xC7, 0xF7, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F,
  0x80, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x7C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x8F, 0x87, 0xCF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0x7F, 0x03,
  0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x1E, 0xF8, 0xFB, 0xC7, 0xBE, 0x3E,
  0xF3, 0xFF, 0x0F, 0xBC, 0xF7, 0xC3, 0xEF, 0x3D, 0xF0, 0xFB, 0xDE, 0x7C,
  0x7E, 0x77, 0xBF, 0x1F, 0x9F, 0xCF, 0x87, 0xC7, 0xF3, 0xE1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x9F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1,
  0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFE, 0x1F, 0x8F, 0xF0, 0xFC, 0x7F, 0x87,
  0xC3, 0xFC, 0x3E, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xDC, 0xFC, 0x7E,
  0xE7, 0xE3, 0xE7, 0xBE, 0x1F, 0x3D, 0xF0, 0xF9, 0xEF, 0x87, 0xC7, 0x7C,
  0x7E, 0x3F, 0xE3, 0xF1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x3F, 0x87, 0xC1,
  0xFC, 0x3E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFD, 0xFC,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x7D,
  0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7,
  0xF7, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0xFE,
  0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC,
  0x7C, 0x1F, 0x9F, 0x8F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFD, 0xFC,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x7D,
  0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xF7,
  0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7,
  0xF7, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8,
  0x7C, 0x3F, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x9F, 0x8F,
  0xC3, 0xE3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xFE, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7E, 0x1F, 0x87, 0xE7, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x07,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3E,
  0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x3F, 0xF8, 0x7C, 0x3E,
  0xF8, 0xFC, 0x3E, 0xF8, 0xFC, 0x7E, 0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x7C,
  0xF9, 0xFC, 0xFC, 0xF9, 0xFC, 0xF8, 0xF9, 0xFC, 0xF8, 0xFB, 0xFC, 0xF8,
  0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xF0, 0xFF, 0xFD, 0xF0, 0xFF, 0xBF, 0xE0,
  0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0x80,
  0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0,
  0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E,
  0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7,
  0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xF9, 0xF0, 0xFC,
  0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC0, 0xF3, 0xF0, 0x3C, 0xF8, 0x0F,
  0xBE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7E, 0x0F, 0xE1, 0xEE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8F, 0x78, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7,
  0xC0, 0x0F, 0x83, 0xFE, 0x1F, 0xFC, 0xFF, 0xF9, 0xF9, 0xF7, 0xE3, 0xEF,
  0x87, 0xDF, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x3D, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F,
  0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFB,
  0xF8, 0xF9, 0xE0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x7C, 0x7D,
  0xF1, 0xFF, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x3E,
  0xF8, 0xFB, 0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x0F, 0xBF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xE7, 0xE7, 0xE1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xE7, 0xE7, 0xCF, 0x87, 0xBE, 0x0F, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x8E, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F,
  0xC1, 0xF8, 0x1F, 0x01, 0xF0, 0x7F, 0xE7, 0xFE, 0xFF, 0xCF, 0xFC, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xCF, 0x87, 0xF7,
  0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xF3, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xF3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x1F,
  0x00, 0x1F, 0x86, 0x1F, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x70,
  0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x87,
  0xCF, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0x1F,
  0x7C, 0x7C, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F,
  0x3F, 0xBF, 0x3E, 0x3E, 0x1F, 0x3E, 0x3E, 0x1F, 0x3E, 0x3E, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0x7C, 0xF8, 0x7C, 0x7C, 0xF8,
  0xFC, 0x7C, 0xF8, 0xF8, 0x7C, 0x1F, 0x7C, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0x07, 0xE0, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE7, 0xE7, 0xCF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x9F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x00, 0x0F, 0xBC, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1,
  0xF9, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x0F,
  0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF9, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7D, 0xFC, 0x3E, 0x78, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x1F,
  0xDE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3E, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x1F,
  0x71, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xCF, 0x87, 0x9F, 0x1F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00,
  0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xFC, 0x7F, 0x1F, 0x81, 0xE0, 0x3E, 0x1F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0x3E,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0xF8, 0x7B, 0xE1, 0xEF, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8,
  0x00, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF9, 0xF1, 0xEF, 0x9F, 0x3E, 0xFB,
  0xF3, 0xEF, 0xBF, 0x3C, 0xFB, 0xF7, 0xCF, 0x7F, 0x78, 0xF7, 0xF7, 0x8F,
  0xF7, 0xF8, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x8F, 0x8F, 0x83, 0xE7, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0xF9, 0xE0, 0xFC, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E,
  0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3F,
  0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0xC0,
  0x70, 0x3C, 0x1F, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x8F, 0xC3, 0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0xC0, 0x60, 0x08, 0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x04, 0x01, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xC3, 0xF0, 0xF8, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0x80, 0xC0,
  0x00, 0x1E, 0x00, 0x3F, 0x87, 0x7F, 0x8F, 0x7F, 0xCF, 0x7B, 0xFF, 0xF1,
  0xFE, 0xF0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 10, 10, 11, 2, -26 },
  { 46, 18, 25, 18, 0, -25 },
  { 103, 16, 32, 17, 1, -29 },
  { 167, 17, 25, 22, 3, -25 },
  { 221, 18, 25, 20, 0, -25 },
  { 278, 5, 10, 5, 2, -26 },
  { 285, 10, 36, 11, 2, -28 },
  { 330, 12, 36, 11, -2, -28 },
  { 384, 15, 15, 16, 2, -25 },
  { 413, 15, 19, 16, 1, -21 },
  { 449, 8, 11, 9, -2, -4 },
  { 460, 9, 4, 13, 2, -13 },
  { 465, 6, 6, 10, 1, -6 },
  { 470, 15, 27, 11, -2, -25 },
  { 521, 16, 25, 17, 1, -25 },
  { 571, 11, 25, 17, 4, -25 },
  { 606, 17, 25, 17, 0, -25 },
  { 660, 17, 25, 17, 0, -25 },
  { 714, 17, 25, 17, 0, -25 },
  { 768, 16, 25, 17, 1, -25 },
  { 818, 15, 25, 17, 1, -25 },
  { 865, 17, 25, 17, 1, -25 },
  { 919, 16, 25, 17, 1, -25 },
  { 969, 15, 25, 17, 2, -25 },
  { 1016, 8, 20, 10, 1, -20 },
  { 1036, 11, 27, 9, -2, -20 },
  { 1074, 14, 17, 15, 1, -19 },
  { 1104, 15, 12, 17, 1, -17 },
  { 1127, 15, 17, 15, 0, -19 },
  { 1159, 14, 25, 15, 2, -25 },
  { 1203, 25, 32, 26, 0, -24 },
  { 1303, 20, 25, 20, -2, -25 },
  { 1366, 19, 25, 19, 0, -25 },
  { 1426, 19, 25, 19, 1, -25 },
  { 1486, 19, 25, 19, 0, -25 },
  { 1546, 18, 25, 17, 0, -25 },
  { 1603, 18, 25, 16, 0, -25 },
  { 1660, 19, 25, 20, 1, -25 },
  { 1720, 22, 25, 21, 0, -25 },
  { 1789, 10, 25, 9, 0, -25 },
  { 1821, 17, 25, 17, 0, -25 },
  { 1875, 22, 25, 19, 0, -25 },
  { 1944, 14, 25, 16, 0, -25 },
  { 1988, 26, 25, 26, 0, -25 },
  { 2070, 21, 25, 21, 0, -25 },
  { 2136, 19, 25, 20, 1, -25 },
  { 2196, 19, 25, 19, 0, -25 },
  { 2256, 19, 30, 20, 1, -25 },
  { 2328, 19, 25, 19, 0, -25 },
  { 2388, 18, 25, 19, 1, -25 },
  { 2445, 17, 25, 19, 3, -25 },
  { 2499, 19, 25, 20, 1, -25 },
  { 2559, 19, 25, 20, 3, -25 },
  { 2619, 24, 25, 25, 3, -25 },
  { 2694, 22, 25, 19, -1, -25 },
  { 2763, 18, 25, 19, 3, -25 },
  { 2820, 21, 25, 18, -1, -25 },
  { 2886, 12, 35, 9, -1, -29 },
  { 2939, 8, 27, 13, 3, -25 },
  { 2966, 12, 35, 9, -2, -29 },
  { 3019, 12, 12, 13, 1, -25 },
  { 3037, 13, 4, 14, -2, 0 },
  { 3044, 8, 5, 11, 3, -26 },
  { 3049, 15, 18, 16, 0, -18 },
  { 3083, 16, 26, 17, 0, -26 },
  { 3135, 14, 18, 16, 1, -18 },
  { 3167, 17, 26, 17, 1, -26 },
  { 3223, 15, 18, 16, 1, -18 },
  { 3257, 12, 26, 11, 1, -26 },
  { 3296, 17, 25, 17, 0, -18 },
  { 3350, 16, 26, 17, 0, -26 },
  { 3402, 9, 25, 9, 0, -25 },
  { 3431, 13, 32, 9, -4, -25 },
  { 3483, 18, 26, 16, 0, -26 },
  { 3542, 10, 26, 9, 0, -26 },
  { 3575, 24, 18, 25, 0, -18 },
  { 3629, 16, 18, 17, 0, -18 },
  { 3665, 15, 18, 17, 1, -18 },
  { 3699, 17, 25, 17, -1, -18 },
  { 3753, 16, 25, 17, 1, -18 },
  { 3803, 12, 18, 11, 0, -18 },
  { 3830, 15, 18, 15, 0, -18 },
  { 3864, 10, 23, 11, 1, -23 },
  { 3893, 16, 18, 17, 1, -18 },
  { 3929, 14, 18, 15, 2, -18 },
  { 3961, 20, 18, 21, 2, -18 },
  { 4006, 17, 18, 15, -1, -18 },
  { 4045, 18, 25, 15, -1, -18 },
  { 4102, 16, 18, 15, -1, -18 },
  { 4138, 10, 33, 10, 1, -27 },
  { 4180, 7, 30, 9, 1, -25 },
  { 4207, 10, 33, 10, -1, -27 },
  { 4249, 16, 8, 19, 1, -14 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC35PT7B_H_
