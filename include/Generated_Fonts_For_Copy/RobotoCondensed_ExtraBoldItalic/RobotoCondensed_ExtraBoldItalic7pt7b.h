#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC7PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0x80, 0xF0, 0x07, 0x6E, 0xC0, 0x2D, 0xBB, 0xD0, 0x99, 0x76,
  0x66, 0x4A, 0xE0, 0xC0, 0x16, 0xA8, 0x15, 0x58, 0x0E, 0x80, 0x5D, 0x20,
  0xC0, 0x40, 0x80, 0x09, 0x48, 0x6E, 0xDE, 0xDE, 0x80, 0x74, 0xAE, 0x65,
  0x9E, 0x2D, 0xF2, 0x6B, 0x9E, 0x6B, 0xD6, 0x72, 0x24, 0x40, 0x6D, 0xDE,
  0x6D, 0x94, 0x42, 0x42, 0x80, 0x3B, 0x00, 0x7C, 0x0F, 0x00, 0x65, 0x04,
  0x32, 0x6F, 0xBF, 0x41, 0x80, 0x26, 0x6E, 0x90, 0x65, 0xEA, 0xE0, 0x75,
  0x89, 0x60, 0x65, 0x9A, 0xE0, 0x74, 0xE8, 0xE0, 0x64, 0xE8, 0x80, 0x75,
  0xB9, 0x60, 0x55, 0xF9, 0xB0, 0x5E, 0x80, 0x22, 0x22, 0xC0, 0x56, 0xEA,
  0xA0, 0x4A, 0x4E, 0x4A, 0xEF, 0x5B, 0x80, 0x55, 0xBB, 0xB0, 0x75, 0x99,
  0x60, 0x75, 0xF8, 0x80, 0x75, 0x99, 0x62, 0x75, 0xEA, 0xA0, 0x65, 0x6A,
  0xE0, 0xEA, 0x48, 0x55, 0x9A, 0xE0, 0xB7, 0x68, 0xDD, 0xDA, 0xA0, 0x56,
  0x66, 0xA0, 0xBB, 0x48, 0x72, 0x44, 0xE0, 0x56, 0xA8, 0xF8, 0x57, 0xA8,
  0x4A, 0x80, 0xC0, 0x80, 0x67, 0xF0, 0x4E, 0xDE, 0x76, 0x70, 0x26, 0xAA,
  0xE0, 0x77, 0xF0, 0x79, 0x48, 0x76, 0xFE, 0x4E, 0xDA, 0x5A, 0x80, 0x25,
  0x24, 0x80, 0x46, 0xEC, 0xA0, 0x5A, 0x80, 0x7D, 0x6B, 0x60, 0x76, 0xD0,
  0x76, 0xF0, 0x76, 0xF8, 0x76, 0xF2, 0x6A, 0x71, 0xE0, 0x76, 0xC0, 0x76,
  0xF0, 0xB5, 0x20, 0xBB, 0xFE, 0xAD, 0x50, 0xB5, 0x28, 0x00, 0x6D, 0x70,
  0x5A, 0xA0, 0x5A, 0xA0, 0x56, 0xA0, 0x4A,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 7, 3, 0, -6 },
  { 10, 3, 5, 4, 1, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 3, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 5, 2, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 2, 5, 3, 1, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 4, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 2, 5, 2, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 2, 3, 0, -3 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 5, 7, 5, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 3, 0, -5 },
  { 80, 4, 5, 3, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 2, 5, 2, 0, -5 },
  { 91, 4, 5, 3, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 5, 5, 5, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 6, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 3, 5, 4, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 4, 5, 5, 1, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 2, 7, 2, 0, -6 },
  { 141, 1, 5, 3, 1, -5 },
  { 142, 2, 7, 2, 0, -6 },
  { 144, 3, 3, 3, 0, -5 },
  { 146, 2, 1, 3, 0, 0 },
  { 147, 1, 1, 2, 1, -5 },
  { 148, 3, 4, 3, 0, -4 },
  { 150, 3, 5, 3, 0, -5 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 4, 5, 3, 0, -5 },
  { 157, 3, 4, 3, 0, -4 },
  { 159, 3, 5, 2, 0, -5 },
  { 161, 3, 5, 3, 0, -4 },
  { 163, 3, 5, 3, 0, -5 },
  { 165, 2, 5, 2, 0, -5 },
  { 167, 3, 7, 2, -1, -5 },
  { 170, 4, 5, 3, 0, -5 },
  { 173, 2, 5, 2, 0, -5 },
  { 175, 5, 4, 5, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 3, 5, 3, 0, -4 },
  { 184, 3, 5, 3, 0, -4 },
  { 186, 2, 4, 2, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 2, 5, 2, 0, -5 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 4, 3, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 3, 6, 3, 0, -4 },
  { 202, 3, 4, 3, 0, -4 },
  { 204, 2, 6, 2, 0, -5 },
  { 206, 2, 6, 2, 0, -5 },
  { 208, 2, 6, 2, 0, -5 },
  { 210, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC7PT7B_H_
