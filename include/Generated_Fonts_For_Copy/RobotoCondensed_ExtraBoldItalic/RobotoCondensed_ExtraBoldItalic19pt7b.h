#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC19PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x18, 0xCE, 0x73, 0x80, 0xCE, 0x30, 0x6D, 0x3D,
  0xB6, 0xD8, 0x05, 0x83, 0x60, 0xD8, 0x2C, 0x3F, 0xCF, 0xE1, 0xA0, 0x58,
  0xFF, 0x3F, 0xC2, 0xC1, 0xB0, 0x6C, 0x16, 0x00, 0x04, 0x04, 0x1E, 0x3F,
  0x77, 0x77, 0x70, 0x70, 0x38, 0x1E, 0x0E, 0x06, 0xCE, 0xEE, 0xFC, 0x78,
  0x30, 0x20, 0x70, 0x7C, 0x36, 0xD3, 0x4F, 0x67, 0xE0, 0x20, 0x30, 0x37,
  0x17, 0x9A, 0x79, 0x30, 0xF0, 0x70, 0x0E, 0x07, 0xC3, 0xB0, 0xEC, 0x3B,
  0x0F, 0x81, 0xC0, 0xF7, 0x7F, 0xFB, 0xEE, 0x7B, 0x9C, 0x7F, 0x8F, 0xE0,
  0x6F, 0x6C, 0x08, 0x71, 0x8C, 0x71, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x82, 0x00, 0x10, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C,
  0x31, 0xC7, 0x18, 0x63, 0x8C, 0x63, 0x88, 0x00, 0x0C, 0x08, 0x49, 0xFF,
  0x18, 0x3C, 0x6C, 0x44, 0x0E, 0x0C, 0x0C, 0x1C, 0x7F, 0x7F, 0x7F, 0x18,
  0x18, 0x18, 0x38, 0x37, 0x76, 0xEC, 0xFF, 0xC0, 0x6F, 0x60, 0x03, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0xC0, 0x1E, 0x3E, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC6, 0xCE,
  0xEE, 0xFC, 0x78, 0x0C, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xC7, 0x1C,
  0x71, 0xC0, 0x0F, 0x1F, 0xCE, 0xEE, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0F, 0xF7, 0xF8, 0x0E, 0x1F, 0xCE, 0xEE, 0x70, 0x38,
  0x1C, 0x7C, 0x3C, 0x07, 0x01, 0xB9, 0xDC, 0xE7, 0xE1, 0xE0, 0x03, 0x83,
  0xC1, 0xE1, 0xE1, 0xB0, 0xF8, 0xDC, 0xEE, 0x67, 0x7F, 0xFF, 0xC1, 0xC0,
  0xE0, 0x70, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0x01, 0xF1, 0xFC, 0x6E, 0x03,
  0x01, 0xB9, 0xCE, 0xE7, 0xE1, 0xE0, 0x0E, 0x1E, 0x3C, 0x70, 0x60, 0xFC,
  0xFE, 0xEF, 0xE7, 0xC7, 0xC6, 0xEE, 0xFC, 0x78, 0x7F, 0xBF, 0xC1, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x0F, 0x0F, 0xCE, 0xE7, 0x73, 0xB9, 0xDC, 0x7C, 0x7C, 0x77, 0x33, 0x99,
  0xCE, 0xE7, 0xE1, 0xE0, 0x1C, 0x3E, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0x7F,
  0x7E, 0x0E, 0x0E, 0x3C, 0x78, 0x60, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x67,
  0x98, 0x18, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x71, 0x84,
  0x00, 0x01, 0x07, 0x1F, 0x7C, 0x70, 0xF8, 0x3E, 0x0E, 0x02, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x20, 0x38, 0x7C, 0x1F, 0x07, 0x3F, 0x7C, 0x70,
  0x80, 0x3C, 0x7E, 0x6E, 0xE6, 0x0E, 0x0E, 0x1C, 0x38, 0x30, 0x30, 0x00,
  0x60, 0x70, 0x60, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x8E, 0x06, 0x33, 0xC9,
  0x9F, 0x26, 0x6C, 0x9B, 0x32, 0xCC, 0xCB, 0x36, 0x6C, 0xD9, 0xB3, 0xFC,
  0xCE, 0xE1, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0x80, 0x70,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0xE6, 0x18, 0xC7, 0xF8, 0xFF,
  0xB8, 0x77, 0x0F, 0xC1, 0xC0, 0x3F, 0x0F, 0xF3, 0x9C, 0xE7, 0x31, 0xDC,
  0x77, 0xF9, 0xFE, 0x73, 0x9C, 0xE6, 0x3B, 0x9E, 0xFF, 0x3F, 0x80, 0x1F,
  0x0F, 0xE7, 0xB9, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE,
  0x33, 0x9C, 0x7E, 0x0F, 0x00, 0x3F, 0x0F, 0xE3, 0xBC, 0xE7, 0x31, 0xDC,
  0x77, 0x1D, 0xC7, 0x71, 0xDC, 0xE6, 0x3B, 0x9C, 0xFF, 0x3F, 0x00, 0x3F,
  0xCF, 0xF3, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0xF1, 0xFC, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE3, 0x80, 0xE0, 0x30, 0x1C,
  0x07, 0xF1, 0xFC, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F,
  0x0F, 0xE7, 0xB9, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x9E, 0xEF, 0xB8, 0xEE,
  0x3B, 0xDE, 0x7F, 0x0F, 0x80, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x30,
  0xE7, 0x0E, 0x7F, 0xE7, 0xFC, 0x71, 0xC7, 0x1C, 0x61, 0xCE, 0x1C, 0xE1,
  0xCE, 0x18, 0x39, 0xCE, 0x73, 0x99, 0xCE, 0x73, 0x9C, 0xCE, 0x70, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0xB9, 0xDD,
  0xC7, 0xE1, 0xE0, 0x38, 0xE3, 0x9E, 0x3B, 0xC3, 0xB8, 0x37, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x67, 0x0E, 0x78, 0xE3, 0x8E, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0,
  0xFF, 0xFE, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x7D, 0xF3,
  0xE7, 0xCD, 0x9F, 0xBE, 0x77, 0xB9, 0xDE, 0xE6, 0x7B, 0xB9, 0xCC, 0xE7,
  0x73, 0x99, 0xC0, 0x38, 0x73, 0xC6, 0x3C, 0xE3, 0xCE, 0x3C, 0xE7, 0x4E,
  0x76, 0xE7, 0x6C, 0x77, 0xC7, 0x7C, 0x63, 0xCE, 0x3C, 0xE3, 0xCE, 0x38,
  0x1F, 0x0F, 0xE7, 0xB9, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0xB8,
  0xEE, 0x3B, 0x9C, 0x7E, 0x0F, 0x00, 0x3F, 0x87, 0xF8, 0xE7, 0x1C, 0x63,
  0x0C, 0xE3, 0x9C, 0xF3, 0xFC, 0x7F, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x00, 0x1F, 0x0F, 0xE7, 0xB9, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x86,
  0xE3, 0xB8, 0xEE, 0x3B, 0x9C, 0x7E, 0x0F, 0x80, 0x70, 0x08, 0x3F, 0x8F,
  0xF3, 0x9C, 0xE7, 0x31, 0xDC, 0x77, 0x3D, 0xFE, 0x7F, 0x1D, 0xC6, 0x73,
  0x9C, 0xE3, 0xB8, 0xE0, 0x0F, 0x07, 0xE3, 0x9C, 0xE7, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xB8, 0xEE, 0x39, 0xDE, 0x7F, 0x07, 0x80, 0x7F, 0xDF,
  0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x71, 0xDC, 0x77, 0x1D, 0xC6, 0x63, 0xB8, 0xEE,
  0x3B, 0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0x9C, 0xFE, 0x1F, 0x00, 0xF1, 0xEE,
  0x39, 0xC7, 0x39, 0xC7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x76, 0x0F, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x00, 0xC6, 0x3E, 0x73, 0xB3, 0x9D, 0x9C,
  0xED, 0xEE, 0x6F, 0x73, 0x7B, 0x9F, 0xD8, 0xFF, 0xC7, 0xBE, 0x3D, 0xE1,
  0xEF, 0x0E, 0x78, 0x73, 0x80, 0x1C, 0x71, 0xCE, 0x1C, 0xE0, 0xDC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF8, 0x3B, 0x83, 0x98, 0x71,
  0xC7, 0x1C, 0xE3, 0xF1, 0xF9, 0xDC, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3F, 0xE7, 0xF8, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0xF9,
  0xFE, 0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC7, 0x1C, 0x63,
  0x8E, 0x38, 0xE3, 0x8E, 0x00, 0xE3, 0x1C, 0xE7, 0x39, 0xCE, 0x31, 0x8E,
  0x73, 0x9C, 0xE0, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70,
  0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x71, 0xE3, 0xC0, 0x18, 0xE3, 0x9B, 0x6F,
  0x3C, 0xC0, 0xFF, 0xFC, 0xE6, 0x30, 0x1E, 0x3F, 0x77, 0x07, 0x3F, 0x7F,
  0xE6, 0xEE, 0xFE, 0x7E, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF3, 0xF9, 0xCE,
  0xE7, 0x73, 0xB1, 0x98, 0xDC, 0xEF, 0xE7, 0xF0, 0x1E, 0x3F, 0x77, 0x63,
  0x60, 0xE0, 0xE7, 0xEE, 0x7E, 0x3C, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x3F,
  0x9F, 0xE7, 0x79, 0x8C, 0x67, 0x39, 0xCE, 0x73, 0x9C, 0x7F, 0x1D, 0x80,
  0x1E, 0x3F, 0x73, 0x73, 0x7F, 0xFF, 0xE0, 0x72, 0x7E, 0x3C, 0x0E, 0x3C,
  0x71, 0xC7, 0xCF, 0x8E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x00, 0x1D,
  0x9F, 0xDC, 0xEE, 0x76, 0x37, 0x1B, 0x9D, 0xCE, 0x7F, 0x1F, 0x81, 0x89,
  0xCF, 0xE3, 0xC0, 0x38, 0x38, 0x38, 0x30, 0x7F, 0x7F, 0x77, 0x73, 0x73,
  0x67, 0xE7, 0xE7, 0xE7, 0xE6, 0x19, 0xCE, 0x03, 0x19, 0xCE, 0x73, 0x99,
  0xCE, 0x70, 0x06, 0x1C, 0x38, 0x00, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x0E, 0x3C, 0xF1, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x33,
  0x9D, 0xC7, 0xF1, 0xF8, 0x7C, 0x1F, 0x07, 0xE3, 0xB8, 0xE6, 0x39, 0xC0,
  0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x99, 0xCE, 0x70, 0x37, 0x73, 0xFF,
  0xDD, 0xEE, 0xE6, 0x77, 0x73, 0xB3, 0x9D, 0x9C, 0xDC, 0xEE, 0xE6, 0x77,
  0x33, 0x80, 0x77, 0x7F, 0x77, 0x73, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0xE6,
  0x1E, 0x1F, 0x9C, 0xCE, 0x76, 0x3F, 0x1B, 0x9C, 0xCE, 0x7E, 0x1E, 0x00,
  0x1F, 0x8F, 0xE3, 0x9C, 0xE7, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x7F, 0x1F,
  0xC7, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x3F, 0xBF, 0xDC, 0xEC, 0x66, 0x77,
  0x3B, 0x9D, 0xCE, 0x7F, 0x3B, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3E, 0xF9,
  0xF3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC0, 0x1E, 0x7F, 0x77, 0x70, 0x7C,
  0x3E, 0x0E, 0xE6, 0xFE, 0x3C, 0x73, 0x9D, 0xFF, 0xB3, 0x9C, 0xE7, 0x39,
  0xE7, 0x00, 0x33, 0xB9, 0xDC, 0xEE, 0x67, 0x33, 0x3B, 0x9D, 0xCE, 0x7F,
  0x3B, 0x00, 0xE7, 0xEE, 0xEE, 0xEC, 0xFC, 0xFC, 0x78, 0x78, 0x70, 0x70,
  0xEE, 0xFD, 0xDF, 0xBB, 0x7F, 0xEF, 0xF9, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7,
  0x1C, 0xE0, 0x39, 0xC6, 0xE1, 0xB0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xFC,
  0x77, 0x1D, 0xC0, 0x73, 0xBB, 0x9D, 0xCE, 0xC7, 0xE3, 0xF0, 0xF0, 0x78,
  0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x00, 0x7F, 0x7F, 0x0F, 0x0E, 0x1C,
  0x38, 0x70, 0x70, 0xFE, 0xFE, 0x04, 0x71, 0x86, 0x38, 0xE3, 0x8C, 0xE3,
  0x86, 0x1C, 0x71, 0x86, 0x18, 0x70, 0x80, 0x11, 0x33, 0x33, 0x22, 0x26,
  0x66, 0x64, 0x44, 0xC0, 0x10, 0x61, 0x87, 0x1C, 0x61, 0x86, 0x0C, 0x73,
  0x8C, 0x30, 0xC3, 0x1C, 0xE1, 0x00, 0x73, 0xFB, 0xDF, 0xCE,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 6, 1, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 8, 18, 9, 1, -16 },
  { 50, 9, 14, 12, 2, -14 },
  { 66, 10, 14, 11, 0, -14 },
  { 84, 3, 5, 3, 1, -14 },
  { 86, 6, 19, 6, 1, -15 },
  { 101, 6, 19, 6, -1, -15 },
  { 116, 8, 8, 8, 1, -14 },
  { 124, 8, 11, 9, 0, -12 },
  { 135, 4, 6, 5, -1, -2 },
  { 138, 5, 2, 7, 1, -7 },
  { 140, 4, 3, 5, 0, -3 },
  { 142, 8, 15, 6, -1, -14 },
  { 157, 8, 14, 9, 1, -14 },
  { 171, 6, 14, 9, 2, -14 },
  { 182, 9, 14, 9, 0, -14 },
  { 198, 9, 14, 9, 0, -14 },
  { 214, 9, 14, 9, 0, -14 },
  { 230, 9, 14, 9, 0, -14 },
  { 246, 8, 14, 9, 1, -14 },
  { 260, 9, 14, 9, 1, -14 },
  { 276, 9, 14, 9, 0, -14 },
  { 292, 8, 14, 9, 1, -14 },
  { 306, 5, 11, 5, 0, -11 },
  { 313, 6, 15, 5, -1, -11 },
  { 325, 8, 9, 8, 0, -10 },
  { 334, 8, 6, 9, 1, -9 },
  { 340, 8, 9, 8, 0, -10 },
  { 349, 8, 14, 8, 1, -14 },
  { 363, 14, 17, 14, 0, -13 },
  { 393, 11, 14, 11, -1, -14 },
  { 413, 10, 14, 10, 0, -14 },
  { 431, 10, 14, 11, 1, -14 },
  { 449, 10, 14, 10, 0, -14 },
  { 467, 10, 14, 9, 0, -14 },
  { 485, 10, 14, 9, 0, -14 },
  { 503, 10, 14, 11, 1, -14 },
  { 521, 12, 14, 11, 0, -14 },
  { 542, 5, 14, 5, 0, -14 },
  { 551, 9, 14, 9, 0, -14 },
  { 567, 12, 14, 10, 0, -14 },
  { 588, 8, 14, 9, 0, -14 },
  { 602, 14, 14, 14, 0, -14 },
  { 627, 12, 14, 11, 0, -14 },
  { 648, 10, 14, 11, 1, -14 },
  { 666, 11, 14, 11, 0, -14 },
  { 686, 10, 16, 11, 1, -14 },
  { 706, 10, 14, 10, 0, -14 },
  { 724, 10, 14, 10, 0, -14 },
  { 742, 10, 14, 10, 1, -14 },
  { 760, 10, 14, 11, 1, -14 },
  { 778, 11, 14, 11, 1, -14 },
  { 798, 13, 14, 14, 2, -14 },
  { 821, 12, 14, 10, -1, -14 },
  { 842, 9, 14, 10, 2, -14 },
  { 858, 11, 14, 10, 0, -14 },
  { 878, 6, 19, 5, 0, -16 },
  { 893, 5, 15, 7, 1, -14 },
  { 903, 7, 19, 5, -1, -16 },
  { 920, 6, 7, 7, 1, -14 },
  { 926, 7, 2, 7, -1, 0 },
  { 928, 4, 3, 6, 2, -14 },
  { 930, 8, 10, 9, 0, -10 },
  { 940, 9, 14, 9, 0, -14 },
  { 956, 8, 10, 8, 0, -10 },
  { 966, 10, 14, 9, 0, -14 },
  { 984, 8, 10, 9, 0, -10 },
  { 994, 7, 14, 6, 0, -14 },
  { 1007, 9, 14, 9, 0, -10 },
  { 1023, 8, 14, 9, 0, -14 },
  { 1037, 5, 14, 5, 0, -14 },
  { 1046, 7, 18, 5, -2, -14 },
  { 1062, 10, 14, 9, 0, -14 },
  { 1080, 5, 14, 5, 0, -14 },
  { 1089, 13, 10, 14, 0, -10 },
  { 1106, 8, 10, 9, 0, -10 },
  { 1116, 9, 10, 9, 0, -10 },
  { 1128, 10, 14, 9, -1, -10 },
  { 1146, 9, 14, 9, 0, -10 },
  { 1162, 7, 10, 6, 0, -10 },
  { 1171, 8, 10, 8, 0, -10 },
  { 1181, 5, 13, 6, 1, -13 },
  { 1190, 9, 10, 9, 0, -10 },
  { 1202, 8, 10, 8, 1, -10 },
  { 1212, 11, 10, 12, 1, -10 },
  { 1226, 10, 10, 8, -1, -10 },
  { 1239, 9, 14, 8, 0, -10 },
  { 1255, 8, 10, 8, 0, -10 },
  { 1265, 6, 18, 5, 0, -15 },
  { 1279, 4, 17, 5, 0, -14 },
  { 1288, 6, 18, 5, -1, -15 },
  { 1302, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC19PT7B_H_
