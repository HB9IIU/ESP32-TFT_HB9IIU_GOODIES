#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC21PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC0, 0x00, 0x63, 0xC6,
  0x00, 0x6D, 0xB6, 0xF3, 0xCF, 0x60, 0x06, 0xC0, 0xD8, 0x12, 0x06, 0xC3,
  0xFE, 0x7F, 0x86, 0xC0, 0xD8, 0x1B, 0x1F, 0xF3, 0xFE, 0x1B, 0x06, 0xC0,
  0xD8, 0x1B, 0x00, 0x06, 0x03, 0x07, 0x87, 0xE3, 0xFB, 0x9D, 0xCE, 0xE0,
  0x38, 0x1F, 0x03, 0xC0, 0xEE, 0x77, 0x3B, 0xFD, 0xFC, 0x3C, 0x18, 0x0C,
  0x00, 0x70, 0x3E, 0x0D, 0x9B, 0x66, 0xDB, 0x3F, 0x87, 0x60, 0x30, 0x1B,
  0x8D, 0xE3, 0xCD, 0xB3, 0xCC, 0xD3, 0xE0, 0x70, 0x0F, 0x03, 0xF0, 0x7E,
  0x0C, 0xC3, 0x98, 0x3F, 0x07, 0xC1, 0xE7, 0x7E, 0xEF, 0xFB, 0x9F, 0x73,
  0xEF, 0xF8, 0xFF, 0x8F, 0x70, 0x6D, 0xFD, 0x80, 0x04, 0x31, 0xC6, 0x30,
  0xC7, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x70,
  0x80, 0x10, 0x30, 0x30, 0x60, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC3, 0x87, 0x0E, 0x18, 0x70, 0xC3, 0x0E, 0x10, 0x00, 0x0C, 0x06, 0x03,
  0x3F, 0xF3, 0xF0, 0xE0, 0xF0, 0xCC, 0x04, 0x00, 0x0E, 0x07, 0x03, 0x81,
  0xC7, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x33, 0x77, 0xEC,
  0x7F, 0xFF, 0x80, 0x7F, 0x60, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x81, 0x80, 0x1E,
  0x1F, 0x9F, 0xEE, 0x77, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xB9, 0xDC,
  0xEF, 0xE3, 0xF0, 0xF0, 0x06, 0x79, 0xF7, 0xE9, 0xC3, 0x87, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x71,
  0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x7F, 0xBF, 0xEF,
  0xF8, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x01, 0xC0, 0x70, 0x38, 0x3C, 0x0F,
  0x00, 0xE0, 0x3B, 0x8E, 0xFF, 0x9F, 0xC3, 0xE0, 0x01, 0xC0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x87, 0xE1, 0xB8, 0xEE, 0x77, 0x9F, 0xFF, 0xFB, 0xFE, 0x07,
  0x01, 0xC0, 0xF0, 0x1F, 0xC7, 0xF1, 0xFC, 0xE0, 0x38, 0x0D, 0xC7, 0xF9,
  0xCE, 0x03, 0x80, 0xE0, 0x39, 0xCE, 0x7F, 0x1F, 0xC3, 0xE0, 0x07, 0x0F,
  0x8F, 0xC7, 0x07, 0x03, 0xF3, 0xFD, 0xFE, 0xE7, 0xF3, 0xF9, 0xDC, 0xEF,
  0xF3, 0xF0, 0xF0, 0x7F, 0xDF, 0xF7, 0xF8, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x0F, 0x07,
  0xE3, 0xFC, 0xE7, 0x39, 0xCE, 0x73, 0xF8, 0x7C, 0x3F, 0x1C, 0xE7, 0x39,
  0xCE, 0x7F, 0x9F, 0xC3, 0xE0, 0x1E, 0x1F, 0x9F, 0xEE, 0x77, 0x3F, 0x1F,
  0x8E, 0xEF, 0x7F, 0x1F, 0x81, 0xC1, 0xC7, 0xC3, 0xC1, 0xC0, 0x39, 0xCE,
  0x00, 0x00, 0x00, 0x77, 0x98, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0xC3, 0x1C, 0x61, 0x00, 0x00, 0x81, 0xC7, 0xCF, 0xC7, 0x83, 0x81, 0xF0,
  0x3E, 0x0E, 0x01, 0x00, 0x7F, 0xBF, 0xDF, 0xC0, 0x00, 0x07, 0xFB, 0xFD,
  0xFC, 0x20, 0x1C, 0x0F, 0x83, 0xE0, 0x78, 0x78, 0xFC, 0xF8, 0x70, 0x40,
  0x00, 0x3E, 0x7F, 0x7F, 0xE7, 0x07, 0x0F, 0x1E, 0x1C, 0x38, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x70, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x30, 0xC0, 0x23,
  0x9E, 0x66, 0x7E, 0xD9, 0xD9, 0xB3, 0x33, 0x6E, 0x66, 0xD9, 0xCF, 0x33,
  0x36, 0x66, 0x6C, 0xFF, 0x98, 0xEE, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x07, 0xE0,
  0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xFE, 0x3F, 0xE3, 0xFF, 0x78, 0x77,
  0x07, 0xF0, 0x70, 0x1F, 0x87, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xDE,
  0x7B, 0xFC, 0x7F, 0xCE, 0x39, 0xC7, 0x38, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0,
  0x0F, 0x87, 0xF8, 0xFF, 0x38, 0x77, 0x0F, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x87, 0x71, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x1F, 0x87, 0xF8,
  0xFF, 0x1C, 0x73, 0x8E, 0x71, 0xDE, 0x3B, 0x87, 0x70, 0xEE, 0x3D, 0xC7,
  0x39, 0xEF, 0xF9, 0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xFC, 0xFF, 0x9C, 0x03,
  0x80, 0x70, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x0F, 0xF9,
  0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0xFF, 0x1C, 0x03, 0x80, 0x70, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x00,
  0x0F, 0x87, 0xF8, 0xFF, 0x38, 0x77, 0x0F, 0xE0, 0x38, 0x07, 0x3E, 0xE7,
  0xDC, 0x3B, 0x87, 0x71, 0xEF, 0xFC, 0xFF, 0x0F, 0x80, 0x1C, 0x39, 0xE3,
  0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3,
  0x87, 0x1C, 0x38, 0xE1, 0xCF, 0x0E, 0x70, 0xF3, 0x87, 0x00, 0x1C, 0xF3,
  0x8E, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0x73, 0xCE, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xEE, 0x3B,
  0x9C, 0xFF, 0x1F, 0x83, 0xC0, 0x1C, 0x79, 0xE7, 0x8E, 0x78, 0x73, 0x83,
  0xB8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1C, 0xE0, 0xE7,
  0x0F, 0x3C, 0x71, 0xE3, 0x87, 0x00, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xFF, 0xFB, 0xFC, 0x1E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x76,
  0x7E, 0x76, 0x6E, 0x76, 0xFC, 0x76, 0xDC, 0x77, 0xDC, 0x77, 0x9C, 0xF7,
  0x9C, 0xE7, 0x3C, 0xE3, 0x38, 0x1C, 0x39, 0xE3, 0xCF, 0x1C, 0x7C, 0xE3,
  0xE7, 0x1F, 0x39, 0xF9, 0xCE, 0xFE, 0x73, 0xE3, 0x9F, 0x1C, 0xF8, 0xE7,
  0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x38, 0x77,
  0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xEF, 0xF8,
  0xFE, 0x0F, 0x80, 0x1F, 0x83, 0xFE, 0x3F, 0xE3, 0x8E, 0x38, 0xF3, 0x8E,
  0x78, 0xE7, 0xFE, 0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x38, 0x77, 0x0F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xEF, 0xF8, 0xFE, 0x0F, 0xC0, 0x3C,
  0x03, 0x80, 0x20, 0x1F, 0x87, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xDE,
  0x3B, 0xFE, 0x7F, 0xCF, 0xF1, 0xCE, 0x39, 0xCF, 0x39, 0xC7, 0xB8, 0xF0,
  0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0x78, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3B, 0xC7, 0x38, 0xE7, 0xFC, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0x00, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C, 0xE3,
  0xBC, 0x77, 0x0E, 0xE1, 0xDC, 0x7B, 0x8E, 0x71, 0xCF, 0xF8, 0xFE, 0x0F,
  0x80, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xEE, 0x39, 0xCF, 0x39, 0xC7, 0x38,
  0x6E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0xE7, 0x1F,
  0x9C, 0x7E, 0x73, 0xBB, 0xCE, 0xEF, 0x3B, 0xBD, 0xCF, 0xF7, 0x3F, 0xDC,
  0xFB, 0x63, 0xEF, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C,
  0x00, 0x1C, 0x38, 0x79, 0xE1, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC1,
  0xE7, 0x87, 0x0E, 0x00, 0xE1, 0xDC, 0x7B, 0x8E, 0x33, 0xC7, 0x70, 0xFC,
  0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xCF, 0xF8, 0xFF, 0x80,
  0x1E, 0x3C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0xCE,
  0x73, 0x9C, 0xE7, 0x3C, 0xE7, 0x1E, 0x3C, 0x38, 0x71, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xE1, 0xC7, 0x8F, 0x00,
  0x1C, 0x38, 0xF1, 0xE6, 0xDD, 0xF1, 0x80, 0xFF, 0xFF, 0xF3, 0x8E, 0x1E,
  0x1F, 0x9E, 0xEE, 0x73, 0xFB, 0xFF, 0xDD, 0xCE, 0xEF, 0x7F, 0x9D, 0xC0,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xC3, 0xF9, 0xFE, 0x71, 0x9C,
  0xE7, 0x39, 0xCE, 0xF3, 0xBF, 0xEF, 0xF3, 0xB8, 0x1F, 0x1F, 0x9F, 0xEE,
  0x77, 0x03, 0x83, 0x81, 0xCE, 0x7F, 0x3F, 0x0F, 0x00, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x3B, 0x8F, 0xF3, 0xFE, 0x73, 0x8E, 0x73, 0xCE,
  0x71, 0xCE, 0x39, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x1F, 0xDF, 0xEE, 0x77,
  0xFB, 0xFF, 0xC0, 0xE0, 0x7F, 0x3F, 0x8F, 0x80, 0x07, 0x1F, 0x1F, 0x1C,
  0x3C, 0x7E, 0x7E, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x1D, 0xCF, 0xF7, 0xFD, 0xC7, 0x73, 0x9C, 0xEE, 0x3B, 0x8E, 0x7F, 0x9F,
  0xE3, 0xF0, 0x1C, 0x6F, 0x3F, 0x87, 0xC0, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xF9, 0xFE, 0xFF, 0x73, 0xB9, 0xDC, 0xEE, 0x7E, 0x3F, 0x3F, 0x9D,
  0xCE, 0x18, 0xF1, 0x80, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E,
  0x00, 0x06, 0x0F, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x77, 0x8E, 0xE3, 0xBC, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0x71, 0xCE, 0x39, 0xC7, 0x3C, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x9E,
  0x71, 0xC7, 0x1C, 0x73, 0xCE, 0x38, 0x3F, 0x38, 0xFF, 0xF7, 0xFF, 0xDC,
  0xE7, 0x73, 0x9D, 0xCE, 0x77, 0x39, 0xDC, 0xE7, 0xE7, 0x3B, 0x9C, 0xEE,
  0x73, 0x80, 0x3F, 0x3F, 0xDF, 0xEE, 0x77, 0x3B, 0x9D, 0xCF, 0xC7, 0xE7,
  0xF3, 0xB9, 0xC0, 0x1F, 0x0F, 0xE7, 0xF9, 0xCE, 0x73, 0x9C, 0xEE, 0x3B,
  0x8E, 0x7F, 0x1F, 0xC3, 0xE0, 0x1F, 0x83, 0xF8, 0xFF, 0x1C, 0xF3, 0x9C,
  0x73, 0x8E, 0x73, 0xCE, 0x7F, 0xCF, 0xF1, 0xDC, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x00, 0x1D, 0xCF, 0xF7, 0xFD, 0xCE, 0x73, 0xBC, 0xEE, 0x3B, 0x8E,
  0xFF, 0x1F, 0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3E, 0x7D, 0xFB,
  0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x80, 0x1E, 0x1F, 0x9C, 0xEE, 0x77,
  0x81, 0xF0, 0x3D, 0xCE, 0xE7, 0x3F, 0x0F, 0x00, 0x39, 0xE7, 0x3F, 0xF9,
  0xC7, 0x38, 0xE3, 0x8E, 0x3C, 0xF1, 0xC0, 0x39, 0xDE, 0x77, 0x1D, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x9F, 0xC3, 0xF0, 0xE7, 0xF3, 0xB9,
  0xDD, 0xCE, 0xE3, 0x71, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x00, 0xE6, 0x7E,
  0x67, 0xEE, 0x6E, 0xEE, 0xFF, 0xEF, 0xFC, 0xFB, 0xCF, 0x3C, 0xF3, 0x8F,
  0x38, 0xE3, 0x80, 0x39, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF0, 0x1E, 0x07,
  0xC1, 0xF8, 0x3F, 0x0E, 0x71, 0xCE, 0x00, 0x73, 0xDC, 0xE7, 0x39, 0xDC,
  0x37, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0xF0, 0x3C,
  0x0E, 0x00, 0x3F, 0xBF, 0xDF, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xFF,
  0x7F, 0xBF, 0x80, 0x04, 0x1C, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0xE3,
  0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x18, 0xC6, 0x23,
  0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x8C, 0x46, 0x00, 0x10, 0x30, 0x70,
  0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x71, 0xC3, 0x87, 0x0E, 0x18, 0x30,
  0xE3, 0x82, 0x00, 0x71, 0xBC, 0xFF, 0xF9, 0xFC, 0x70,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 6, 6, 7, 1, -16 },
  { 18, 11, 15, 11, 0, -15 },
  { 39, 9, 19, 10, 1, -17 },
  { 61, 10, 15, 13, 2, -15 },
  { 80, 11, 15, 12, 0, -15 },
  { 101, 3, 6, 3, 1, -16 },
  { 104, 6, 22, 7, 1, -17 },
  { 121, 7, 22, 7, -1, -17 },
  { 141, 9, 9, 9, 1, -15 },
  { 152, 9, 11, 10, 0, -13 },
  { 165, 4, 6, 5, -1, -3 },
  { 168, 6, 3, 8, 1, -8 },
  { 171, 4, 3, 6, 0, -3 },
  { 173, 9, 16, 7, -1, -15 },
  { 191, 9, 15, 10, 1, -15 },
  { 208, 7, 15, 10, 2, -15 },
  { 222, 10, 15, 10, 0, -15 },
  { 241, 10, 15, 10, 0, -15 },
  { 260, 10, 15, 10, 0, -15 },
  { 279, 10, 15, 10, 0, -15 },
  { 298, 9, 15, 10, 1, -15 },
  { 315, 10, 15, 10, 1, -15 },
  { 334, 10, 15, 10, 0, -15 },
  { 353, 9, 15, 10, 1, -15 },
  { 370, 5, 11, 6, 0, -11 },
  { 377, 6, 14, 6, -1, -11 },
  { 388, 9, 10, 9, 0, -11 },
  { 400, 9, 8, 10, 1, -11 },
  { 409, 9, 10, 9, 0, -11 },
  { 421, 8, 15, 9, 1, -15 },
  { 436, 15, 19, 16, 0, -14 },
  { 472, 12, 15, 12, -1, -15 },
  { 495, 11, 15, 12, 0, -15 },
  { 516, 11, 15, 12, 1, -15 },
  { 537, 11, 15, 11, 0, -15 },
  { 558, 11, 15, 10, 0, -15 },
  { 579, 11, 15, 10, 0, -15 },
  { 600, 11, 15, 12, 1, -15 },
  { 621, 13, 15, 12, 0, -15 },
  { 646, 6, 15, 6, 0, -15 },
  { 658, 10, 15, 10, 0, -15 },
  { 677, 13, 15, 11, 0, -15 },
  { 702, 9, 15, 10, 0, -15 },
  { 719, 16, 15, 15, 0, -15 },
  { 749, 13, 15, 12, 0, -15 },
  { 774, 11, 15, 12, 1, -15 },
  { 795, 12, 15, 12, 0, -15 },
  { 818, 11, 18, 12, 1, -15 },
  { 843, 11, 15, 11, 0, -15 },
  { 864, 11, 15, 11, 0, -15 },
  { 885, 10, 15, 11, 2, -15 },
  { 904, 11, 15, 12, 1, -15 },
  { 925, 11, 15, 12, 2, -15 },
  { 946, 14, 15, 15, 2, -15 },
  { 973, 14, 15, 11, -1, -15 },
  { 1000, 11, 15, 11, 2, -15 },
  { 1021, 12, 15, 11, 0, -15 },
  { 1044, 7, 21, 5, 0, -17 },
  { 1063, 5, 16, 8, 2, -15 },
  { 1073, 7, 21, 5, -1, -17 },
  { 1092, 7, 7, 8, 1, -15 },
  { 1099, 8, 2, 8, -1, 0 },
  { 1101, 5, 3, 7, 2, -16 },
  { 1103, 9, 11, 10, 0, -11 },
  { 1116, 10, 16, 10, 0, -16 },
  { 1136, 9, 11, 9, 0, -11 },
  { 1149, 11, 16, 10, 0, -16 },
  { 1171, 9, 11, 10, 0, -11 },
  { 1184, 8, 16, 7, 0, -16 },
  { 1200, 10, 15, 10, 0, -11 },
  { 1219, 9, 16, 10, 0, -16 },
  { 1237, 6, 15, 5, 0, -15 },
  { 1249, 8, 19, 5, -2, -15 },
  { 1268, 11, 16, 10, 0, -16 },
  { 1290, 6, 16, 5, 0, -16 },
  { 1302, 14, 11, 15, 0, -11 },
  { 1322, 9, 11, 10, 0, -11 },
  { 1335, 10, 11, 10, 0, -11 },
  { 1349, 11, 15, 10, -1, -11 },
  { 1370, 10, 15, 10, 0, -11 },
  { 1389, 7, 11, 7, 0, -11 },
  { 1399, 9, 11, 9, 0, -11 },
  { 1412, 6, 14, 6, 1, -14 },
  { 1423, 10, 11, 10, 0, -11 },
  { 1437, 9, 11, 9, 1, -11 },
  { 1450, 12, 11, 13, 1, -11 },
  { 1467, 11, 11, 9, -1, -11 },
  { 1483, 10, 15, 9, 0, -11 },
  { 1502, 9, 11, 9, 0, -11 },
  { 1515, 7, 20, 6, 0, -16 },
  { 1533, 5, 18, 5, 0, -15 },
  { 1545, 7, 20, 6, -1, -16 },
  { 1563, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC21PT7B_H_
