#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC54PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x3F, 0x1F,
  0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x07, 0xC7, 0x80, 0x00, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE3, 0xE0, 0x63,
  0xF1, 0xF0, 0x7D, 0xF0, 0xF8, 0x3E, 0xF8, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E,
  0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x9F, 0x0F, 0x8F, 0xDF, 0x07, 0xC7, 0xDF,
  0x83, 0xFF, 0xEF, 0x80, 0xFF, 0xEF, 0x80, 0x3F, 0xEF, 0xC0, 0x0F, 0xE7,
  0xC0, 0x00, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE7, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF7, 0xFF, 0x01,
  0xF7, 0xFF, 0x81, 0xFB, 0xE7, 0xE0, 0xFB, 0xF1, 0xF0, 0xF9, 0xF0, 0xF8,
  0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x7C, 0x1F, 0x0F,
  0xBE, 0x0F, 0x8F, 0xDE, 0x07, 0xC7, 0xC2, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xE7,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFE, 0x1F, 0xFF, 0x1F,
  0xC7, 0xFF, 0xE3, 0xF9, 0xFF, 0xFE, 0x7F, 0x7F, 0xBF, 0xDF, 0xCF, 0xF7,
  0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0x7F, 0x87, 0xFF, 0xCF, 0xF0, 0xFF, 0xF9,
  0xFE, 0x0F, 0xFE, 0x3F, 0xC1, 0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x87,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x06, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x08, 0x0F, 0x01, 0x3C, 0x1E, 0x0E, 0x7E, 0x3C, 0xFD, 0xFF, 0x7F,
  0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0x3E, 0x00,
  0xFE, 0x3E, 0x03, 0xF8, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0xF8, 0x07,
  0x01, 0xC0, 0x04, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE,
  0x07, 0xC0, 0x18, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x1F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3E, 0x7F, 0x98, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xE0, 0x07, 0xEF, 0xE0,
  0x07, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xF3, 0xFC, 0x03, 0xF9, 0xFE,
  0x03, 0xF8, 0xFF, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x81, 0xFC, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFB, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x0F, 0xF0, 0x01, 0x81, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF9, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xDF, 0xF0,
  0x7F, 0xBF, 0xC0, 0x7F, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F,
  0x9F, 0xC1, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xFB, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xC7, 0xF0, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x83, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8,
  0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x03,
  0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xF3, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xCF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0xFE, 0x03, 0xF0, 0x04, 0x00, 0x00, 0x78, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0x7F, 0x87, 0xFB,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3C,
  0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xFE, 0x0F, 0x87, 0xE0, 0xFF,
  0xF8, 0x7C, 0x3E, 0x07, 0xFF, 0xE1, 0xE3, 0xF0, 0x7F, 0xFE, 0x0F, 0x1F,
  0x07, 0xF1, 0xF0, 0x79, 0xF8, 0x7E, 0x0F, 0x83, 0xCF, 0x83, 0xF0, 0xFC,
  0x1E, 0x7C, 0x3F, 0x07, 0xE0, 0xF7, 0xE1, 0xF8, 0x3E, 0x0F, 0xBE, 0x0F,
  0x81, 0xF0, 0x7D, 0xF0, 0xFC, 0x1F, 0x83, 0xEF, 0x87, 0xE0, 0xFC, 0x1F,
  0xFC, 0x3F, 0x07, 0xC0, 0xFF, 0xC1, 0xF8, 0x3E, 0x07, 0xBE, 0x1F, 0x81,
  0xF0, 0x7D, 0xF0, 0xFC, 0x1F, 0x83, 0xEF, 0x87, 0xE0, 0xF8, 0x1E, 0x7C,
  0x3F, 0x07, 0xC1, 0xF3, 0xE1, 0xF8, 0x7E, 0x0F, 0x9F, 0x0F, 0xC3, 0xF0,
  0xF8, 0xF8, 0x7F, 0x7F, 0x8F, 0x87, 0xC1, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F,
  0xFD, 0xFF, 0xC1, 0xF0, 0x3F, 0xCF, 0xFC, 0x0F, 0x80, 0xFC, 0x3F, 0xC0,
  0x7E, 0x01, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF,
  0x81, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x3F, 0xFE, 0x7F, 0x83, 0xFF, 0xE7, 0xF8, 0x3F, 0xFE, 0xFF, 0x83,
  0xFF, 0xEF, 0xF8, 0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xCF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF8,
  0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0xE3, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x07, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFB, 0xF8, 0x0F, 0xEF, 0xC1, 0xFF, 0xFC, 0x07, 0xF7, 0xE0, 0xFD,
  0xFE, 0x07, 0xF9, 0xF0, 0xFE, 0xFF, 0x03, 0xFC, 0xF8, 0x7E, 0x7F, 0x01,
  0xFE, 0x7E, 0x3F, 0x7F, 0x80, 0xFF, 0x3F, 0x3F, 0x3F, 0xC0, 0x7F, 0x9F,
  0x9F, 0x9F, 0xE0, 0x3F, 0x8F, 0xDF, 0xCF, 0xF0, 0x3F, 0xC7, 0xEF, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFF, 0xE7, 0xF8, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0x83, 0xFC, 0x07, 0xF8, 0x1F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF0, 0x3F, 0xDF, 0x0F, 0xF8, 0x1F, 0xEF,
  0x87, 0xF8, 0x0F, 0xF7, 0xE3, 0xFC, 0x07, 0xF9, 0xF1, 0xFE, 0x07, 0xFC,
  0xF8, 0xFF, 0x03, 0xFC, 0x7C, 0x7F, 0x81, 0xFE, 0x3F, 0x7F, 0xC0, 0xFF,
  0x0F, 0xBF, 0xC0, 0x7F, 0x87, 0xDF, 0xE0, 0x3F, 0xC3, 0xEF, 0xF0, 0x3F,
  0xE1, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x07,
  0xF8, 0x1F, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xCF, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x83,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xF1,
  0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0,
  0x7F, 0xBF, 0xC0, 0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xF8, 0x3F, 0xEF, 0xF0,
  0x7F, 0xC1, 0xFE, 0x7F, 0x03, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0xF0, 0x7F,
  0x9F, 0xC1, 0xFF, 0x87, 0xF8, 0xFE, 0x0F, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF,
  0xE1, 0xFE, 0x3F, 0x87, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xF8, 0xFF, 0x0F,
  0xE3, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0xF3,
  0xFC, 0x1F, 0xCF, 0xFF, 0x9F, 0xE0, 0xFE, 0x7F, 0xFC, 0xFE, 0x07, 0xF3,
  0xFF, 0xEF, 0xF0, 0x3F, 0xBF, 0xFF, 0x7F, 0x81, 0xFD, 0xFF, 0xFB, 0xF8,
  0x0F, 0xEF, 0xDF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xF7,
  0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x07,
  0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xF7, 0xE0, 0xFC, 0xF8, 0x7E,
  0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3F, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x87,
  0xF9, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF,
  0x3F, 0xC1, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x01, 0xFC, 0xFF, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFE, 0x7F, 0xE0, 0xFE, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x3F, 0xC1, 0xFC, 0xFE, 0x07,
  0xF7, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F,
  0x1F, 0xC3, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x0F, 0xFC, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x30, 0x3F, 0xE1, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x1F, 0xF9, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0x0C, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0C,
  0x03, 0xFC, 0x03, 0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x04, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFE,
  0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x07,
  0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xFC, 0x0F,
  0xF3, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0x9F, 0xF0, 0x0F, 0xF7, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F, 0x9F,
  0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8,
  0x3F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x3F,
  0xC3, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xEF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x87,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE0, 0x40,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC1, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xC7, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x04, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFC, 0xC3, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x83,
  0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F,
  0x81, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x20, 0x00,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81,
  0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC,
  0x7F, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE,
  0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0xFF, 0xFC, 0x1F,
  0x83, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE,
  0x3F, 0xDF, 0xC3, 0xFC, 0x7F, 0x3F, 0x8F, 0xF8, 0xFE, 0x7F, 0x1F, 0xF3,
  0xFC, 0xFE, 0x3F, 0xE7, 0xF1, 0xFC, 0xFF, 0xCF, 0xE3, 0xF9, 0xFF, 0x9F,
  0xC7, 0xF7, 0xFF, 0x7F, 0x0F, 0xEF, 0xFE, 0xFE, 0x1F, 0xDF, 0x7D, 0xFC,
  0x3F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0x81,
  0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x7F, 0xC0, 0x0F,
  0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x7F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x01, 0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x0F,
  0xC7, 0xFE, 0x07, 0xE7, 0xFF, 0x83, 0xF7, 0xFF, 0xE3, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFD, 0xFC, 0x7F, 0xFC, 0xFC, 0x1F, 0xFE, 0x7E, 0x07,
  0xFE, 0x3E, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 39, 14, 1, -38 },
  { 70, 16, 15, 17, 3, -41 },
  { 100, 27, 38, 27, 1, -38 },
  { 229, 25, 51, 27, 1, -45 },
  { 389, 25, 40, 34, 5, -39 },
  { 514, 27, 40, 31, 1, -39 },
  { 649, 8, 15, 8, 3, -41 },
  { 664, 17, 55, 17, 2, -43 },
  { 781, 17, 54, 17, -2, -42 },
  { 896, 23, 24, 24, 3, -38 },
  { 965, 23, 28, 25, 1, -31 },
  { 1046, 12, 17, 13, -3, -7 },
  { 1072, 14, 7, 20, 3, -20 },
  { 1085, 9, 9, 16, 1, -8 },
  { 1096, 24, 41, 17, -4, -38 },
  { 1219, 24, 40, 27, 2, -39 },
  { 1339, 17, 38, 27, 6, -38 },
  { 1420, 26, 39, 27, 0, -39 },
  { 1547, 25, 40, 27, 1, -39 },
  { 1672, 25, 38, 27, 1, -38 },
  { 1791, 26, 39, 27, 1, -38 },
  { 1918, 23, 39, 27, 2, -38 },
  { 2031, 26, 38, 27, 2, -38 },
  { 2155, 25, 40, 27, 1, -39 },
  { 2280, 23, 39, 27, 3, -39 },
  { 2393, 13, 30, 15, 1, -29 },
  { 2442, 15, 39, 14, -2, -29 },
  { 2516, 22, 25, 23, 1, -29 },
  { 2585, 23, 19, 27, 2, -26 },
  { 2640, 22, 26, 24, 1, -29 },
  { 2712, 21, 40, 24, 3, -39 },
  { 2817, 37, 49, 40, 1, -37 },
  { 3044, 30, 38, 31, -2, -38 },
  { 3187, 29, 38, 30, 0, -38 },
  { 3325, 28, 40, 30, 2, -39 },
  { 3465, 29, 38, 30, 0, -38 },
  { 3603, 28, 38, 26, 0, -38 },
  { 3736, 28, 38, 25, 0, -38 },
  { 3869, 28, 40, 31, 2, -39 },
  { 4009, 33, 38, 32, 0, -38 },
  { 4166, 15, 38, 14, 0, -38 },
  { 4238, 27, 39, 26, 0, -38 },
  { 4370, 34, 38, 29, 0, -38 },
  { 4532, 22, 38, 25, 0, -38 },
  { 4637, 41, 38, 40, 0, -38 },
  { 4832, 33, 38, 32, 0, -38 },
  { 4989, 29, 40, 32, 2, -39 },
  { 5134, 30, 38, 30, 0, -38 },
  { 5277, 29, 46, 32, 2, -39 },
  { 5444, 29, 38, 29, 0, -38 },
  { 5582, 28, 40, 29, 1, -39 },
  { 5722, 27, 38, 29, 4, -38 },
  { 5851, 29, 39, 30, 2, -38 },
  { 5993, 30, 38, 30, 4, -38 },
  { 6136, 37, 38, 39, 5, -38 },
  { 6312, 34, 38, 29, -2, -38 },
  { 6474, 28, 38, 29, 4, -38 },
  { 6607, 31, 38, 28, -1, -38 },
  { 6755, 18, 54, 14, -1, -45 },
  { 6877, 14, 41, 20, 4, -38 },
  { 6949, 19, 54, 14, -3, -45 },
  { 7078, 18, 19, 21, 2, -38 },
  { 7121, 21, 6, 21, -3, 0 },
  { 7137, 12, 8, 18, 5, -40 },
  { 7149, 23, 31, 25, 0, -30 },
  { 7239, 24, 42, 26, 0, -41 },
  { 7365, 22, 31, 24, 1, -30 },
  { 7451, 27, 42, 26, 1, -41 },
  { 7593, 23, 31, 25, 1, -30 },
  { 7683, 20, 42, 17, 1, -42 },
  { 7788, 26, 41, 26, 0, -30 },
  { 7922, 25, 41, 26, -1, -41 },
  { 8051, 14, 40, 13, 0, -40 },
  { 8121, 20, 51, 13, -6, -40 },
  { 8249, 27, 41, 25, 0, -41 },
  { 8388, 15, 41, 13, 0, -41 },
  { 8465, 37, 30, 39, 0, -30 },
  { 8604, 25, 30, 26, -1, -30 },
  { 8698, 23, 31, 26, 1, -30 },
  { 8788, 27, 41, 26, -2, -30 },
  { 8927, 25, 41, 26, 1, -30 },
  { 9056, 19, 30, 18, 0, -30 },
  { 9128, 23, 31, 24, 0, -30 },
  { 9218, 15, 37, 16, 2, -36 },
  { 9288, 25, 30, 26, 1, -29 },
  { 9382, 22, 29, 24, 3, -29 },
  { 9462, 31, 29, 33, 3, -29 },
  { 9575, 27, 29, 24, -2, -29 },
  { 9673, 27, 40, 24, -1, -29 },
  { 9808, 25, 29, 24, -1, -29 },
  { 9899, 16, 52, 16, 1, -42 },
  { 10003, 12, 45, 13, 1, -38 },
  { 10071, 17, 52, 16, -2, -42 },
  { 10182, 25, 12, 29, 2, -22 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC54PT7B_H_
