#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC14PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x60, 0xCC, 0xFB, 0xAA, 0x1E, 0x28, 0x53, 0xF2,
  0x85, 0x3F, 0x3C, 0x50, 0xA0, 0x08, 0x38, 0xFB, 0x36, 0x07, 0x07, 0x06,
  0xCC, 0xF9, 0xE1, 0x00, 0x61, 0xAB, 0x57, 0xC7, 0x83, 0x8F, 0xAB, 0xD6,
  0x18, 0x1C, 0x78, 0x91, 0xE3, 0x8F, 0xF7, 0xE7, 0xFC, 0xEC, 0xFA, 0x13,
  0x64, 0xCC, 0xC8, 0x88, 0x88, 0xC4, 0x20, 0x84, 0x31, 0x8C, 0x63, 0x11,
  0x8C, 0x46, 0x20, 0x10, 0xCF, 0xD8, 0x52, 0x40, 0x18, 0x61, 0x1F, 0xFC,
  0xC3, 0x0C, 0x6D, 0xE0, 0xFC, 0xF8, 0x04, 0x30, 0x86, 0x10, 0xC2, 0x08,
  0x61, 0x0C, 0x00, 0x39, 0xEC, 0xF3, 0xCF, 0x6D, 0xB6, 0xF3, 0xC0, 0x1B,
  0xDC, 0x63, 0x18, 0xC6, 0x63, 0x00, 0x3C, 0xFD, 0x98, 0x70, 0xC3, 0x0C,
  0x38, 0xFD, 0xF8, 0x3C, 0xF9, 0x98, 0x71, 0xC7, 0x03, 0x66, 0xFC, 0xF0,
  0x0E, 0x18, 0x71, 0xE2, 0xCD, 0xBF, 0x7E, 0x18, 0x30, 0x3E, 0x7D, 0x83,
  0xC7, 0xC1, 0x83, 0x66, 0x7C, 0xF0, 0x1B, 0xD9, 0xFF, 0xEF, 0x7B, 0xFB,
  0x80, 0xFF, 0xF1, 0x86, 0x30, 0xC6, 0x18, 0xC3, 0x00, 0x1C, 0x7D, 0x9B,
  0x33, 0xCF, 0x1B, 0x66, 0x7C, 0xF0, 0x39, 0xEC, 0xF3, 0xDB, 0xE7, 0x8E,
  0xF3, 0x80, 0x66, 0x00, 0x00, 0xEC, 0x33, 0x00, 0x00, 0x26, 0x6C, 0x04,
  0x77, 0xB8, 0xF0, 0xE0, 0x80, 0x7D, 0xF0, 0x1F, 0x7C, 0x41, 0xC3, 0xC3,
  0x7B, 0x88, 0x00, 0x77, 0xF6, 0x33, 0x31, 0x80, 0xC6, 0x00, 0x0F, 0x06,
  0x22, 0x0D, 0xB9, 0x4B, 0x56, 0x9D, 0x27, 0x5A, 0xD6, 0xB6, 0xCC, 0x01,
  0x90, 0x3C, 0x00, 0x06, 0x0E, 0x0E, 0x1A, 0x1B, 0x3B, 0x3F, 0x3F, 0x63,
  0x63, 0x3C, 0x7E, 0x66, 0x66, 0x7E, 0x7C, 0x66, 0xE6, 0xFC, 0xF8, 0x1E,
  0x3E, 0x63, 0x63, 0x60, 0x60, 0x60, 0x66, 0x7E, 0x3C, 0x3C, 0xFD, 0x9B,
  0x36, 0x6C, 0xD9, 0xF7, 0xFD, 0xF0, 0x3E, 0xFD, 0x83, 0x07, 0xCF, 0x98,
  0x70, 0xFD, 0xF8, 0x3E, 0xFD, 0x83, 0x07, 0xCF, 0x98, 0x70, 0xC1, 0x80,
  0x3C, 0xFF, 0x1E, 0x0D, 0xFB, 0xB3, 0x66, 0xFC, 0xF0, 0x33, 0xB9, 0x98,
  0xCC, 0x67, 0xF3, 0xF9, 0x99, 0xCC, 0xC6, 0x63, 0x00, 0x33, 0x76, 0x66,
  0x66, 0xCC, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x66, 0xF8, 0xE0, 0x33,
  0x3B, 0x9B, 0x8D, 0x87, 0x83, 0xC1, 0xB1, 0xD8, 0xCC, 0x67, 0x00, 0x31,
  0xC6, 0x18, 0x61, 0x86, 0x38, 0xFF, 0xF0, 0x30, 0xEF, 0x39, 0xE7, 0x3D,
  0xE7, 0xBC, 0xF5, 0x9F, 0xE7, 0x6C, 0xCD, 0x99, 0x30, 0x33, 0xB9, 0x9C,
  0xCF, 0x67, 0xB3, 0x59, 0xB9, 0xDC, 0xCE, 0x63, 0x00, 0x1E, 0x3F, 0x63,
  0x63, 0x63, 0x63, 0x67, 0x66, 0x7E, 0x3C, 0x3E, 0x7E, 0x63, 0x63, 0x66,
  0x7E, 0x7C, 0xE0, 0xC0, 0xC0, 0x1E, 0x3F, 0x63, 0x63, 0x63, 0x63, 0x67,
  0x66, 0x7E, 0x3C, 0x0E, 0x04, 0x3E, 0x7E, 0x67, 0x66, 0x7E, 0x7C, 0x6C,
  0xEC, 0xCC, 0xCE, 0x1C, 0x7D, 0x9B, 0x83, 0x83, 0x83, 0xE7, 0x7C, 0xF0,
  0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC0, 0x33, 0x73, 0x63,
  0x67, 0x66, 0x66, 0x66, 0x66, 0x7C, 0x38, 0xC7, 0xC6, 0xCE, 0xEC, 0x6C,
  0x78, 0x78, 0x78, 0x70, 0x70, 0xCC, 0xF3, 0x6D, 0xDB, 0x76, 0xDF, 0x3F,
  0xCF, 0xF3, 0xB8, 0xEE, 0x3B, 0x80, 0x39, 0x8D, 0x86, 0xC3, 0xC1, 0xE0,
  0xE0, 0x78, 0x6C, 0x76, 0x33, 0x80, 0xC7, 0xDD, 0xB3, 0xC7, 0x8E, 0x0C,
  0x38, 0x60, 0xC0, 0x7F, 0x7E, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xFC,
  0xFC, 0x31, 0x9C, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x8E, 0x60, 0xCC, 0xC6,
  0x66, 0x66, 0x66, 0x70, 0x39, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x98, 0xCE,
  0x70, 0x19, 0xCE, 0xD4, 0x80, 0xFB, 0xE0, 0x62, 0x39, 0xF0, 0xDF, 0xEF,
  0x6F, 0x9E, 0x30, 0xC6, 0x1F, 0x7D, 0xB6, 0xDB, 0xCF, 0xFF, 0x80, 0x39,
  0xF6, 0xF0, 0xC3, 0x37, 0x9C, 0x06, 0x0C, 0x19, 0xB7, 0xCD, 0xB3, 0x66,
  0xCD, 0xF9, 0xA0, 0x39, 0xF6, 0xF3, 0xFF, 0x07, 0x9E, 0x19, 0xCC, 0xF7,
  0xB1, 0x8C, 0x63, 0x30, 0x36, 0xFD, 0xB6, 0x6C, 0xD9, 0xBF, 0x3E, 0x19,
  0xF3, 0xC0, 0x31, 0x86, 0x1F, 0x7D, 0xB6, 0xF3, 0xCF, 0x3D, 0x80, 0x33,
  0x06, 0x66, 0x66, 0xCC, 0xC0, 0x0C, 0x30, 0x06, 0x18, 0x61, 0x86, 0x30,
  0xC3, 0x0C, 0x73, 0x80, 0x30, 0x61, 0x83, 0x76, 0xCF, 0x1C, 0x3C, 0xF9,
  0xB3, 0x30, 0x33, 0x66, 0x66, 0x66, 0xCC, 0xC0, 0x7F, 0x9F, 0xE6, 0xD9,
  0xB6, 0xED, 0xB3, 0x6C, 0xDB, 0x66, 0x7D, 0xF6, 0xDB, 0xCF, 0x3C, 0xF6,
  0x39, 0xF6, 0xF3, 0xCF, 0x37, 0x9E, 0x3E, 0x7C, 0xD9, 0xB7, 0x6C, 0xDF,
  0xBE, 0x60, 0xC1, 0x80, 0x36, 0xF9, 0xB6, 0x6C, 0xD9, 0xBF, 0x3C, 0x18,
  0x30, 0x60, 0x7B, 0xD8, 0xCE, 0x63, 0x18, 0x39, 0xF6, 0x1C, 0x38, 0x6D,
  0x9C, 0x37, 0xF6, 0x66, 0x66, 0x60, 0x66, 0xD9, 0xB3, 0x6C, 0xD9, 0xBF,
  0x34, 0xDB, 0x6D, 0xBC, 0xF3, 0x8E, 0x38, 0xDB, 0xDA, 0xFE, 0xFE, 0xFC,
  0xFC, 0xDC, 0xD8, 0x36, 0x36, 0x3C, 0x1C, 0x3C, 0x3C, 0x6C, 0x6C, 0x6C,
  0xD9, 0xB3, 0xC7, 0x8E, 0x1C, 0x30, 0x61, 0xC3, 0x00, 0x7D, 0xF1, 0x8C,
  0x31, 0x8F, 0xBE, 0x11, 0x8C, 0x42, 0x73, 0x0C, 0x63, 0x10, 0x82, 0x00,
  0x24, 0x96, 0x92, 0x4B, 0x40, 0x22, 0x22, 0x63, 0x36, 0x44, 0xCC, 0x80,
  0x76, 0xFD, 0x30,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 10, 7, 0, -10 },
  { 17, 7, 12, 7, 0, -11 },
  { 28, 7, 10, 9, 1, -10 },
  { 37, 7, 10, 8, 0, -10 },
  { 46, 2, 4, 2, 1, -11 },
  { 47, 4, 14, 4, 1, -11 },
  { 54, 5, 14, 4, -1, -11 },
  { 63, 6, 6, 6, 1, -10 },
  { 68, 6, 8, 6, 0, -9 },
  { 74, 3, 4, 3, -1, -2 },
  { 76, 3, 2, 5, 1, -5 },
  { 77, 3, 2, 4, 0, -2 },
  { 78, 6, 11, 4, -1, -10 },
  { 87, 6, 10, 7, 1, -10 },
  { 95, 5, 10, 7, 1, -10 },
  { 102, 7, 10, 7, 0, -10 },
  { 111, 7, 10, 7, 0, -10 },
  { 120, 7, 10, 7, 0, -10 },
  { 129, 7, 10, 7, 0, -10 },
  { 138, 5, 10, 7, 1, -10 },
  { 145, 6, 10, 7, 1, -10 },
  { 153, 7, 10, 7, 0, -10 },
  { 162, 6, 10, 7, 1, -10 },
  { 170, 4, 8, 4, 0, -8 },
  { 174, 4, 10, 4, -1, -8 },
  { 179, 6, 7, 6, 0, -8 },
  { 185, 6, 5, 7, 0, -7 },
  { 189, 6, 7, 6, 0, -8 },
  { 195, 5, 10, 6, 1, -10 },
  { 202, 10, 13, 10, 0, -10 },
  { 219, 8, 10, 8, -1, -10 },
  { 229, 8, 10, 8, 0, -10 },
  { 239, 8, 10, 8, 0, -10 },
  { 249, 7, 10, 8, 0, -10 },
  { 258, 7, 10, 7, 0, -10 },
  { 267, 7, 10, 6, 0, -10 },
  { 276, 7, 10, 8, 1, -10 },
  { 285, 9, 10, 8, 0, -10 },
  { 297, 4, 10, 4, 0, -10 },
  { 302, 7, 10, 7, 0, -10 },
  { 311, 9, 10, 8, 0, -10 },
  { 323, 6, 10, 7, 0, -10 },
  { 331, 11, 10, 10, 0, -10 },
  { 345, 9, 10, 8, 0, -10 },
  { 357, 8, 10, 8, 0, -10 },
  { 367, 8, 10, 8, 0, -10 },
  { 377, 8, 12, 8, 0, -10 },
  { 389, 8, 10, 8, 0, -10 },
  { 399, 7, 10, 7, 0, -10 },
  { 408, 7, 10, 7, 1, -10 },
  { 417, 8, 10, 8, 0, -10 },
  { 427, 8, 10, 8, 1, -10 },
  { 437, 10, 10, 10, 1, -10 },
  { 450, 9, 10, 8, -1, -10 },
  { 462, 7, 10, 7, 1, -10 },
  { 471, 8, 10, 7, 0, -10 },
  { 481, 5, 14, 4, 0, -12 },
  { 490, 4, 11, 5, 1, -10 },
  { 496, 5, 14, 4, -1, -12 },
  { 505, 5, 5, 5, 0, -10 },
  { 509, 6, 2, 5, -1, 0 },
  { 511, 4, 2, 5, 1, -10 },
  { 512, 6, 8, 6, 0, -8 },
  { 518, 6, 11, 7, 0, -11 },
  { 527, 6, 8, 6, 0, -8 },
  { 533, 7, 11, 7, 0, -11 },
  { 543, 6, 8, 7, 0, -8 },
  { 549, 5, 11, 4, 0, -11 },
  { 556, 7, 11, 7, 0, -8 },
  { 566, 6, 11, 7, 0, -11 },
  { 575, 4, 11, 3, 0, -11 },
  { 581, 6, 14, 3, -2, -11 },
  { 592, 7, 11, 7, 0, -11 },
  { 602, 4, 11, 3, 0, -11 },
  { 608, 10, 8, 10, 0, -8 },
  { 618, 6, 8, 7, 0, -8 },
  { 624, 6, 8, 7, 0, -8 },
  { 630, 7, 11, 7, -1, -8 },
  { 640, 7, 11, 7, 0, -8 },
  { 650, 5, 8, 5, 0, -8 },
  { 655, 6, 8, 6, 0, -8 },
  { 661, 4, 9, 4, 0, -9 },
  { 666, 7, 8, 7, 0, -8 },
  { 673, 6, 8, 6, 1, -8 },
  { 679, 8, 8, 9, 1, -8 },
  { 687, 8, 8, 6, -1, -8 },
  { 695, 7, 11, 6, 0, -8 },
  { 705, 6, 8, 6, 0, -8 },
  { 711, 5, 13, 4, 0, -11 },
  { 720, 3, 12, 3, 0, -10 },
  { 725, 4, 13, 4, 0, -11 },
  { 732, 7, 3, 7, 0, -6 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC14PT7B_H_
