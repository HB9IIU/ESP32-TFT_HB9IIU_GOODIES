#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC31PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x1F, 0x07,
  0x83, 0x80, 0x73, 0xB9, 0xFD, 0xFC, 0xEE, 0x77, 0x3B, 0x9D, 0x8C, 0x00,
  0xEE, 0x01, 0xCE, 0x01, 0xCC, 0x01, 0xDC, 0x03, 0x9C, 0x03, 0x98, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x1D, 0xC0, 0x39, 0xC0, 0x39,
  0x80, 0x3B, 0x80, 0x33, 0x80, 0x73, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x9F, 0x3E, 0x3C, 0xF0,
  0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xCF, 0x0F, 0x3C, 0x3C, 0xF9, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xF0, 0x39, 0xC7, 0xE7, 0x3B, 0x9D, 0xCE, 0x77, 0x3F, 0xB8, 0xFF, 0xC1,
  0xF7, 0x00, 0x38, 0x01, 0xC0, 0x06, 0xF0, 0x3F, 0xF1, 0xDF, 0xCE, 0xE7,
  0x3B, 0x9D, 0xCE, 0x7E, 0x39, 0xD8, 0xFF, 0x01, 0xF8, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E,
  0x3C, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xCF, 0x3F,
  0xCF, 0x7F, 0xEF, 0x79, 0xFE, 0xF9, 0xFE, 0xF8, 0xFE, 0xF8, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xBE, 0x77, 0x7F, 0xFE, 0xEE, 0xE0,
  0x00, 0x80, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x3C,
  0x06, 0x00, 0x80, 0x04, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x38, 0x08, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x0E, 0x73, 0x7F, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0x01, 0xFC, 0x1E, 0xE1,
  0xE3, 0x86, 0x1C, 0x10, 0x80, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x83, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x3C, 0x78, 0xE3, 0xC7,
  0x9E, 0x3C, 0xF0, 0x40, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87,
  0xFE, 0x3E, 0x78, 0xF1, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1, 0xF7,
  0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF8, 0xF3,
  0xE7, 0xC7, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xC1, 0xF1,
  0xFD, 0xFE, 0x7F, 0x9F, 0xEC, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7,
  0xCF, 0x8F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0xF8, 0x79, 0xF1, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x1C, 0xF0, 0x7B, 0xE1, 0xE7, 0xC3,
  0xCF, 0x8F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xDF, 0x02, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBC, 0x3E, 0xF0,
  0xF3, 0xE7, 0xCF, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xF0,
  0x1F, 0x81, 0xFC, 0x1F, 0xE1, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xBC, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFE, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFB, 0xCF, 0x9F, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x3E,
  0x7C, 0xF9, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C, 0x78, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xE1, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xE7, 0xCF,
  0xFF, 0x1F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE7, 0xCF, 0x3C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xBE,
  0x3D, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x7C, 0x03, 0xC0, 0x7E,
  0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x3E, 0x7C, 0x70, 0x07, 0x07,
  0x83, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x01, 0x80,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x3F, 0xEF, 0xF8, 0xFE, 0x0F, 0x80,
  0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x40, 0x3F,
  0xF9, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x07, 0xF8, 0xFF, 0x9F, 0xF0, 0xFE,
  0x07, 0xC0, 0x38, 0x01, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF,
  0xF9, 0xFF, 0x9F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x07, 0xC0,
  0x78, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xF0, 0x1C, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x60, 0xE1, 0xE1, 0xC7, 0x1F,
  0xE7, 0x1C, 0xFF, 0x9C, 0xE3, 0x8E, 0x73, 0x9E, 0x71, 0xDC, 0x71, 0xC7,
  0x73, 0xC7, 0x1D, 0xCF, 0x1C, 0x77, 0x38, 0xE1, 0x9C, 0xE3, 0x8E, 0xE3,
  0x8E, 0x3B, 0x8E, 0x79, 0xCE, 0x3F, 0xFF, 0x38, 0xFF, 0xF8, 0x71, 0xE7,
  0xC1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x08, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0x03,
  0xEF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7C, 0x0F, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1E,
  0x3E, 0x1F, 0x1F, 0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xE1,
  0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x1F, 0x3E, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3C, 0x3E, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3F, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0xFF, 0x78, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xE0, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0,
  0x3C, 0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF3, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x03, 0xE0,
  0x00, 0x0F, 0x07, 0xE1, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF3,
  0xF0, 0x3E, 0xFC, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xBE,
  0x03, 0xE7, 0xC0, 0x7C, 0xFC, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x00, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8, 0xF7,
  0x9F, 0xF1, 0xEF, 0x3B, 0xC3, 0xDE, 0xF7, 0x8F, 0xBD, 0xCF, 0x1F, 0x3F,
  0xBE, 0x3E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xE3,
  0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x1F, 0x1F, 0x1E, 0x3E, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1, 0xE1, 0xFC, 0x3C, 0x3F, 0x8F,
  0x87, 0xF1, 0xF0, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xDC, 0xF0, 0xFB, 0x9E,
  0x1F, 0x77, 0xC3, 0xCE, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xF8,
  0x7C, 0x7F, 0x0F, 0x07, 0xE1, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1,
  0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0x9E, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3C, 0xF8, 0x3E, 0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x8F,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1,
  0xF0, 0x78, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0x9E, 0x03,
  0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8,
  0x3E, 0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E,
  0x3C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x1E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xF0, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E, 0x1E, 0x3C, 0x1E, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xE0, 0xF1, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F,
  0x07, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xF8,
  0x0F, 0xFC, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E,
  0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0xF0,
  0xFF, 0x87, 0x87, 0xBC, 0x7C, 0x7D, 0xE3, 0xE3, 0xEF, 0x1F, 0x1F, 0x79,
  0xF8, 0xF3, 0xCF, 0xCF, 0x9E, 0x7E, 0x7C, 0xF7, 0xF3, 0xC7, 0xBF, 0xBE,
  0x3D, 0xFD, 0xF1, 0xFE, 0xEF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0xF8,
  0x7E, 0x0F, 0x87, 0xC0, 0x78, 0xF8, 0x07, 0xCF, 0x80, 0x7D, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFB, 0xC0,
  0x1F, 0x3C, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x1F,
  0x0F, 0xC1, 0xF0, 0xF0, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0x78,
  0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x00,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xDC, 0x3B, 0x8F, 0x71, 0xCE, 0x79,
  0xCE, 0x3B, 0xC7, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF0,
  0xF1, 0xE1, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x7D, 0xF3, 0xC7, 0x80,
  0x7C, 0x03, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0x9E, 0x3D, 0xF1, 0xEF, 0x9F,
  0x7D, 0xFB, 0xFF, 0xCF, 0xFE, 0x3D, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xEF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF3, 0xE7, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x78,
  0x7D, 0xE1, 0xE7, 0x8F, 0xBF, 0xFE, 0xFF, 0xF3, 0xDF, 0x8F, 0x3C, 0x00,
  0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x78, 0xFF, 0x8F, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF1, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x07, 0xBE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3C, 0x7C,
  0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0x78, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x1E, 0xF0,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x01, 0xE0, 0x0F, 0x84, 0x7F, 0xF1, 0xFF,
  0x87, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF1, 0xF0, 0x3C,
  0x1F, 0xE7, 0xFC, 0xFF, 0x87, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00,
  0x07, 0x9E, 0x3F, 0xBC, 0x7F, 0xF9, 0xFF, 0xE3, 0xC3, 0xCF, 0x87, 0x9F,
  0x1F, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F,
  0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x1E, 0xF0, 0x03, 0xE1, 0x07, 0xC3,
  0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xEF, 0x0F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C, 0x7D, 0xF1, 0xE7, 0xC7, 0x9F, 0x1E,
  0x78, 0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F,
  0x00, 0x06, 0x0F, 0x1F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8,
  0xF8, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x01, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x3E,
  0x1E, 0x7E, 0x3E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xF0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF0, 0xF8, 0x0F, 0x07, 0x83, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE0, 0x1E, 0xF1,
  0xE1, 0xFF, 0xDF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xC7, 0xCF, 0x9E,
  0x3E, 0x7C, 0xF1, 0xF3, 0xEF, 0x8F, 0x1F, 0x7C, 0x78, 0xFB, 0xE7, 0xC7,
  0x9E, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x9F, 0x7C, 0x78, 0xFB, 0xE3,
  0xC7, 0xDF, 0x1E, 0x3C, 0xF1, 0xF1, 0xE0, 0x3E, 0xF0, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFF, 0x3C, 0x7C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x79, 0xE1,
  0xE7, 0x8F, 0x9E, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0xF0,
  0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xEF, 0x1F, 0x7F, 0xF1,
  0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x0F, 0x78, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF1, 0xE3, 0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF0, 0xF9, 0xE1, 0xE3, 0xC7, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x79,
  0xE0, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0xF8, 0xFB, 0xE3, 0xEF,
  0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x7C, 0xF1, 0xF3,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3,
  0xFC, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7D,
  0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xEF, 0x1F, 0x7C, 0xF9, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x1E, 0x0F,
  0x07, 0x8F, 0xFF, 0xFF, 0xF8, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07,
  0x83, 0xC3, 0xE1, 0xF0, 0xFE, 0x3F, 0x1F, 0x07, 0x80, 0x7C, 0x7D, 0xF1,
  0xF7, 0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0xBE, 0x3E, 0xF8,
  0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F,
  0xF8, 0x3D, 0xE0, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0x9E, 0x3C, 0x79, 0xF1,
  0xE7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xC1, 0xEF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF1, 0xC7, 0xFC,
  0xF1, 0xEF, 0x3C, 0x7B, 0xCF, 0x3E, 0xF7, 0xCF, 0x3D, 0xF3, 0xCF, 0x7F,
  0xE3, 0xFF, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x00,
  0x1E, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xF8, 0xF8, 0x1E, 0x1F,
  0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE0, 0x01, 0x81, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0xC7, 0xC3, 0x81, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x01, 0x00, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E,
  0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x04, 0x07,
  0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x0F, 0x8F, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x06, 0x00, 0x1C, 0x00, 0xFC, 0x77,
  0xF1, 0xDF, 0xFF, 0xF3, 0xFF, 0x87, 0xE0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 9, 8, 10, 2, -23 },
  { 35, 16, 22, 16, 0, -22 },
  { 79, 14, 28, 15, 1, -25 },
  { 128, 14, 22, 19, 3, -22 },
  { 167, 16, 22, 18, 0, -22 },
  { 211, 4, 9, 5, 2, -23 },
  { 216, 10, 31, 10, 1, -24 },
  { 255, 10, 31, 10, -1, -24 },
  { 294, 13, 14, 14, 2, -22 },
  { 317, 13, 16, 14, 1, -18 },
  { 343, 7, 10, 8, -2, -4 },
  { 352, 8, 4, 12, 2, -12 },
  { 356, 5, 5, 9, 1, -5 },
  { 360, 14, 24, 10, -2, -22 },
  { 402, 14, 22, 15, 1, -22 },
  { 441, 10, 22, 15, 3, -22 },
  { 469, 15, 22, 15, 0, -22 },
  { 511, 15, 22, 15, 0, -22 },
  { 553, 15, 22, 15, 0, -22 },
  { 595, 14, 22, 15, 1, -22 },
  { 634, 13, 22, 15, 1, -22 },
  { 670, 15, 22, 15, 1, -22 },
  { 712, 14, 22, 15, 1, -22 },
  { 751, 13, 22, 15, 2, -22 },
  { 787, 7, 17, 9, 1, -17 },
  { 802, 9, 23, 8, -1, -17 },
  { 828, 12, 15, 13, 1, -17 },
  { 851, 13, 11, 15, 1, -15 },
  { 869, 13, 15, 14, 0, -17 },
  { 894, 12, 22, 14, 2, -22 },
  { 927, 22, 28, 23, 0, -21 },
  { 1004, 17, 22, 18, -1, -22 },
  { 1051, 17, 22, 17, 0, -22 },
  { 1098, 16, 22, 17, 1, -22 },
  { 1142, 17, 22, 17, 0, -22 },
  { 1189, 16, 22, 15, 0, -22 },
  { 1233, 16, 22, 14, 0, -22 },
  { 1277, 16, 22, 18, 1, -22 },
  { 1321, 19, 22, 18, 0, -22 },
  { 1374, 9, 22, 8, 0, -22 },
  { 1399, 15, 22, 15, 0, -22 },
  { 1441, 19, 22, 17, 0, -22 },
  { 1494, 13, 22, 14, 0, -22 },
  { 1530, 23, 22, 23, 0, -22 },
  { 1594, 19, 22, 18, 0, -22 },
  { 1647, 17, 22, 18, 1, -22 },
  { 1694, 17, 22, 17, 0, -22 },
  { 1741, 17, 26, 18, 1, -22 },
  { 1797, 17, 22, 17, 0, -22 },
  { 1844, 16, 22, 16, 1, -22 },
  { 1888, 16, 22, 17, 2, -22 },
  { 1932, 17, 22, 17, 1, -22 },
  { 1979, 17, 22, 17, 2, -22 },
  { 2026, 21, 22, 22, 3, -22 },
  { 2084, 20, 22, 17, -1, -22 },
  { 2139, 16, 22, 16, 3, -22 },
  { 2183, 17, 22, 16, 0, -22 },
  { 2230, 11, 31, 8, -1, -26 },
  { 2273, 8, 24, 12, 2, -22 },
  { 2297, 11, 31, 8, -2, -26 },
  { 2340, 11, 11, 12, 1, -22 },
  { 2356, 12, 4, 12, -2, 0 },
  { 2362, 7, 5, 10, 3, -24 },
  { 2367, 13, 17, 14, 0, -17 },
  { 2395, 14, 23, 15, 0, -23 },
  { 2436, 12, 17, 14, 1, -17 },
  { 2462, 16, 23, 15, 0, -23 },
  { 2508, 13, 17, 14, 1, -17 },
  { 2536, 11, 23, 10, 1, -23 },
  { 2568, 15, 23, 15, 0, -17 },
  { 2612, 14, 23, 15, 0, -23 },
  { 2653, 8, 24, 8, 0, -24 },
  { 2677, 12, 30, 8, -4, -24 },
  { 2722, 16, 23, 15, 0, -23 },
  { 2768, 9, 23, 8, 0, -23 },
  { 2794, 21, 17, 22, 0, -17 },
  { 2839, 14, 17, 15, 0, -17 },
  { 2869, 13, 17, 15, 1, -17 },
  { 2897, 15, 23, 15, -1, -17 },
  { 2941, 14, 23, 15, 1, -17 },
  { 2982, 11, 17, 10, 0, -17 },
  { 3006, 13, 17, 14, 0, -17 },
  { 3034, 9, 20, 9, 1, -20 },
  { 3057, 14, 17, 15, 1, -17 },
  { 3087, 14, 17, 14, 1, -17 },
  { 3117, 18, 17, 19, 2, -17 },
  { 3156, 16, 17, 14, -1, -17 },
  { 3190, 16, 23, 14, -1, -17 },
  { 3236, 14, 17, 14, 0, -17 },
  { 3266, 9, 29, 9, 1, -24 },
  { 3299, 7, 26, 8, 0, -22 },
  { 3322, 9, 30, 9, -1, -24 },
  { 3356, 14, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC31PT7B_H_
