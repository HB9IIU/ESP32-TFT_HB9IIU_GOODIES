#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC13PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x36, 0x66, 0x64, 0x0C, 0xC0, 0xBA, 0xAA, 0x14, 0x28, 0x73, 0xF2,
  0x9F, 0x94, 0x28, 0x70, 0x08, 0xE3, 0xDB, 0x60, 0xE0, 0xF3, 0x79, 0xE2,
  0x00, 0x63, 0xDB, 0x9E, 0x10, 0xF5, 0x75, 0x1C, 0x38, 0x78, 0xB1, 0xC7,
  0x6B, 0xB7, 0x7E, 0x7C, 0xEA, 0x22, 0x4C, 0xC8, 0x88, 0x88, 0x88, 0x40,
  0x20, 0x84, 0x21, 0x8C, 0x42, 0x31, 0x88, 0xC4, 0x00, 0x21, 0x3E, 0xCF,
  0x48, 0x10, 0xC7, 0xFF, 0x30, 0xC2, 0x00, 0x6D, 0xE0, 0xFC, 0xF0, 0x0C,
  0x21, 0x84, 0x10, 0x82, 0x18, 0x43, 0x00, 0x73, 0xF7, 0xBD, 0xCE, 0x7E,
  0xE0, 0x17, 0xF3, 0x32, 0x66, 0x60, 0x39, 0xF6, 0xC3, 0x18, 0xC6, 0x3F,
  0xF8, 0x39, 0xF0, 0xCF, 0x38, 0x3C, 0xFE, 0x70, 0x0C, 0x71, 0xCB, 0x6B,
  0xFF, 0xC6, 0x18, 0x3C, 0xF6, 0x1E, 0x6C, 0x3C, 0xDE, 0x70, 0x1C, 0xE6,
  0x1E, 0x7D, 0x34, 0xDE, 0x70, 0x7E, 0xF8, 0x30, 0xC1, 0x86, 0x0C, 0x30,
  0x60, 0x3D, 0xF6, 0xDF, 0x79, 0x3C, 0xFE, 0x70, 0x77, 0xF7, 0xBD, 0xBC,
  0xDE, 0xC0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x02, 0x66, 0xC0, 0x09, 0xFD,
  0xC3, 0x88, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x43, 0x86, 0x7F, 0x40, 0x77,
  0xF6, 0x66, 0x30, 0x18, 0xC0, 0x0F, 0x18, 0xC8, 0x29, 0xD5, 0xAE, 0xB6,
  0x53, 0x6A, 0x9F, 0x60, 0x11, 0x07, 0x80, 0x06, 0x0E, 0x0E, 0x1E, 0x16,
  0x3E, 0x3E, 0x63, 0x63, 0x3C, 0xFD, 0x9B, 0x77, 0xCD, 0xB3, 0x7E, 0xF8,
  0x1C, 0x7D, 0x9B, 0x06, 0x08, 0x11, 0xBE, 0x38, 0x3C, 0xF9, 0x9B, 0x36,
  0x6C, 0xF3, 0x7E, 0xF8, 0x3E, 0xFD, 0x83, 0xE7, 0x8C, 0x30, 0x7C, 0xF8,
  0x3E, 0xF9, 0x83, 0xE7, 0x8C, 0x30, 0x60, 0xC0, 0x1C, 0x7D, 0x9B, 0x06,
  0x0D, 0xD9, 0xBF, 0x3C, 0x23, 0x63, 0x63, 0x7E, 0x7E, 0x66, 0xC6, 0xC6,
  0xC4, 0x36, 0x66, 0x66, 0x4C, 0xC0, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xB6,
  0x7C, 0x70, 0x27, 0x66, 0x6C, 0x78, 0x78, 0x78, 0xDC, 0xCC, 0xCC, 0x23,
  0x18, 0xC6, 0x33, 0x1F, 0xF8, 0x31, 0xDC, 0x77, 0x39, 0xCE, 0x77, 0x9F,
  0x6D, 0xDB, 0x66, 0xDB, 0x00, 0x33, 0x73, 0x73, 0x76, 0x7E, 0x6E, 0xCE,
  0xCE, 0xCC, 0x1C, 0x7D, 0x9B, 0x36, 0x6C, 0xD1, 0xBE, 0x38, 0x3C, 0xFD,
  0x9B, 0x37, 0xEF, 0xB0, 0x60, 0xC0, 0x1C, 0x7D, 0x9B, 0x36, 0x68, 0xD1,
  0xBE, 0x38, 0x18, 0x10, 0x3C, 0xFD, 0x9B, 0x37, 0xCF, 0x37, 0x66, 0xCC,
  0x3C, 0xFD, 0x9B, 0x83, 0x81, 0xB3, 0x3E, 0x78, 0xFD, 0xF8, 0xC1, 0x83,
  0x0C, 0x18, 0x30, 0x60, 0x62, 0x66, 0x66, 0x66, 0x66, 0x66, 0xCC, 0x7C,
  0x78, 0xC7, 0x9B, 0x36, 0x65, 0x8B, 0x1C, 0x38, 0x60, 0xC9, 0xEC, 0xF6,
  0xDB, 0x6F, 0xB7, 0x73, 0xB9, 0xDC, 0xCC, 0x00, 0x66, 0x36, 0x3C, 0x3C,
  0x38, 0x38, 0x6C, 0xEC, 0xCC, 0xCF, 0x99, 0x63, 0xC7, 0x0E, 0x18, 0x30,
  0x60, 0x7E, 0xFC, 0x30, 0xC3, 0x86, 0x18, 0x7E, 0xFC, 0x36, 0x66, 0x66,
  0x64, 0xCC, 0xCC, 0xC0, 0xDB, 0x64, 0xDB, 0x6C, 0x38, 0xCC, 0x63, 0x18,
  0xC6, 0x23, 0x18, 0xCE, 0x00, 0x31, 0x8C, 0xF5, 0x80, 0xFF, 0xC0, 0x6C,
  0x39, 0xE0, 0x9E, 0xDB, 0x67, 0x80, 0x21, 0x86, 0x1E, 0x7D, 0xB4, 0xF3,
  0xFB, 0xE0, 0x39, 0xEC, 0xF0, 0xDB, 0xE7, 0x00, 0x06, 0x08, 0x33, 0xE7,
  0xD9, 0xB3, 0x64, 0xF8, 0xF0, 0x39, 0xF4, 0xFF, 0xC3, 0xE7, 0x80, 0x19,
  0xC8, 0xE6, 0x31, 0x8C, 0x46, 0x00, 0x3D, 0xFC, 0xF3, 0xCF, 0xE7, 0x86,
  0xFB, 0xC0, 0x61, 0x86, 0x1E, 0x7D, 0xBC, 0xF2, 0xDB, 0x60, 0x24, 0x36,
  0xDE, 0xD8, 0x11, 0x03, 0x33, 0x36, 0x66, 0x6E, 0xC0, 0x20, 0xC1, 0x83,
  0x67, 0x8F, 0x1C, 0x7C, 0xD9, 0xB0, 0x36, 0x66, 0x66, 0x4C, 0xCC, 0x7B,
  0x3F, 0xDB, 0x69, 0xBD, 0x96, 0xDB, 0x6C, 0x79, 0xF6, 0xF3, 0xCB, 0x6D,
  0x80, 0x39, 0xF4, 0xF3, 0xCF, 0xE7, 0x00, 0x3C, 0x7C, 0xD9, 0x36, 0x6F,
  0x9F, 0x30, 0x60, 0x80, 0x7D, 0xFC, 0xF3, 0xCB, 0xE7, 0x86, 0x18, 0x60,
  0x73, 0x98, 0x8C, 0x63, 0x00, 0x39, 0xE6, 0x1C, 0x1B, 0x67, 0x00, 0x26,
  0x76, 0x66, 0x66, 0x60, 0x6D, 0xB6, 0xF3, 0xCB, 0xE7, 0x80, 0xDE, 0xBD,
  0xEE, 0x73, 0x00, 0x97, 0x6E, 0xD7, 0xED, 0xDB, 0x36, 0x00, 0x6D, 0xE7,
  0x8C, 0x73, 0x6D, 0x80, 0x6D, 0xB7, 0x9E, 0x71, 0xC6, 0x18, 0xE3, 0x00,
  0x7D, 0xE3, 0x8C, 0x63, 0xEF, 0x80, 0x13, 0x22, 0x66, 0xC4, 0x44, 0x44,
  0x24, 0xA4, 0x92, 0x5A, 0x00, 0x46, 0x26, 0x66, 0x26, 0x4C, 0xC8, 0x75,
  0xFD, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 4, 4, 1, -10 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 6, 9, 8, 1, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 2, 4, 2, 1, -10 },
  { 41, 4, 13, 4, 1, -10 },
  { 48, 5, 13, 4, -1, -10 },
  { 57, 5, 6, 6, 1, -9 },
  { 61, 6, 7, 6, 0, -7 },
  { 67, 3, 4, 3, -1, -2 },
  { 69, 3, 2, 5, 1, -5 },
  { 70, 2, 2, 4, 0, -2 },
  { 71, 6, 10, 4, -1, -9 },
  { 79, 5, 9, 6, 1, -9 },
  { 85, 4, 9, 6, 1, -9 },
  { 90, 6, 9, 6, 0, -9 },
  { 97, 6, 9, 6, 0, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 6, 9, 6, 0, -9 },
  { 125, 7, 9, 6, 0, -9 },
  { 133, 6, 9, 6, 0, -9 },
  { 140, 5, 9, 6, 1, -9 },
  { 146, 3, 7, 4, 0, -7 },
  { 149, 4, 9, 3, -1, -7 },
  { 154, 5, 6, 6, 0, -7 },
  { 158, 6, 6, 6, 0, -7 },
  { 163, 5, 6, 6, 0, -7 },
  { 167, 5, 9, 6, 1, -9 },
  { 173, 9, 12, 10, 0, -9 },
  { 187, 8, 9, 8, -1, -9 },
  { 196, 7, 9, 7, 0, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 7, 9, 7, 0, -9 },
  { 220, 7, 9, 6, 0, -9 },
  { 228, 7, 9, 6, 0, -9 },
  { 236, 7, 9, 7, 0, -9 },
  { 244, 8, 9, 8, 0, -9 },
  { 253, 4, 9, 3, 0, -9 },
  { 258, 7, 9, 6, 0, -9 },
  { 266, 8, 9, 7, 0, -9 },
  { 275, 5, 9, 6, 0, -9 },
  { 281, 10, 9, 10, 0, -9 },
  { 293, 8, 9, 8, 0, -9 },
  { 302, 7, 9, 8, 0, -9 },
  { 310, 7, 9, 7, 0, -9 },
  { 318, 7, 11, 8, 0, -9 },
  { 328, 7, 9, 7, 0, -9 },
  { 336, 7, 9, 7, 0, -9 },
  { 344, 7, 9, 7, 1, -9 },
  { 352, 8, 9, 7, 0, -9 },
  { 361, 7, 9, 7, 1, -9 },
  { 369, 9, 9, 9, 1, -9 },
  { 380, 8, 9, 7, 0, -9 },
  { 389, 7, 9, 7, 1, -9 },
  { 397, 7, 9, 7, 0, -9 },
  { 405, 4, 13, 3, 0, -11 },
  { 412, 3, 10, 5, 1, -9 },
  { 416, 5, 13, 3, -1, -11 },
  { 425, 5, 5, 5, 0, -9 },
  { 429, 5, 2, 5, -1, 0 },
  { 431, 3, 2, 4, 1, -10 },
  { 432, 6, 7, 6, 0, -7 },
  { 438, 6, 10, 6, 0, -10 },
  { 446, 6, 7, 6, 0, -7 },
  { 452, 7, 10, 6, 0, -10 },
  { 461, 6, 7, 6, 0, -7 },
  { 467, 5, 10, 4, 0, -10 },
  { 474, 6, 10, 6, 0, -7 },
  { 482, 6, 10, 6, 0, -10 },
  { 490, 3, 10, 3, 0, -10 },
  { 494, 4, 13, 3, -1, -10 },
  { 501, 7, 10, 6, 0, -10 },
  { 510, 4, 10, 3, 0, -10 },
  { 515, 9, 7, 9, 0, -7 },
  { 523, 6, 7, 6, 0, -7 },
  { 529, 6, 7, 6, 0, -7 },
  { 535, 7, 10, 6, -1, -7 },
  { 544, 6, 10, 6, 0, -7 },
  { 552, 5, 7, 4, 0, -7 },
  { 557, 6, 7, 6, 0, -7 },
  { 563, 4, 9, 4, 0, -9 },
  { 568, 6, 7, 6, 0, -7 },
  { 574, 5, 7, 6, 1, -7 },
  { 579, 7, 7, 8, 1, -7 },
  { 586, 6, 7, 6, 0, -7 },
  { 592, 6, 10, 6, 0, -7 },
  { 600, 6, 7, 6, 0, -7 },
  { 606, 4, 12, 4, 0, -10 },
  { 612, 3, 11, 3, 0, -9 },
  { 617, 4, 12, 4, 0, -10 },
  { 623, 6, 3, 7, 0, -5 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC13PT7B_H_
