#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC42PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x3C, 0x79, 0xE7, 0xDF, 0x3E,
  0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C,
  0x78, 0x00, 0x1C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x00, 0x1E, 0x78, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1E, 0x78, 0x00,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0xF0,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0x1E, 0x1D, 0xE3, 0xC7, 0xBC, 0x78, 0xF7, 0x8F, 0x3C, 0xF1, 0xEF,
  0x1E, 0x7B, 0xE3, 0xFF, 0x78, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7C, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xEF, 0x80, 0x7F, 0xF8, 0x1E, 0xFF,
  0x87, 0xBF, 0xF0, 0xF7, 0x9E, 0x3D, 0xE3, 0xCF, 0x3C, 0x79, 0xE7, 0x8F,
  0x78, 0xF1, 0xFE, 0x1E, 0x3C, 0xC3, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x1F, 0x1F,
  0xFC, 0xFC, 0xFF, 0xF3, 0xE3, 0xFF, 0xEF, 0x9F, 0x9F, 0xFE, 0x7E, 0x3F,
  0xF9, 0xF8, 0xFF, 0xC7, 0xE1, 0xFF, 0x1F, 0x87, 0xF8, 0x7F, 0x1F, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFB, 0xF0, 0x1F,
  0x8F, 0xE0, 0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF3, 0xE7,
  0x80, 0x00, 0x10, 0x01, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1C,
  0x38, 0x77, 0xCE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0x7E,
  0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xE3, 0xC1, 0xF0, 0xF0,
  0x38, 0x3C, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1E, 0x02, 0x00, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x30, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE7, 0xE3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xF0,
  0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x1F, 0xFC, 0x73, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F,
  0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F, 0x3F, 0x07,
  0xEF, 0xE0, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x7C, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xE1, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF8, 0xFE, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x9F, 0x0F, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7F, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0x9F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x3F, 0x07, 0xC7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xE3, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0xFE, 0x3F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF3, 0xF9,
  0xF9, 0xF8, 0x7D, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xEF, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xC0, 0x00, 0x06, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC1, 0xE0, 0x00, 0xC0,
  0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC0, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0x80, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x70, 0xF8, 0x1F, 0x03, 0x87, 0x83, 0xFE, 0x1E,
  0x7C, 0x3F, 0xF8, 0xF3, 0xC3, 0xFF, 0xC7, 0x9E, 0x1F, 0x1E, 0x3D, 0xE1,
  0xF1, 0xE1, 0xEF, 0x0F, 0x0F, 0x0F, 0x78, 0xF8, 0x78, 0x7F, 0x87, 0x83,
  0xC3, 0xBC, 0x3C, 0x3C, 0x1D, 0xE3, 0xE1, 0xE1, 0xEF, 0x1F, 0x0F, 0x0F,
  0x78, 0xF8, 0xF8, 0x7B, 0xC7, 0x87, 0x83, 0x9E, 0x3C, 0x3C, 0x3C, 0xF1,
  0xF3, 0xE3, 0xC7, 0x8F, 0xFF, 0xBE, 0x3C, 0x3F, 0xBF, 0xE1, 0xE1, 0xFD,
  0xFE, 0x0F, 0x07, 0x87, 0xC0, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC,
  0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F,
  0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF9,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0x7E, 0x1F, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x8F, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xFD,
  0xFC, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE1, 0xFF, 0xBF, 0x8F, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0, 0xFF,
  0xCF, 0xC3, 0xFF, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x81, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0,
  0x7E, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7E,
  0x0F, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0x9F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xBC,
  0x3E, 0xFC, 0x1F, 0xBC, 0x3F, 0xF8, 0x1F, 0xBC, 0x7D, 0xF8, 0x1F, 0xBC,
  0x7D, 0xF8, 0x3F, 0x3C, 0x7D, 0xF8, 0x3F, 0x3C, 0xF9, 0xF8, 0x3F, 0x3E,
  0xFB, 0xF8, 0x3F, 0x3F, 0xF3, 0xF0, 0x3F, 0x3F, 0xF3, 0xF0, 0x7F, 0x3F,
  0xE3, 0xF0, 0x7F, 0x1F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F,
  0xC7, 0xF0, 0x7E, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0xFE, 0x1F,
  0x87, 0xE0, 0xFE, 0x1F, 0x0F, 0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F,
  0xF0, 0x1F, 0x83, 0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0xFC,
  0x0F, 0xF8, 0x3F, 0x03, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF1,
  0xFC, 0x1F, 0xBC, 0x7F, 0x07, 0xEF, 0x9F, 0x81, 0xF9, 0xE7, 0xE0, 0x7E,
  0x79, 0xF8, 0x3F, 0x9E, 0x7E, 0x0F, 0xE7, 0xFF, 0x83, 0xF0, 0xFF, 0xE0,
  0xFC, 0x3F, 0xF0, 0x3F, 0x0F, 0xFC, 0x1F, 0xC3, 0xFF, 0x07, 0xF0, 0x7F,
  0xC1, 0xFC, 0x1F, 0xF0, 0x7E, 0x07, 0xFC, 0x1F, 0x81, 0xFE, 0x07, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x8F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE,
  0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xE0, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x9F, 0xE3, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x01, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x83, 0xF8,
  0xFF, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8,
  0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC3,
  0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xF1, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xC1,
  0xFC, 0x7F, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x7E, 0xFC, 0x3F, 0x87, 0xEF,
  0xC7, 0xF8, 0xFE, 0xFC, 0x7F, 0x8F, 0xCF, 0xC7, 0xF8, 0xFC, 0xFC, 0xFF,
  0x8F, 0xCF, 0xCF, 0xF9, 0xF8, 0xFC, 0xFF, 0x9F, 0x8F, 0xDF, 0xF9, 0xF8,
  0xFD, 0xFF, 0xBF, 0x0F, 0xDF, 0xFB, 0xF0, 0xFF, 0xFF, 0xBF, 0x0F, 0xFE,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFD,
  0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0xFC,
  0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0x7C, 0x7E,
  0x01, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x1F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xBC,
  0x0F, 0x3C, 0x3E, 0x78, 0xF8, 0xF1, 0xF1, 0xE7, 0xC3, 0xCF, 0x87, 0xBE,
  0x0F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF8,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0x8F, 0xEF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xBF, 0x07, 0xCF, 0xC0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x7C, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC,
  0x7F, 0x3F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xDF, 0xC3, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF9, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0x7F,
  0x87, 0xE7, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF3, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFE, 0xF8, 0x03,
  0xE7, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x10, 0xFE, 0x1C, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xF9, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0x07, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x7C,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x7F,
  0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0x00, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF1,
  0xFE, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xCF, 0xE0, 0x7E, 0xFE, 0x03,
  0xF7, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x0F, 0x9F, 0x07, 0xC0,
  0xFD, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x87, 0xE7, 0xF1, 0xFC, 0x3F, 0x3F, 0x0F, 0xC3, 0xF9, 0xF8,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x3F, 0x3F, 0x8F, 0xE1, 0xF9, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0x03, 0xF7, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7F, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC,
  0x3F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0,
  0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFE, 0x3F, 0x1F,
  0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xF1, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xF7, 0xF8, 0x1F, 0x9F, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE1,
  0xFE, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3E,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0x9E, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xDF, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xF3,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F,
  0xE7, 0xE1, 0xF8, 0xFE, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFB, 0xE0, 0x3E, 0x7C, 0x00, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3,
  0xFB, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8,
  0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x3E, 0x1F, 0xFE,
  0x1F, 0x1F, 0xBF, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7, 0xCF, 0xCF, 0xE7, 0xE3,
  0xE7, 0xF3, 0xF1, 0xF3, 0xF9, 0xF0, 0xFB, 0xFD, 0xF8, 0x7D, 0xFE, 0xFC,
  0x3E, 0xFF, 0x7C, 0x1F, 0xFF, 0xBE, 0x0F, 0xFB, 0xFF, 0x07, 0xFD, 0xFF,
  0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1,
  0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x3F, 0x01, 0xF9, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F,
  0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x30, 0x03, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x38, 0x00, 0x80, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x02, 0x00, 0x38,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xE0, 0x0C, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x0F, 0x3F, 0xE1, 0xF3, 0xFF, 0x3F, 0x7F, 0xFF, 0xE7, 0xCF, 0xFE,
  0x78, 0x7F, 0xCF, 0x83, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 30, 11, 1, -30 },
  { 43, 13, 11, 13, 2, -32 },
  { 61, 21, 30, 21, 0, -30 },
  { 140, 19, 38, 21, 1, -34 },
  { 231, 19, 30, 26, 4, -30 },
  { 303, 22, 30, 24, 0, -30 },
  { 386, 7, 12, 6, 2, -32 },
  { 397, 13, 42, 13, 2, -33 },
  { 466, 14, 42, 13, -2, -33 },
  { 540, 18, 18, 19, 2, -30 },
  { 581, 18, 22, 19, 1, -25 },
  { 631, 9, 13, 10, -2, -5 },
  { 646, 11, 5, 16, 2, -15 },
  { 653, 7, 7, 12, 1, -7 },
  { 660, 19, 33, 13, -3, -30 },
  { 739, 18, 30, 21, 2, -30 },
  { 807, 14, 30, 21, 4, -30 },
  { 860, 20, 30, 21, 0, -30 },
  { 935, 20, 30, 21, 0, -30 },
  { 1010, 19, 30, 21, 1, -30 },
  { 1082, 20, 30, 21, 1, -30 },
  { 1157, 17, 30, 21, 2, -30 },
  { 1221, 20, 30, 21, 2, -30 },
  { 1296, 19, 30, 21, 1, -30 },
  { 1368, 17, 30, 21, 3, -30 },
  { 1432, 10, 24, 12, 1, -24 },
  { 1462, 12, 32, 11, -2, -24 },
  { 1510, 17, 20, 18, 1, -23 },
  { 1553, 18, 14, 21, 1, -20 },
  { 1585, 17, 20, 18, 1, -22 },
  { 1628, 16, 30, 18, 3, -30 },
  { 1688, 29, 38, 31, 1, -29 },
  { 1826, 24, 30, 24, -2, -30 },
  { 1916, 23, 30, 23, 0, -30 },
  { 2003, 23, 30, 23, 1, -30 },
  { 2090, 22, 30, 23, 0, -30 },
  { 2173, 22, 30, 20, 0, -30 },
  { 2256, 22, 30, 19, 0, -30 },
  { 2339, 22, 30, 24, 2, -30 },
  { 2422, 26, 30, 25, 0, -30 },
  { 2520, 12, 30, 11, 0, -30 },
  { 2565, 21, 30, 20, 0, -30 },
  { 2644, 26, 30, 23, 0, -30 },
  { 2742, 17, 30, 20, 0, -30 },
  { 2806, 32, 30, 31, 0, -30 },
  { 2926, 26, 30, 25, 0, -30 },
  { 3024, 23, 30, 25, 1, -30 },
  { 3111, 23, 30, 23, 0, -30 },
  { 3198, 22, 35, 25, 2, -30 },
  { 3295, 23, 30, 23, 0, -30 },
  { 3382, 21, 30, 22, 1, -30 },
  { 3461, 21, 30, 22, 3, -30 },
  { 3540, 23, 30, 23, 1, -30 },
  { 3627, 23, 30, 24, 3, -30 },
  { 3714, 28, 30, 30, 4, -30 },
  { 3819, 27, 30, 23, -2, -30 },
  { 3921, 22, 30, 22, 3, -30 },
  { 4004, 24, 30, 22, -1, -30 },
  { 4094, 15, 42, 11, -1, -35 },
  { 4173, 11, 33, 16, 3, -30 },
  { 4219, 14, 42, 11, -2, -35 },
  { 4293, 15, 15, 16, 1, -30 },
  { 4322, 17, 5, 16, -3, 0 },
  { 4333, 10, 6, 14, 4, -31 },
  { 4341, 18, 22, 19, 0, -22 },
  { 4391, 19, 32, 20, 0, -32 },
  { 4467, 17, 22, 19, 1, -22 },
  { 4514, 21, 32, 20, 1, -32 },
  { 4598, 18, 22, 20, 1, -22 },
  { 4648, 15, 32, 13, 1, -32 },
  { 4708, 20, 31, 21, 0, -22 },
  { 4786, 19, 32, 20, 0, -32 },
  { 4862, 11, 32, 10, 0, -32 },
  { 4906, 16, 41, 10, -5, -32 },
  { 4988, 21, 32, 20, 0, -32 },
  { 5072, 12, 32, 10, 0, -32 },
  { 5120, 29, 22, 30, 0, -22 },
  { 5200, 19, 22, 20, 0, -22 },
  { 5253, 18, 22, 20, 1, -22 },
  { 5303, 21, 31, 20, -2, -22 },
  { 5385, 19, 31, 20, 1, -22 },
  { 5459, 15, 22, 14, 0, -22 },
  { 5501, 18, 22, 18, 0, -22 },
  { 5551, 12, 28, 13, 1, -28 },
  { 5593, 19, 22, 20, 1, -22 },
  { 5646, 18, 22, 19, 2, -22 },
  { 5696, 25, 22, 26, 2, -22 },
  { 5765, 22, 22, 19, -2, -22 },
  { 5826, 21, 31, 18, -1, -22 },
  { 5908, 20, 22, 19, -1, -22 },
  { 5963, 13, 40, 12, 1, -33 },
  { 6028, 9, 36, 10, 1, -30 },
  { 6069, 12, 40, 12, -1, -33 },
  { 6129, 20, 9, 22, 1, -17 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC42PT7B_H_
