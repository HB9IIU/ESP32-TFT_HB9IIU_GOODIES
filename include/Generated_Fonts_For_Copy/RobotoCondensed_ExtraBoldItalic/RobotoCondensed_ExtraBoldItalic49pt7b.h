#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC49PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x3F, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x9F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x80, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x03,
  0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0xCF, 0x80, 0x07,
  0xCF, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xCF, 0x81, 0x8F, 0x8F, 0x07, 0x9E,
  0x1E, 0x1F, 0x7C, 0x3C, 0x3C, 0xF8, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xE3,
  0xEF, 0x83, 0xCF, 0xDE, 0x07, 0xFF, 0x7C, 0x0F, 0xFD, 0xF0, 0x0F, 0xFB,
  0xC0, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x1F, 0x7F, 0x80, 0x3D, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xEF, 0x9F, 0x07, 0x9F, 0x1E, 0x1F, 0x7C, 0x3C, 0x7C, 0xF8, 0x78,
  0xF1, 0xF0, 0xF3, 0xE3, 0xE3, 0xEF, 0x87, 0xC7, 0xCE, 0x0F, 0x9F, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x07,
  0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07,
  0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0x1F, 0xFE, 0x3F, 0x3F,
  0xFF, 0x3F, 0x7F, 0x7F, 0x3F, 0x7F, 0x7F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFE,
  0x3F, 0xFE, 0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFC, 0xFE, 0x0F, 0xFC, 0xFE,
  0x0F, 0xF8, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFE, 0x01, 0x80, 0x00, 0x3E,
  0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x00, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x10, 0x1E, 0x04, 0xE0,
  0xF0, 0xEF, 0xC7, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF3,
  0xC0, 0x1F, 0x1F, 0x01, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x38, 0x0E, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x06, 0x00, 0x7F, 0xFB, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x3F, 0xF1, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xF3, 0xFB, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xFC, 0x0F,
  0xCF, 0xF0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFD, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0x9F, 0xE0, 0x1C, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x7F,
  0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x9F, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7,
  0xF8, 0x7F, 0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xCF, 0xE3, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7D, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x07, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01,
  0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0xFC, 0x1E, 0x0F, 0x83, 0xFF,
  0xC7, 0xC7, 0xC1, 0xFF, 0xF1, 0xF1, 0xF0, 0xFE, 0x7C, 0x3C, 0xF8, 0x7E,
  0x1E, 0x0F, 0x3E, 0x1F, 0x0F, 0x83, 0xDF, 0x0F, 0xC3, 0xE1, 0xF7, 0xC3,
  0xE0, 0xF8, 0x7D, 0xF0, 0xF8, 0x3E, 0x1F, 0x78, 0x7E, 0x1F, 0x07, 0xBE,
  0x1F, 0x07, 0xC1, 0xEF, 0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xF0, 0x7C, 0x1E,
  0xF8, 0xFC, 0x3E, 0x0F, 0xBC, 0x3F, 0x0F, 0x83, 0xCF, 0x0F, 0xC3, 0xE0,
  0xF3, 0xC3, 0xF0, 0xF8, 0x7C, 0xF0, 0xFC, 0x7E, 0x1E, 0x3C, 0x3F, 0x3F,
  0x8F, 0x8F, 0x07, 0xFF, 0xF7, 0xC3, 0xC1, 0xFF, 0xFF, 0xE0, 0xF8, 0x3F,
  0x9F, 0xF0, 0x3E, 0x0F, 0xC3, 0xF8, 0x0F, 0x80, 0x40, 0x30, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x1F, 0xF1, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x07,
  0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF,
  0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0x0F, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F,
  0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x07, 0xFF, 0x9F, 0xC1, 0xFF, 0xCF, 0xF0, 0xFF, 0xF3, 0xFC, 0x3F, 0xFC,
  0xFF, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x03,
  0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0x81, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xF1, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF8,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x1F,
  0xBF, 0x83, 0xFB, 0xF0, 0xFF, 0xF8, 0x1F, 0xDF, 0x87, 0xDF, 0xC0, 0xFE,
  0xFC, 0x7E, 0xFE, 0x07, 0xF3, 0xE3, 0xE7, 0xF0, 0x3F, 0x9F, 0x3F, 0x3F,
  0x81, 0xFC, 0xF9, 0xFB, 0xFC, 0x1F, 0xE7, 0xDF, 0x9F, 0xC0, 0xFE, 0x3E,
  0xFC, 0xFE, 0x07, 0xF1, 0xF7, 0xC7, 0xF0, 0x3F, 0x8F, 0xFE, 0x7F, 0x81,
  0xFC, 0x7F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0,
  0xFE, 0x07, 0xF8, 0xFF, 0x87, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0xFE,
  0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0xC1, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00,
  0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F,
  0x81, 0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0,
  0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F,
  0xBE, 0x3F, 0xC0, 0xFE, 0xF8, 0xFF, 0x07, 0xFB, 0xE3, 0xF8, 0x1F, 0xEF,
  0x8F, 0xE0, 0x7F, 0x1F, 0x3F, 0x81, 0xFC, 0x7D, 0xFE, 0x07, 0xF1, 0xF7,
  0xF8, 0x1F, 0xC7, 0xDF, 0xE0, 0xFF, 0x0F, 0x7F, 0x03, 0xFC, 0x3F, 0xFC,
  0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x07,
  0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x81, 0xFC,
  0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0xFE,
  0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x8F, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3,
  0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0xC0,
  0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7,
  0xF8, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC7,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x03, 0xFB, 0xF8,
  0x1F, 0xC1, 0xFE, 0xFE, 0x0F, 0xF0, 0x7F, 0x3F, 0x83, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0xC3, 0xF8, 0xFE, 0x1F, 0xF0, 0xFE,
  0x3F, 0x87, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0xC7,
  0xF0, 0xFE, 0x3F, 0xF1, 0xFC, 0x3F, 0x9F, 0xFC, 0xFF, 0x0F, 0xE7, 0xFF,
  0x3F, 0x83, 0xF9, 0xFF, 0xCF, 0xE0, 0xFE, 0xFF, 0xF7, 0xF8, 0x3F, 0xBF,
  0xFD, 0xFC, 0x0F, 0xEF, 0xFF, 0x7F, 0x03, 0xFF, 0xE7, 0xDF, 0xC0, 0xFF,
  0xF9, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xFC, 0x00,
  0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF,
  0x83, 0xE7, 0xC3, 0xF1, 0xE1, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC,
  0x1F, 0x7C, 0x0F, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7F,
  0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7C,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF9, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F,
  0xE7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xEF, 0xFC, 0x3F, 0xBF, 0xE0, 0xFC, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xF1,
  0xFC, 0x07, 0xFD, 0xFC, 0x0F, 0xFD, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF,
  0xC0, 0x0F, 0x9F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x40, 0xFE, 0x0F, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xE8, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x03, 0xFE, 0x7F, 0x07, 0xFF, 0x7E,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x87, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x20, 0x1F, 0xE0, 0x30, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF9, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3,
  0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF9,
  0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0x00, 0x40, 0x0F,
  0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0x7F, 0x1F, 0xF0, 0x3F, 0x9F,
  0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xCF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x7C, 0x07, 0xF7, 0xF8, 0xFF, 0x03,
  0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xF8, 0xFE, 0x3F, 0x87, 0xF8, 0x7F,
  0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xCF, 0xF0, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x87, 0xF9, 0xFC, 0x1F, 0xC3,
  0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE0, 0xFE, 0x7F, 0x87, 0xF0,
  0x7F, 0x3F, 0x83, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xF3, 0xFC, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE1, 0xFE, 0x7F, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xE1, 0xFE, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07,
  0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xEF, 0xF0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFE, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF9, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE1, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xBF, 0xF0,
  0x3F, 0xBF, 0xE0, 0x3F, 0x8F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0xFC, 0x1F, 0xF7, 0xF0, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xE7, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xF3, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x8F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xCF, 0xF0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1,
  0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0xC3, 0xFC,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3E, 0x00, 0x00, 0xFF, 0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xC3, 0xFC,
  0xFE, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0xFE, 0x03,
  0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0x07, 0xFF, 0xC1, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F, 0xEF,
  0xC3, 0xF8, 0xFE, 0xFC, 0x3F, 0x8F, 0xEF, 0xC7, 0xF8, 0xFC, 0xFC, 0x7F,
  0x9F, 0xCF, 0xCF, 0xF9, 0xF8, 0xFC, 0xFF, 0x9F, 0x8F, 0xCF, 0xFB, 0xF8,
  0xFD, 0xFF, 0xBF, 0x0F, 0xDF, 0xFB, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE,
  0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x83,
  0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xDF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE,
  0x7E, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x87, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xFC,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0,
  0x0F, 0xEF, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xDF, 0xFE, 0x1F, 0x7F, 0xF8,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xBE, 0x1F, 0xFE, 0xF8, 0x3F, 0xF3,
  0xE0, 0x7F, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 35, 12, 1, -35 },
  { 58, 15, 13, 15, 2, -37 },
  { 83, 24, 35, 25, 1, -35 },
  { 188, 23, 45, 24, 1, -40 },
  { 318, 23, 35, 30, 4, -35 },
  { 419, 24, 36, 28, 1, -35 },
  { 527, 7, 13, 8, 3, -37 },
  { 539, 15, 50, 15, 2, -39 },
  { 633, 15, 50, 15, -2, -39 },
  { 727, 21, 21, 22, 2, -35 },
  { 783, 21, 26, 22, 1, -29 },
  { 852, 11, 15, 12, -3, -6 },
  { 873, 13, 6, 19, 3, -18 },
  { 883, 8, 8, 14, 1, -8 },
  { 891, 21, 38, 15, -3, -35 },
  { 991, 21, 35, 24, 2, -35 },
  { 1083, 15, 35, 24, 5, -35 },
  { 1149, 24, 35, 24, 0, -35 },
  { 1254, 24, 35, 24, 0, -35 },
  { 1359, 22, 35, 24, 1, -35 },
  { 1456, 23, 35, 24, 1, -35 },
  { 1557, 20, 35, 24, 2, -35 },
  { 1645, 23, 35, 24, 2, -35 },
  { 1746, 23, 35, 24, 1, -35 },
  { 1847, 20, 35, 24, 3, -35 },
  { 1935, 12, 27, 14, 1, -27 },
  { 1976, 14, 36, 13, -2, -27 },
  { 2039, 20, 24, 21, 1, -27 },
  { 2099, 21, 17, 24, 2, -24 },
  { 2144, 20, 23, 22, 1, -26 },
  { 2202, 19, 35, 22, 3, -35 },
  { 2286, 34, 45, 36, 1, -34 },
  { 2478, 28, 35, 29, -2, -35 },
  { 2601, 26, 35, 27, 0, -35 },
  { 2715, 25, 35, 27, 2, -35 },
  { 2825, 26, 35, 27, 0, -35 },
  { 2939, 26, 35, 23, 0, -35 },
  { 3053, 25, 35, 23, 0, -35 },
  { 3163, 26, 35, 28, 2, -35 },
  { 3277, 30, 35, 29, 0, -35 },
  { 3409, 14, 35, 13, 0, -35 },
  { 3471, 24, 35, 23, 0, -35 },
  { 3576, 30, 35, 26, 0, -35 },
  { 3708, 20, 35, 23, 0, -35 },
  { 3796, 37, 35, 36, 0, -35 },
  { 3958, 30, 35, 29, 0, -35 },
  { 4090, 26, 35, 29, 2, -35 },
  { 4204, 27, 35, 27, 0, -35 },
  { 4323, 26, 41, 29, 2, -35 },
  { 4457, 27, 35, 27, 0, -35 },
  { 4576, 25, 35, 26, 1, -35 },
  { 4686, 25, 35, 26, 4, -35 },
  { 4796, 28, 35, 27, 1, -35 },
  { 4919, 27, 35, 28, 4, -35 },
  { 5038, 34, 35, 35, 4, -35 },
  { 5187, 31, 35, 27, -2, -35 },
  { 5323, 25, 35, 26, 4, -35 },
  { 5433, 28, 35, 25, -1, -35 },
  { 5556, 17, 49, 13, -1, -41 },
  { 5661, 12, 38, 18, 4, -35 },
  { 5718, 17, 49, 13, -3, -41 },
  { 5823, 17, 17, 19, 1, -35 },
  { 5860, 19, 6, 19, -3, 0 },
  { 5875, 11, 7, 16, 5, -36 },
  { 5885, 21, 26, 22, 0, -26 },
  { 5954, 22, 37, 24, 0, -37 },
  { 6056, 20, 26, 22, 1, -26 },
  { 6121, 24, 37, 24, 1, -37 },
  { 6232, 21, 26, 23, 1, -26 },
  { 6301, 18, 38, 16, 1, -38 },
  { 6387, 24, 36, 24, 0, -26 },
  { 6495, 22, 37, 24, 0, -37 },
  { 6597, 13, 37, 12, 0, -37 },
  { 6658, 19, 47, 12, -6, -37 },
  { 6770, 25, 37, 23, 0, -37 },
  { 6886, 14, 37, 12, 0, -37 },
  { 6951, 33, 26, 35, 0, -26 },
  { 7059, 22, 26, 24, 0, -26 },
  { 7131, 21, 26, 24, 1, -26 },
  { 7200, 24, 36, 24, -2, -26 },
  { 7308, 22, 36, 24, 1, -26 },
  { 7407, 17, 26, 16, 0, -26 },
  { 7463, 21, 26, 22, 0, -26 },
  { 7532, 14, 32, 15, 2, -32 },
  { 7588, 22, 26, 24, 1, -26 },
  { 7660, 21, 26, 22, 2, -26 },
  { 7729, 28, 26, 30, 3, -26 },
  { 7820, 25, 26, 22, -2, -26 },
  { 7902, 24, 36, 22, -1, -26 },
  { 8010, 23, 26, 22, -1, -26 },
  { 8085, 15, 47, 14, 1, -38 },
  { 8174, 10, 41, 12, 1, -35 },
  { 8226, 15, 47, 14, -2, -38 },
  { 8315, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC49PT7B_H_
