#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC37PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x00, 0x79, 0xEF,
  0x3D, 0xE7, 0xBC, 0xF7, 0x1C, 0xE7, 0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x70,
  0x00, 0x79, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x78,
  0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x78, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x78, 0x01, 0xCE, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xCF, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x0F,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0x8F, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0x7E, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xEF, 0x0C,
  0xF1, 0xC7, 0xBC, 0x71, 0xCF, 0x1C, 0xE3, 0xCF, 0x78, 0xF3, 0xFC, 0x1F,
  0xEE, 0x07, 0xF7, 0x80, 0x7B, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3D,
  0xE0, 0x1F, 0xFE, 0x07, 0x7F, 0x83, 0xFC, 0xE1, 0xEF, 0x3C, 0x73, 0x8F,
  0x38, 0xE3, 0xDE, 0x38, 0xE7, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x9F, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE3, 0xC7,
  0xFC, 0xF9, 0xFF, 0xDF, 0x7E, 0xFB, 0xEF, 0x9F, 0xF9, 0xF1, 0xFF, 0x3E,
  0x3F, 0xC7, 0xC3, 0xF8, 0xFC, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC1, 0xF8, 0xF8, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0xF3, 0xC0,
  0x00, 0x40, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0E, 0x00, 0x80, 0x02, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x00, 0x40, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC2, 0x79, 0xDE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3E, 0xE0, 0x3C,
  0xF0, 0x78, 0xF0, 0x30, 0x70, 0x00, 0x40, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x20, 0x7F, 0xDF, 0xFF, 0xFB, 0xFE, 0x73,
  0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xFB, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3F, 0x3E, 0x1F, 0x9F,
  0x0F, 0xDF, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC,
  0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7,
  0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x60, 0x3C, 0x3F, 0xBF, 0xF7, 0xFF, 0xFF, 0xBF, 0xF6, 0x3E, 0x07,
  0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x87,
  0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0x87, 0xE3,
  0xF1, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xDF, 0x03, 0xDF, 0x83, 0xEF, 0xC3,
  0xE7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x78, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE1, 0xF3, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F,
  0xCF, 0xC7, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0x7F, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xEF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFC, 0xF8, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF,
  0xC7, 0xE7, 0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7E, 0x7E,
  0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x78, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xFC, 0xFC, 0xFC,
  0xFC, 0x78, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x1F, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFC, 0x7F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x20, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x20, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF,
  0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F, 0xBF,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x0F, 0x07, 0xC1, 0xC7, 0x83, 0xFC, 0x71, 0xE1, 0xFF,
  0x1C, 0xF0, 0xFB, 0xC7, 0x3C, 0x78, 0xF1, 0xCE, 0x1E, 0x3C, 0x77, 0x8F,
  0x0E, 0x1D, 0xE3, 0xC7, 0x87, 0x78, 0xF1, 0xE1, 0xDC, 0x78, 0x78, 0xF7,
  0x1E, 0x1C, 0x39, 0xC7, 0x8F, 0x0E, 0xF1, 0xE3, 0xC3, 0xBC, 0x78, 0xF1,
  0xCF, 0x1F, 0x7C, 0xF1, 0xC7, 0xFF, 0xF8, 0x70, 0xFD, 0xFC, 0x1C, 0x1E,
  0x3E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF3, 0xC0,
  0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x07,
  0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xE3,
  0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xF8, 0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF0, 0x3F,
  0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x3F, 0xE7, 0xE3, 0xFE, 0x7C, 0x3F, 0xE7, 0xC3, 0xFE,
  0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x01, 0xF8, 0x3E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xC1, 0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80,
  0xF8, 0x7E, 0x01, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFE, 0x7C, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0x7C, 0x3F, 0x79,
  0xF7, 0xC3, 0xF7, 0x9E, 0xFC, 0x3E, 0x79, 0xEF, 0x83, 0xE7, 0xBC, 0xF8,
  0x3E, 0x7B, 0xCF, 0x87, 0xE7, 0xFD, 0xF8, 0x7E, 0x7F, 0x9F, 0x87, 0xE7,
  0xF9, 0xF8, 0x7E, 0x7F, 0x1F, 0x07, 0xC7, 0xF1, 0xF0, 0x7C, 0x3E, 0x3F,
  0x0F, 0xC3, 0xE3, 0xF0, 0xFC, 0x3C, 0x3F, 0x0F, 0xC3, 0xC3, 0xF0, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x81, 0xF0, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0,
  0xF8, 0x3F, 0xE3, 0xF0, 0x7D, 0xE7, 0xE0, 0xFB, 0xCF, 0xC3, 0xF7, 0x9F,
  0x87, 0xE7, 0x3E, 0x0F, 0xCF, 0x7C, 0x1F, 0x1F, 0xF8, 0x3E, 0x3F, 0xF0,
  0xFC, 0x3F, 0xE1, 0xF8, 0x7F, 0x83, 0xF0, 0xFF, 0x07, 0xE1, 0xFE, 0x0F,
  0x81, 0xFC, 0x1F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x1F, 0x81,
  0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x7F, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7C, 0x07, 0xC7,
  0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x7E,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0x0F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x1F, 0x03, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0xC3,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3E,
  0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C,
  0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0x7C, 0x3F, 0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x7E,
  0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x3E, 0x0F, 0xBF, 0x0F, 0x83, 0xEF,
  0xC3, 0xE1, 0xFB, 0xF1, 0xF8, 0x7C, 0xFC, 0x7E, 0x1F, 0x3F, 0x1F, 0x8F,
  0xCF, 0xCF, 0xE3, 0xE3, 0xF3, 0xF8, 0xF8, 0xFC, 0xFE, 0x7E, 0x3E, 0x7F,
  0x9F, 0x0F, 0x9F, 0xE7, 0xC3, 0xE7, 0xFB, 0xF0, 0xFB, 0xFE, 0xF8, 0x3E,
  0xFF, 0xBE, 0x0F, 0xBD, 0xEF, 0x83, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xF8, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xFF,
  0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F,
  0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0x03, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x7B, 0xC3, 0xDE, 0x3C, 0xF1,
  0xE3, 0x9F, 0x1C, 0xF0, 0xFF, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x3F, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C,
  0xFC, 0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0x7C, 0x1E, 0x7C,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFB, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F,
  0x9F, 0x0F, 0xDF, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0xFC, 0xFE, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3E, 0xFE, 0x1F, 0x3E, 0x00,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xF7, 0xEF, 0x87, 0xDF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x0F, 0xBE, 0x3E, 0x7E, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0x9F, 0x87, 0xF7,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x7F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8,
  0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF7, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFB, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xF3, 0xF7, 0xEF, 0xC7, 0xDF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0x04, 0x7F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x87, 0xE0, 0x3E, 0x03, 0xF0, 0x7F, 0xF3, 0xFF, 0x1F,
  0xF9, 0xFF, 0xC1, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE7, 0xC3, 0xFD, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xBF, 0x8F, 0xC3, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7C,
  0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F,
  0xC7, 0xC3, 0xF1, 0xFD, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x3D, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC1, 0xC7, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xBF, 0x3F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0xF8, 0x7E,
  0xF8, 0x7E, 0xF8, 0x7C, 0x03, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0,
  0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x8F, 0xC3, 0xE3, 0xF8, 0x7C, 0xFE, 0x0F, 0x9F, 0x83, 0xF7,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F,
  0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0x1F, 0x3C, 0x3E, 0x0F, 0xFF, 0x3F, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFB, 0xFD, 0xF9, 0xF8, 0xFC, 0x7C, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E,
  0x1F, 0x3E, 0x1F, 0x1F, 0x9F, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7, 0xEF, 0xC7,
  0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0, 0xF9, 0xF0, 0xF8, 0xFC, 0xF8,
  0xFC, 0x7E, 0xFC, 0x7E, 0x3F, 0x7E, 0x3F, 0x1F, 0x3E, 0x1F, 0x0F, 0x9F,
  0x0F, 0x87, 0xC0, 0x1F, 0x3C, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xBF, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC,
  0x7E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8,
  0x7C, 0xFC, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xBE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xC7, 0xE3,
  0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0, 0xF8,
  0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF8, 0xFE, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0x87, 0xDF, 0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x07, 0x8F, 0x8F, 0xEF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xF7,
  0xF3, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xFB, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xDF, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x78, 0xFF, 0xC7, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F, 0xE8,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3E, 0x3E, 0x3F, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC7, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFE, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8,
  0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xE3, 0xF3, 0xF1,
  0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F,
  0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xFB, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xDF, 0x00, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xF7, 0xC7, 0xEF, 0x8F, 0xDF, 0x1F, 0x3E, 0x7E, 0x3C, 0xF8, 0x7D, 0xF0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x78, 0xFB,
  0xE3, 0xE3, 0xEF, 0x8F, 0x8F, 0xBE, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE7,
  0xE7, 0xCF, 0xBF, 0xBE, 0x3E, 0xFE, 0xF8, 0xFB, 0xFB, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F,
  0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3E, 0x0F, 0x80, 0x1F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E,
  0x7C, 0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F, 0x87, 0xC7, 0xE3, 0xF0,
  0xF8, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x04, 0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x06, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0x80,
  0x60, 0x00, 0x0F, 0x00, 0x1F, 0xC1, 0xCF, 0xF1, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFB, 0xC3, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 10, 11, 2, -28 },
  { 48, 19, 26, 19, 0, -26 },
  { 110, 17, 34, 18, 1, -30 },
  { 183, 18, 26, 23, 3, -26 },
  { 242, 19, 26, 21, 0, -26 },
  { 304, 6, 10, 6, 2, -28 },
  { 312, 11, 37, 12, 2, -29 },
  { 363, 12, 37, 12, -2, -29 },
  { 419, 16, 16, 17, 2, -26 },
  { 451, 15, 19, 17, 1, -22 },
  { 487, 8, 11, 9, -2, -5 },
  { 498, 10, 4, 14, 2, -13 },
  { 503, 6, 6, 11, 1, -6 },
  { 508, 17, 28, 12, -3, -26 },
  { 568, 17, 26, 18, 1, -26 },
  { 624, 11, 26, 18, 4, -26 },
  { 660, 18, 26, 18, 0, -26 },
  { 719, 18, 26, 18, 0, -26 },
  { 778, 17, 26, 18, 1, -26 },
  { 834, 17, 26, 18, 1, -26 },
  { 890, 16, 26, 18, 1, -26 },
  { 942, 18, 26, 18, 1, -26 },
  { 1001, 17, 26, 18, 1, -26 },
  { 1057, 16, 26, 18, 2, -26 },
  { 1109, 8, 21, 10, 1, -21 },
  { 1130, 11, 27, 10, -2, -21 },
  { 1168, 15, 18, 16, 1, -20 },
  { 1202, 16, 12, 18, 1, -17 },
  { 1226, 15, 18, 16, 1, -20 },
  { 1260, 15, 26, 16, 2, -26 },
  { 1309, 26, 34, 28, 0, -26 },
  { 1420, 21, 26, 22, -2, -26 },
  { 1489, 20, 26, 20, 0, -26 },
  { 1554, 20, 26, 21, 1, -26 },
  { 1619, 20, 26, 20, 0, -26 },
  { 1684, 19, 26, 18, 0, -26 },
  { 1746, 19, 26, 17, 0, -26 },
  { 1808, 20, 26, 21, 1, -26 },
  { 1873, 23, 26, 22, 0, -26 },
  { 1948, 10, 26, 10, 0, -26 },
  { 1981, 18, 26, 18, 0, -26 },
  { 2040, 23, 26, 20, 0, -26 },
  { 2115, 15, 26, 17, 0, -26 },
  { 2164, 28, 26, 27, 0, -26 },
  { 2255, 23, 26, 22, 0, -26 },
  { 2330, 20, 26, 22, 1, -26 },
  { 2395, 20, 26, 21, 0, -26 },
  { 2460, 20, 31, 22, 1, -26 },
  { 2538, 20, 26, 20, 0, -26 },
  { 2603, 19, 26, 20, 1, -26 },
  { 2665, 19, 26, 20, 3, -26 },
  { 2727, 21, 26, 21, 1, -26 },
  { 2796, 20, 26, 21, 3, -26 },
  { 2861, 26, 26, 27, 3, -26 },
  { 2946, 23, 26, 20, -1, -26 },
  { 3021, 19, 26, 20, 3, -26 },
  { 3083, 22, 26, 19, -1, -26 },
  { 3155, 13, 37, 10, -1, -31 },
  { 3216, 9, 28, 14, 3, -26 },
  { 3248, 13, 37, 10, -2, -31 },
  { 3309, 13, 13, 14, 1, -26 },
  { 3331, 14, 4, 14, -2, 0 },
  { 3338, 8, 6, 12, 4, -28 },
  { 3344, 16, 20, 17, 0, -20 },
  { 3384, 17, 28, 18, 0, -28 },
  { 3444, 15, 20, 17, 1, -20 },
  { 3482, 18, 28, 18, 1, -28 },
  { 3545, 15, 20, 17, 1, -20 },
  { 3583, 13, 28, 12, 1, -28 },
  { 3629, 18, 28, 18, 0, -20 },
  { 3692, 16, 28, 18, 0, -28 },
  { 3748, 10, 28, 9, 0, -28 },
  { 3783, 14, 36, 9, -4, -28 },
  { 3846, 19, 28, 17, 0, -28 },
  { 3913, 10, 28, 9, 0, -28 },
  { 3948, 25, 20, 27, 0, -20 },
  { 4011, 16, 20, 18, 0, -20 },
  { 4051, 16, 20, 18, 1, -20 },
  { 4091, 18, 28, 18, -1, -20 },
  { 4154, 17, 28, 18, 1, -20 },
  { 4214, 13, 20, 12, 0, -20 },
  { 4247, 16, 20, 16, 0, -20 },
  { 4287, 11, 24, 11, 1, -24 },
  { 4320, 17, 20, 18, 1, -20 },
  { 4363, 15, 20, 16, 2, -20 },
  { 4401, 22, 20, 23, 2, -20 },
  { 4456, 18, 20, 16, -1, -20 },
  { 4501, 19, 28, 16, -1, -20 },
  { 4568, 17, 20, 16, -1, -20 },
  { 4611, 11, 36, 11, 1, -29 },
  { 4661, 8, 31, 9, 1, -26 },
  { 4692, 11, 36, 11, -1, -29 },
  { 4742, 17, 8, 20, 1, -15 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC37PT7B_H_
