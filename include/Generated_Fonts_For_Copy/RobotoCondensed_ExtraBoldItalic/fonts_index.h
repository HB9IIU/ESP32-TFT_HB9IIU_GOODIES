#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_ExtraBoldItalic6pt7b, 6, "RobotoCondensed_ExtraBoldItalic6pt7b" },
  { &RobotoCondensed_ExtraBoldItalic7pt7b, 7, "RobotoCondensed_ExtraBoldItalic7pt7b" },
  { &RobotoCondensed_ExtraBoldItalic8pt7b, 8, "RobotoCondensed_ExtraBoldItalic8pt7b" },
  { &RobotoCondensed_ExtraBoldItalic9pt7b, 9, "RobotoCondensed_ExtraBoldItalic9pt7b" },
  { &RobotoCondensed_ExtraBoldItalic10pt7b, 10, "RobotoCondensed_ExtraBoldItalic10pt7b" },
  { &RobotoCondensed_ExtraBoldItalic11pt7b, 11, "RobotoCondensed_ExtraBoldItalic11pt7b" },
  { &RobotoCondensed_ExtraBoldItalic12pt7b, 12, "RobotoCondensed_ExtraBoldItalic12pt7b" },
  { &RobotoCondensed_ExtraBoldItalic13pt7b, 13, "RobotoCondensed_ExtraBoldItalic13pt7b" },
  { &RobotoCondensed_ExtraBoldItalic14pt7b, 14, "RobotoCondensed_ExtraBoldItalic14pt7b" },
  { &RobotoCondensed_ExtraBoldItalic15pt7b, 15, "RobotoCondensed_ExtraBoldItalic15pt7b" },
  { &RobotoCondensed_ExtraBoldItalic16pt7b, 16, "RobotoCondensed_ExtraBoldItalic16pt7b" },
  { &RobotoCondensed_ExtraBoldItalic17pt7b, 17, "RobotoCondensed_ExtraBoldItalic17pt7b" },
  { &RobotoCondensed_ExtraBoldItalic18pt7b, 18, "RobotoCondensed_ExtraBoldItalic18pt7b" },
  { &RobotoCondensed_ExtraBoldItalic19pt7b, 19, "RobotoCondensed_ExtraBoldItalic19pt7b" },
  { &RobotoCondensed_ExtraBoldItalic20pt7b, 20, "RobotoCondensed_ExtraBoldItalic20pt7b" },
  { &RobotoCondensed_ExtraBoldItalic21pt7b, 21, "RobotoCondensed_ExtraBoldItalic21pt7b" },
  { &RobotoCondensed_ExtraBoldItalic22pt7b, 22, "RobotoCondensed_ExtraBoldItalic22pt7b" },
  { &RobotoCondensed_ExtraBoldItalic23pt7b, 23, "RobotoCondensed_ExtraBoldItalic23pt7b" },
  { &RobotoCondensed_ExtraBoldItalic24pt7b, 24, "RobotoCondensed_ExtraBoldItalic24pt7b" },
  { &RobotoCondensed_ExtraBoldItalic25pt7b, 25, "RobotoCondensed_ExtraBoldItalic25pt7b" },
  { &RobotoCondensed_ExtraBoldItalic26pt7b, 26, "RobotoCondensed_ExtraBoldItalic26pt7b" },
  { &RobotoCondensed_ExtraBoldItalic27pt7b, 27, "RobotoCondensed_ExtraBoldItalic27pt7b" },
  { &RobotoCondensed_ExtraBoldItalic28pt7b, 28, "RobotoCondensed_ExtraBoldItalic28pt7b" },
  { &RobotoCondensed_ExtraBoldItalic29pt7b, 29, "RobotoCondensed_ExtraBoldItalic29pt7b" },
  { &RobotoCondensed_ExtraBoldItalic30pt7b, 30, "RobotoCondensed_ExtraBoldItalic30pt7b" },
  { &RobotoCondensed_ExtraBoldItalic31pt7b, 31, "RobotoCondensed_ExtraBoldItalic31pt7b" },
  { &RobotoCondensed_ExtraBoldItalic32pt7b, 32, "RobotoCondensed_ExtraBoldItalic32pt7b" },
  { &RobotoCondensed_ExtraBoldItalic33pt7b, 33, "RobotoCondensed_ExtraBoldItalic33pt7b" },
  { &RobotoCondensed_ExtraBoldItalic34pt7b, 34, "RobotoCondensed_ExtraBoldItalic34pt7b" },
  { &RobotoCondensed_ExtraBoldItalic35pt7b, 35, "RobotoCondensed_ExtraBoldItalic35pt7b" },
  { &RobotoCondensed_ExtraBoldItalic36pt7b, 36, "RobotoCondensed_ExtraBoldItalic36pt7b" },
  { &RobotoCondensed_ExtraBoldItalic37pt7b, 37, "RobotoCondensed_ExtraBoldItalic37pt7b" },
  { &RobotoCondensed_ExtraBoldItalic38pt7b, 38, "RobotoCondensed_ExtraBoldItalic38pt7b" },
  { &RobotoCondensed_ExtraBoldItalic39pt7b, 39, "RobotoCondensed_ExtraBoldItalic39pt7b" },
  { &RobotoCondensed_ExtraBoldItalic40pt7b, 40, "RobotoCondensed_ExtraBoldItalic40pt7b" },
  { &RobotoCondensed_ExtraBoldItalic41pt7b, 41, "RobotoCondensed_ExtraBoldItalic41pt7b" },
  { &RobotoCondensed_ExtraBoldItalic42pt7b, 42, "RobotoCondensed_ExtraBoldItalic42pt7b" },
  { &RobotoCondensed_ExtraBoldItalic43pt7b, 43, "RobotoCondensed_ExtraBoldItalic43pt7b" },
  { &RobotoCondensed_ExtraBoldItalic44pt7b, 44, "RobotoCondensed_ExtraBoldItalic44pt7b" },
  { &RobotoCondensed_ExtraBoldItalic45pt7b, 45, "RobotoCondensed_ExtraBoldItalic45pt7b" },
  { &RobotoCondensed_ExtraBoldItalic46pt7b, 46, "RobotoCondensed_ExtraBoldItalic46pt7b" },
  { &RobotoCondensed_ExtraBoldItalic47pt7b, 47, "RobotoCondensed_ExtraBoldItalic47pt7b" },
  { &RobotoCondensed_ExtraBoldItalic48pt7b, 48, "RobotoCondensed_ExtraBoldItalic48pt7b" },
  { &RobotoCondensed_ExtraBoldItalic49pt7b, 49, "RobotoCondensed_ExtraBoldItalic49pt7b" },
  { &RobotoCondensed_ExtraBoldItalic50pt7b, 50, "RobotoCondensed_ExtraBoldItalic50pt7b" },
  { &RobotoCondensed_ExtraBoldItalic51pt7b, 51, "RobotoCondensed_ExtraBoldItalic51pt7b" },
  { &RobotoCondensed_ExtraBoldItalic52pt7b, 52, "RobotoCondensed_ExtraBoldItalic52pt7b" },
  { &RobotoCondensed_ExtraBoldItalic53pt7b, 53, "RobotoCondensed_ExtraBoldItalic53pt7b" },
  { &RobotoCondensed_ExtraBoldItalic54pt7b, 54, "RobotoCondensed_ExtraBoldItalic54pt7b" },
  { &RobotoCondensed_ExtraBoldItalic55pt7b, 55, "RobotoCondensed_ExtraBoldItalic55pt7b" },
  { &RobotoCondensed_ExtraBoldItalic56pt7b, 56, "RobotoCondensed_ExtraBoldItalic56pt7b" },
  { &RobotoCondensed_ExtraBoldItalic57pt7b, 57, "RobotoCondensed_ExtraBoldItalic57pt7b" },
  { &RobotoCondensed_ExtraBoldItalic58pt7b, 58, "RobotoCondensed_ExtraBoldItalic58pt7b" },
  { &RobotoCondensed_ExtraBoldItalic59pt7b, 59, "RobotoCondensed_ExtraBoldItalic59pt7b" },
  { &RobotoCondensed_ExtraBoldItalic60pt7b, 60, "RobotoCondensed_ExtraBoldItalic60pt7b" },
  { &RobotoCondensed_ExtraBoldItalic61pt7b, 61, "RobotoCondensed_ExtraBoldItalic61pt7b" },
  { &RobotoCondensed_ExtraBoldItalic62pt7b, 62, "RobotoCondensed_ExtraBoldItalic62pt7b" },
  { &RobotoCondensed_ExtraBoldItalic63pt7b, 63, "RobotoCondensed_ExtraBoldItalic63pt7b" },
  { &RobotoCondensed_ExtraBoldItalic64pt7b, 64, "RobotoCondensed_ExtraBoldItalic64pt7b" },
  { &RobotoCondensed_ExtraBoldItalic65pt7b, 65, "RobotoCondensed_ExtraBoldItalic65pt7b" },
  { &RobotoCondensed_ExtraBoldItalic66pt7b, 66, "RobotoCondensed_ExtraBoldItalic66pt7b" },
  { &RobotoCondensed_ExtraBoldItalic67pt7b, 67, "RobotoCondensed_ExtraBoldItalic67pt7b" },
  { &RobotoCondensed_ExtraBoldItalic68pt7b, 68, "RobotoCondensed_ExtraBoldItalic68pt7b" },
  { &RobotoCondensed_ExtraBoldItalic69pt7b, 69, "RobotoCondensed_ExtraBoldItalic69pt7b" },
  { &RobotoCondensed_ExtraBoldItalic70pt7b, 70, "RobotoCondensed_ExtraBoldItalic70pt7b" },
  { &RobotoCondensed_ExtraBoldItalic71pt7b, 71, "RobotoCondensed_ExtraBoldItalic71pt7b" },
  { &RobotoCondensed_ExtraBoldItalic72pt7b, 72, "RobotoCondensed_ExtraBoldItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
