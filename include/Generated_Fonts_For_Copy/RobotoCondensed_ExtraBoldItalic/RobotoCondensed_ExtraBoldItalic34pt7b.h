#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC34PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xE0, 0x79, 0xDC, 0xF7, 0x3D, 0xCE,
  0xF3, 0xB8, 0xEE, 0x3B, 0x9C, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x78, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x73,
  0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEF, 0x00, 0xE7, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0xF3, 0x8E, 0xE3, 0x8E, 0xE3, 0x9C, 0xE3, 0xBC,
  0xE7, 0xB8, 0xFF, 0x70, 0x7F, 0xE0, 0x3D, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0xBC, 0x07, 0xFE, 0x0E, 0xFF, 0x1D, 0xE7, 0x3D, 0xC7, 0x39, 0xC7,
  0x71, 0xC7, 0xF1, 0xCF, 0x21, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0x9E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x1F, 0xE7, 0xCF, 0xF9, 0xE3, 0xFF, 0x79, 0xF7, 0xDE, 0x7C, 0xFF,
  0xBF, 0x3F, 0xCF, 0xC7, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3E, 0x3E, 0x7B, 0xDE, 0xE7, 0x7B, 0xDC, 0xE0, 0x00, 0x80,
  0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x01, 0xE0, 0x38, 0x06, 0x00, 0x80, 0x04, 0x01, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x38,
  0x08, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x63, 0x8F, 0xEE,
  0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0x80, 0x7E, 0x03, 0xDC, 0x1E, 0x70, 0xF8,
  0xE1, 0xC3, 0x82, 0x08, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x20, 0x7F,
  0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F,
  0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xBE,
  0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF9, 0xE3, 0xE3, 0xE7, 0xC7, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF,
  0xBF, 0xEE, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0xF8, 0x3E,
  0xFC, 0x7E, 0x7C, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBE, 0x07, 0xBE, 0x0F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3D, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x18, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7,
  0xCF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF9, 0xE1, 0xF3,
  0xE7, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF,
  0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x3C, 0xF8, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFF, 0x1F, 0x3E, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xE7,
  0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0xFE, 0x7E, 0x7D, 0xF1, 0xF7, 0xC7, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x87,
  0xBE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xE0, 0x1E, 0x00, 0x1E, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0x70, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x87, 0xC3, 0xC0, 0xC0,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF1, 0xFF, 0xBF, 0xF3, 0xFE, 0x1F,
  0x80, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03,
  0x80, 0x04, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x10,
  0x00, 0x70, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x01, 0xFC, 0x1F, 0xF1, 0xFF, 0x9F, 0xF0, 0x7F, 0x01, 0xF0, 0x07,
  0x00, 0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7, 0xCF, 0xFC,
  0x7F, 0xE3, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x07, 0x0E, 0x0F, 0x87, 0x1E, 0x3F, 0xC7, 0x1C, 0x7F, 0xE7,
  0x3C, 0x79, 0xC7, 0x38, 0xF1, 0xC7, 0x38, 0xE1, 0xC7, 0x79, 0xE3, 0xC7,
  0x71, 0xE3, 0x87, 0x71, 0xC3, 0x87, 0x73, 0xC7, 0x8E, 0x73, 0xC7, 0x8E,
  0xF3, 0xC7, 0x0C, 0xF1, 0xCF, 0x1C, 0xF1, 0xFF, 0xF8, 0x71, 0xFB, 0xF8,
  0x70, 0xF1, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0,
  0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03,
  0xF7, 0xC0, 0x3F, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC3, 0xE3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE1,
  0xF1, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xE7, 0xC1, 0xF1, 0xF1, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x8F, 0xC1, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x3E,
  0x07, 0xC7, 0xC1, 0xF1, 0xF9, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0x9F, 0x87, 0xC3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF3, 0xF0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE0,
  0xF9, 0xF8, 0x3E, 0x7C, 0x1F, 0x9F, 0x07, 0xC7, 0xC3, 0xF1, 0xF1, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0xFE, 0x7C, 0x7F, 0x9F,
  0x1F, 0xEF, 0xC7, 0xFB, 0xF0, 0x3E, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xC1,
  0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x3F, 0x1F, 0x9F, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x00,
  0x0F, 0x83, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x1F, 0x81, 0xF9,
  0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xF0, 0x1F,
  0x1F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1E,
  0xE1, 0xFF, 0x07, 0xB8, 0x7F, 0xC3, 0xEF, 0x1F, 0xF0, 0xFB, 0xCF, 0x7C,
  0x3E, 0xF3, 0xDF, 0x0F, 0xBD, 0xEF, 0x83, 0xEF, 0x7B, 0xE1, 0xFB, 0xDC,
  0xF8, 0x7C, 0xFF, 0x3E, 0x1F, 0x3F, 0xCF, 0x87, 0xC7, 0xE7, 0xE1, 0xF1,
  0xF9, 0xF0, 0x7C, 0x7C, 0x7C, 0x3F, 0x1F, 0x1F, 0x0F, 0x87, 0x87, 0xC3,
  0xE1, 0xE3, 0xF0, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x83, 0xE1, 0xFC, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x7E,
  0x1F, 0xE3, 0xE0, 0xFF, 0x9F, 0x0F, 0xFC, 0xF8, 0x7C, 0xE7, 0xC3, 0xE7,
  0x3E, 0x1F, 0x3F, 0xF0, 0xF9, 0xFF, 0x0F, 0xC7, 0xF8, 0x7C, 0x3F, 0xC3,
  0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xE0, 0x7E, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x07, 0xE7, 0xC1,
  0xF1, 0xF9, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C,
  0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8,
  0xFC, 0x1F, 0x1F, 0x0F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF,
  0x07, 0xE7, 0xC1, 0xF1, 0xF9, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xF3, 0xF1,
  0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF9, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F,
  0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0x7C, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x8F,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8,
  0x7E, 0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E,
  0x0F, 0xCF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xCF,
  0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE3, 0xF1, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xC7, 0xDF, 0x3F, 0x9F, 0x3E,
  0x7F, 0x3E, 0x7C, 0xFE, 0x7C, 0xFB, 0xFC, 0xF9, 0xF7, 0xFB, 0xE3, 0xEF,
  0xF7, 0xC7, 0xFF, 0xEF, 0x8F, 0xFB, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xEF,
  0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F,
  0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7D, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xCF, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC1, 0xFE, 0x1C, 0xE3, 0xCE, 0x3C, 0xE7, 0x8E, 0x78, 0xEF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7, 0xCF, 0x80, 0x1F,
  0x03, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF1, 0xF7, 0xE7, 0xCF, 0x8F, 0x9F,
  0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x3D, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0xF3, 0xE7, 0xC3, 0xCF,
  0x87, 0x9F, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x8F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xE7, 0xC0, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0x79, 0xE1, 0xFF, 0x87, 0xFE, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x3C, 0xF0, 0xF3, 0xE7, 0xCF, 0xFF,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x3E,
  0x1F, 0xBE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x3C, 0xF0, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7C, 0x7D, 0xF1, 0xFF, 0x87, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xF1, 0x8F, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0xE7, 0xFC, 0xFF, 0xCF, 0xFC,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xCF, 0x07,
  0xF7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xF1, 0xF0, 0xF9, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7,
  0xC3, 0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00,
  0x3E, 0x00, 0x1F, 0x06, 0x1F, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x78, 0x7F, 0xF8, 0xFF, 0xF9,
  0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8,
  0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0xF9, 0xF1, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00,
  0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x8F, 0x9F, 0x8F, 0x9F,
  0x87, 0xCF, 0x83, 0xEF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0x7C, 0x00, 0x1F, 0x78, 0x78, 0x3F, 0xFB, 0xF8, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xF3, 0xF3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F,
  0x1F, 0x1F, 0x7C, 0x3E, 0x3E, 0xF8, 0xF8, 0x7D, 0xF1, 0xF1, 0xF3, 0xE3,
  0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0xBE, 0x1F, 0x1F, 0x7C, 0x7C,
  0x3E, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xF0, 0x1E, 0x78, 0x3F, 0xF8, 0xFF,
  0xF9, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x3E, 0xF8, 0xF9, 0xF1, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF,
  0x7C, 0x7D, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x7E,
  0x00, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D,
  0xF0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xE7,
  0x87, 0xCF, 0x8F, 0x9F, 0x3F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x7B,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x1E, 0x71, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x3E, 0x7C, 0xF1, 0xF3, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7E, 0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x7E,
  0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x7F, 0xDF, 0xFF, 0xFB, 0xFE, 0x3E,
  0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3F, 0x07,
  0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0x3E, 0x3E, 0x7C, 0x7D, 0xF0, 0xFB, 0xE1,
  0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF0, 0x79, 0xE0, 0xF8, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0xBE, 0x3E, 0xF8, 0x7B, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xF8,
  0xE1, 0xEF, 0x9E, 0x3E, 0xF9, 0xF3, 0xEF, 0x1F, 0x3C, 0xF3, 0xF7, 0xCF,
  0x3F, 0x7C, 0xF7, 0xF7, 0x8F, 0x7F, 0x78, 0xF7, 0xFF, 0x8F, 0xF7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x8F, 0x8F,
  0x83, 0xCF, 0x81, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFB, 0xE0, 0xF8, 0xF0, 0x7C, 0x7C, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x80, 0xF0, 0x7C, 0x1E, 0x0F, 0x03,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x0F, 0xC3,
  0xE0, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x08, 0x00, 0x0E,
  0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00,
  0x04, 0x01, 0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC3, 0xF0, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x0F, 0x7F, 0x8F,
  0x7F, 0xDF, 0x7B, 0xFE, 0xF1, 0xFE, 0xF0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 10, 9, 11, 2, -26 },
  { 43, 17, 24, 17, 0, -24 },
  { 94, 16, 30, 17, 1, -27 },
  { 154, 16, 24, 21, 3, -24 },
  { 202, 18, 24, 19, 0, -24 },
  { 256, 5, 9, 5, 2, -26 },
  { 262, 10, 35, 11, 2, -27 },
  { 306, 10, 35, 11, -1, -27 },
  { 350, 14, 15, 15, 2, -24 },
  { 377, 14, 18, 15, 1, -20 },
  { 409, 8, 10, 8, -2, -4 },
  { 419, 9, 4, 13, 2, -12 },
  { 424, 5, 5, 10, 1, -5 },
  { 428, 15, 26, 11, -2, -24 },
  { 477, 15, 24, 17, 1, -24 },
  { 522, 10, 24, 17, 4, -24 },
  { 552, 16, 24, 17, 0, -24 },
  { 600, 16, 24, 17, 0, -24 },
  { 648, 16, 24, 17, 0, -24 },
  { 696, 16, 24, 17, 1, -24 },
  { 744, 15, 24, 17, 1, -24 },
  { 789, 17, 24, 17, 1, -24 },
  { 840, 15, 24, 17, 1, -24 },
  { 885, 14, 24, 17, 2, -24 },
  { 927, 8, 18, 9, 1, -18 },
  { 945, 9, 24, 9, -1, -18 },
  { 972, 13, 16, 15, 1, -18 },
  { 998, 15, 11, 17, 1, -16 },
  { 1019, 14, 16, 15, 0, -18 },
  { 1047, 13, 24, 15, 2, -24 },
  { 1086, 24, 31, 25, 0, -23 },
  { 1179, 20, 24, 20, -2, -24 },
  { 1239, 18, 24, 19, 0, -24 },
  { 1293, 18, 24, 19, 1, -24 },
  { 1347, 18, 24, 19, 0, -24 },
  { 1401, 18, 24, 16, 0, -24 },
  { 1455, 17, 24, 16, 0, -24 },
  { 1506, 18, 24, 19, 1, -24 },
  { 1560, 21, 24, 20, 0, -24 },
  { 1623, 10, 24, 9, 0, -24 },
  { 1653, 17, 24, 16, 0, -24 },
  { 1704, 21, 24, 18, 0, -24 },
  { 1767, 14, 24, 16, 0, -24 },
  { 1809, 26, 24, 25, 0, -24 },
  { 1887, 21, 24, 20, 0, -24 },
  { 1950, 18, 24, 20, 1, -24 },
  { 2004, 19, 24, 19, 0, -24 },
  { 2061, 18, 28, 20, 1, -24 },
  { 2124, 18, 24, 18, 0, -24 },
  { 2178, 17, 24, 18, 1, -24 },
  { 2229, 18, 24, 18, 2, -24 },
  { 2283, 19, 24, 19, 1, -24 },
  { 2340, 18, 24, 19, 3, -24 },
  { 2394, 23, 24, 25, 3, -24 },
  { 2463, 21, 24, 19, -1, -24 },
  { 2526, 17, 24, 18, 3, -24 },
  { 2577, 20, 24, 18, -1, -24 },
  { 2637, 12, 34, 9, -1, -28 },
  { 2688, 8, 26, 13, 3, -24 },
  { 2714, 12, 34, 9, -2, -28 },
  { 2765, 12, 12, 13, 1, -24 },
  { 2783, 13, 4, 13, -2, 0 },
  { 2790, 8, 5, 11, 3, -25 },
  { 2795, 15, 18, 15, 0, -18 },
  { 2829, 15, 26, 16, 0, -26 },
  { 2878, 14, 18, 15, 1, -18 },
  { 2910, 16, 26, 16, 1, -26 },
  { 2962, 14, 18, 16, 1, -18 },
  { 2994, 12, 26, 11, 1, -26 },
  { 3033, 17, 25, 17, 0, -18 },
  { 3087, 15, 26, 16, 0, -26 },
  { 3136, 9, 25, 8, 0, -25 },
  { 3165, 13, 32, 8, -4, -25 },
  { 3217, 17, 26, 16, 0, -26 },
  { 3273, 9, 26, 8, 0, -26 },
  { 3303, 23, 18, 24, 0, -18 },
  { 3355, 15, 18, 16, 0, -18 },
  { 3389, 14, 18, 16, 1, -18 },
  { 3421, 16, 25, 16, -1, -18 },
  { 3471, 15, 25, 16, 1, -18 },
  { 3518, 12, 18, 11, 0, -18 },
  { 3545, 14, 18, 15, 0, -18 },
  { 3577, 10, 22, 10, 1, -22 },
  { 3605, 15, 18, 16, 1, -18 },
  { 3639, 14, 18, 15, 2, -18 },
  { 3671, 20, 18, 21, 2, -18 },
  { 3716, 17, 18, 15, -1, -18 },
  { 3755, 17, 25, 15, -1, -18 },
  { 3809, 16, 18, 15, -1, -18 },
  { 3845, 10, 33, 10, 1, -27 },
  { 3887, 7, 28, 8, 1, -24 },
  { 3912, 10, 33, 10, -1, -27 },
  { 3954, 16, 8, 18, 1, -14 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC34PT7B_H_
