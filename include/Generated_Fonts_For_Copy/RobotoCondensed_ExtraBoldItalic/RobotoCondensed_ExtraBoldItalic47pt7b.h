#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC47PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x78, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF1, 0xF3, 0xE3, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x3C, 0xF8, 0x00, 0xF9, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0x7E,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8,
  0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xF0,
  0x31, 0xE3, 0xE1, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x7C, 0xF8, 0xF9, 0xE3,
  0xE3, 0xCF, 0x8F, 0x8F, 0x7C, 0x3E, 0x7D, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xF9, 0xF0,
  0x7B, 0xE3, 0xC3, 0xCF, 0x0F, 0x1F, 0x3C, 0x3C, 0x78, 0xF0, 0xF3, 0xC3,
  0xC7, 0xDF, 0x0F, 0x1F, 0x78, 0x3E, 0x78, 0x40, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F,
  0x1F, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x3E, 0x3F, 0xF8, 0xFC, 0xFF, 0xF9,
  0xFB, 0xFF, 0xF3, 0xF7, 0xF7, 0xF7, 0xFF, 0xCF, 0xFF, 0xBF, 0x8F, 0xFF,
  0x7F, 0x1F, 0xFE, 0xFE, 0x1F, 0xF9, 0xFC, 0x3F, 0xE3, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFD, 0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x0E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0x07, 0x81, 0x3C, 0x78, 0xF7, 0xF7, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xBE, 0x01, 0xF1, 0xE0, 0x3E, 0x1F, 0x03, 0xC0,
  0xF0, 0x1C, 0x0E, 0x00, 0x80, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x07, 0xC0,
  0x30, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1,
  0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFE,
  0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x07, 0xF0, 0x7F,
  0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xC7, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0x3F, 0x81, 0xF9, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0x0C, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFB, 0xF8, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0x7F, 0x3F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1,
  0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80,
  0xF8, 0x0F, 0x1F, 0x03, 0xFE, 0x0F, 0x1F, 0x07, 0xFF, 0x8F, 0x3E, 0x0F,
  0xFF, 0x8F, 0x3E, 0x1F, 0x8F, 0x0F, 0x3C, 0x1F, 0x0F, 0x0F, 0x7C, 0x3E,
  0x1F, 0x0F, 0x7C, 0x3E, 0x1F, 0x0F, 0x78, 0x7C, 0x1E, 0x0F, 0xF8, 0x7C,
  0x1E, 0x0F, 0xF8, 0x7C, 0x3E, 0x0F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8,
  0x3C, 0x1E, 0xF0, 0xF8, 0x7C, 0x1E, 0xF0, 0xF8, 0x7C, 0x1E, 0xF0, 0xF8,
  0x7C, 0x3C, 0xF0, 0xF8, 0xFC, 0x3C, 0xF0, 0xFD, 0xFC, 0x78, 0xF0, 0xFF,
  0xFF, 0xF8, 0xF0, 0x7F, 0xBF, 0xF0, 0xF0, 0x7F, 0x3F, 0xE0, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x00, 0x3F, 0xC1,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8,
  0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F,
  0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x3F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xCF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xFE, 0x7F, 0x87, 0xFF,
  0x3F, 0x83, 0xFF, 0x9F, 0xC1, 0xFF, 0xCF, 0xE1, 0xFF, 0xE7, 0xF0, 0x0F,
  0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x80,
  0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF,
  0x81, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xFC, 0x03,
  0xF8, 0x7F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3,
  0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xDF, 0x07, 0xFF, 0x81, 0xFD,
  0xF0, 0x7D, 0xF8, 0x1F, 0xDF, 0x0F, 0xFF, 0x81, 0xFD, 0xF0, 0xFB, 0xF8,
  0x1F, 0xDF, 0x1F, 0xBF, 0x81, 0xFD, 0xF1, 0xF3, 0xF8, 0x1F, 0x9F, 0x3F,
  0x7F, 0x03, 0xF9, 0xF3, 0xE7, 0xF0, 0x3F, 0x9F, 0x3E, 0x7F, 0x03, 0xF9,
  0xF7, 0xE7, 0xF0, 0x3F, 0x8F, 0x7C, 0x7F, 0x03, 0xF8, 0xFF, 0xCF, 0xE0,
  0x7F, 0x8F, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x8F, 0xE0, 0x7F, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE1, 0xFE, 0x07, 0xF0,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x03,
  0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC1, 0xFF, 0xC1, 0xFE, 0x0F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0x03, 0xFF, 0x83, 0xF8, 0x1F, 0xFE, 0x1F,
  0xC0, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0x3C, 0x7F, 0x03,
  0xF9, 0xF3, 0xF8, 0x1F, 0xCF, 0x9F, 0xC0, 0xFE, 0x7C, 0xFE, 0x07, 0xF1,
  0xEF, 0xF0, 0x7F, 0x8F, 0xFF, 0x03, 0xF8, 0x7F, 0xF8, 0x1F, 0xC3, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0x83, 0xFF, 0x83,
  0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF0,
  0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03,
  0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F,
  0x01, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF8, 0x7F, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F,
  0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x1F, 0xC1,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F,
  0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0,
  0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F, 0xE0, 0xFE, 0xFE, 0x1F, 0xE0,
  0xFE, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x3F, 0xE1, 0xFC, 0xFE, 0x3F, 0xE1,
  0xFC, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x7F, 0xE3, 0xF8, 0xFE, 0x7F, 0xE3,
  0xF8, 0xFE, 0x7F, 0xE7, 0xF0, 0xFE, 0xFF, 0xE7, 0xF0, 0xFE, 0xFF, 0xE7,
  0xF0, 0xFE, 0xFF, 0xEF, 0xE0, 0xFF, 0xFB, 0xEF, 0xE0, 0xFF, 0xFB, 0xEF,
  0xE0, 0xFF, 0xFB, 0xEF, 0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF,
  0xC0, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF,
  0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x07,
  0xCF, 0x03, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0xFC, 0x3E, 0x7C, 0x0F, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFE, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFD, 0xFC, 0x0F, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFB, 0xE0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x03, 0xFB, 0xF8,
  0x1F, 0xDF, 0xC0, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xE7, 0xFC, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xC3, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xC0,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF8, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0xDF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xBF, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x87, 0xE7,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x07, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xF8, 0xFE, 0x07, 0xFD, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xCF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0x03, 0xFC, 0x0F,
  0x9F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x1F, 0xBF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x07,
  0xF0, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFE, 0x0F, 0xE3, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xC7, 0xF8, 0x1F, 0xCF,
  0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xBF,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC7,
  0xC0, 0xF8, 0x0F, 0xDF, 0xE3, 0xFC, 0x0F, 0xFF, 0xF7, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xC3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0x7F, 0x3F, 0x83,
  0xF0, 0x7F, 0x3F, 0x87, 0xF0, 0x7F, 0x3F, 0x87, 0xF0, 0x7E, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x07, 0xF0, 0xFE, 0x7F, 0x07,
  0xE0, 0xFE, 0x7F, 0x0F, 0xE0, 0xFE, 0x7F, 0x0F, 0xE0, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7E, 0x0F, 0xE1, 0xFC, 0xFE, 0x0F,
  0xC1, 0xFC, 0xFE, 0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x7F,
  0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x03,
  0xF3, 0xE0, 0x07, 0xEF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0,
  0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0x3F, 0x9F, 0x80, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x3F, 0xCF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xCF, 0x0F, 0xDF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x1F, 0xCF, 0xE3, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFE, 0x3F,
  0xF1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8,
  0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F,
  0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x87, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFB, 0xF0, 0x1F,
  0x9F, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE,
  0x7E, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F,
  0x87, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x0F, 0xFF, 0x87, 0xE1, 0xFB,
  0xF0, 0xFC, 0x3F, 0x7E, 0x3F, 0x8F, 0xEF, 0xC7, 0xF1, 0xF9, 0xF8, 0xFE,
  0x3F, 0x3F, 0x3F, 0xCF, 0xE7, 0xE7, 0xF9, 0xF8, 0xFD, 0xFF, 0x3F, 0x1F,
  0xBF, 0xEF, 0xE3, 0xF7, 0xFD, 0xF8, 0x7F, 0xFF, 0xBF, 0x0F, 0xFE, 0xFF,
  0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE,
  0x07, 0xF1, 0xFE, 0x03, 0xF1, 0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xFB, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xEF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0xCF, 0xE0,
  0x3F, 0x87, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x3F, 0x83, 0xFC, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x02, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x03, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xDF, 0x0F, 0xFE, 0xF8, 0x3F, 0xE7, 0xC0, 0xFE, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 33, 12, 1, -33 },
  { 51, 15, 13, 15, 2, -35 },
  { 76, 23, 33, 24, 1, -33 },
  { 171, 22, 42, 23, 1, -38 },
  { 287, 22, 33, 29, 4, -33 },
  { 378, 23, 33, 27, 1, -33 },
  { 473, 8, 13, 7, 2, -35 },
  { 486, 15, 47, 15, 2, -37 },
  { 575, 15, 47, 15, -2, -37 },
  { 664, 20, 20, 21, 2, -33 },
  { 714, 20, 24, 21, 1, -28 },
  { 774, 11, 14, 12, -3, -6 },
  { 794, 12, 6, 18, 3, -18 },
  { 803, 8, 8, 14, 1, -8 },
  { 811, 21, 36, 15, -3, -33 },
  { 906, 20, 33, 23, 2, -33 },
  { 989, 15, 33, 23, 5, -33 },
  { 1051, 23, 33, 23, 0, -33 },
  { 1146, 23, 33, 23, 0, -33 },
  { 1241, 21, 33, 23, 1, -33 },
  { 1328, 22, 33, 23, 1, -33 },
  { 1419, 19, 33, 23, 2, -33 },
  { 1498, 22, 33, 23, 2, -33 },
  { 1589, 22, 33, 23, 1, -33 },
  { 1680, 19, 33, 23, 3, -33 },
  { 1759, 11, 27, 13, 1, -27 },
  { 1797, 14, 35, 12, -2, -27 },
  { 1859, 19, 23, 20, 1, -26 },
  { 1914, 20, 16, 23, 2, -23 },
  { 1954, 19, 22, 21, 1, -25 },
  { 2007, 18, 33, 21, 3, -33 },
  { 2082, 32, 42, 35, 1, -32 },
  { 2250, 27, 33, 27, -2, -33 },
  { 2362, 25, 33, 26, 0, -33 },
  { 2466, 24, 33, 26, 2, -33 },
  { 2565, 25, 33, 26, 0, -33 },
  { 2669, 25, 33, 22, 0, -33 },
  { 2773, 24, 33, 22, 0, -33 },
  { 2872, 25, 33, 27, 2, -33 },
  { 2976, 29, 33, 28, 0, -33 },
  { 3096, 13, 33, 13, 0, -33 },
  { 3150, 23, 33, 22, 0, -33 },
  { 3245, 29, 33, 25, 0, -33 },
  { 3365, 19, 33, 22, 0, -33 },
  { 3444, 36, 33, 35, 0, -33 },
  { 3593, 29, 33, 28, 0, -33 },
  { 3713, 25, 33, 28, 2, -33 },
  { 3817, 26, 33, 26, 0, -33 },
  { 3925, 25, 39, 28, 2, -33 },
  { 4047, 25, 33, 26, 0, -33 },
  { 4151, 24, 33, 25, 1, -33 },
  { 4250, 24, 33, 25, 3, -33 },
  { 4349, 26, 33, 26, 1, -33 },
  { 4457, 25, 33, 27, 4, -33 },
  { 4561, 32, 33, 34, 4, -33 },
  { 4693, 30, 33, 26, -2, -33 },
  { 4817, 24, 33, 25, 4, -33 },
  { 4916, 27, 33, 24, -1, -33 },
  { 5028, 16, 47, 12, -1, -39 },
  { 5122, 11, 36, 17, 4, -33 },
  { 5172, 17, 47, 12, -3, -39 },
  { 5272, 17, 17, 18, 1, -33 },
  { 5309, 18, 5, 18, -3, 0 },
  { 5321, 10, 7, 15, 5, -35 },
  { 5330, 20, 25, 21, 0, -25 },
  { 5393, 21, 35, 23, 0, -35 },
  { 5485, 19, 25, 21, 1, -25 },
  { 5545, 23, 35, 23, 1, -35 },
  { 5646, 20, 25, 22, 1, -25 },
  { 5709, 17, 35, 15, 1, -35 },
  { 5784, 23, 35, 23, 0, -25 },
  { 5885, 21, 35, 23, 0, -35 },
  { 5977, 13, 35, 12, 0, -35 },
  { 6034, 18, 45, 11, -5, -35 },
  { 6136, 24, 35, 22, 0, -35 },
  { 6241, 13, 35, 12, 0, -35 },
  { 6298, 32, 25, 34, 0, -25 },
  { 6398, 21, 25, 23, 0, -25 },
  { 6464, 20, 25, 23, 1, -25 },
  { 6527, 23, 35, 23, -2, -25 },
  { 6628, 21, 35, 23, 1, -25 },
  { 6720, 16, 25, 15, 0, -25 },
  { 6770, 20, 25, 21, 0, -25 },
  { 6833, 13, 31, 14, 2, -31 },
  { 6884, 21, 25, 23, 1, -25 },
  { 6950, 20, 25, 21, 2, -25 },
  { 7013, 27, 25, 29, 3, -25 },
  { 7098, 24, 25, 21, -2, -25 },
  { 7173, 23, 35, 21, -1, -25 },
  { 7274, 22, 25, 21, -1, -25 },
  { 7343, 14, 45, 14, 1, -37 },
  { 7422, 10, 39, 12, 1, -33 },
  { 7471, 15, 45, 14, -2, -37 },
  { 7556, 21, 11, 25, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC47PT7B_H_
