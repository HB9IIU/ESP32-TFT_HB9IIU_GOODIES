#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC46PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x78, 0x00, 0x3E, 0x3C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1F, 0x3C, 0x7D,
  0xF1, 0xE7, 0xC7, 0x9F, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0xF0, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0x78,
  0x00, 0xF1, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1E, 0x3C, 0x00, 0x79,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x78,
  0xF0, 0x63, 0xE3, 0xC3, 0xEF, 0x8F, 0x0F, 0x3E, 0x3C, 0x78, 0xF0, 0xF3,
  0xE3, 0xC3, 0xCF, 0x0F, 0x9F, 0x78, 0x1F, 0xFB, 0xE0, 0x7F, 0xEF, 0x00,
  0xFF, 0x78, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x7B, 0xFC, 0x03, 0xDF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7B, 0xE7, 0x83, 0xCF, 0x1F, 0x1F, 0x7C, 0x7C, 0xF9, 0xF1, 0xF3,
  0xC7, 0xC7, 0x9E, 0x1F, 0x1E, 0x78, 0x7C, 0xF8, 0x40, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x7E, 0x3F, 0xF8, 0xFC, 0xFF,
  0xF1, 0xFB, 0xFF, 0xF3, 0xE7, 0xEF, 0xEF, 0xDF, 0xCF, 0xFF, 0xBF, 0x9F,
  0xFE, 0x7F, 0x1F, 0xFC, 0xFE, 0x3F, 0xF9, 0xFC, 0x3F, 0xE3, 0xF8, 0x3F,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFD, 0xFC, 0x07, 0xE1, 0xFC, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F,
  0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x80, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x06,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x02, 0x07, 0x82, 0x38, 0x78, 0xF7,
  0xF7, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFB, 0xC0, 0x1F, 0xBC, 0x03, 0xF3, 0xE0, 0x3E, 0x1F,
  0x03, 0xC1, 0xF0, 0x18, 0x0E, 0x00, 0x80, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x06, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFE, 0x7E, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0x3F, 0x07, 0xF3, 0xF0, 0x7F, 0x3F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF,
  0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xF0,
  0x1F, 0xC3, 0xFF, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0x8F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x81, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0x3F, 0x01,
  0xF9, 0xF8, 0x1F, 0x9F, 0xC0, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0x08, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x9F, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF8, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F,
  0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0xFF, 0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF7, 0xF0,
  0xFE, 0xFF, 0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFE,
  0x3F, 0x83, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xFB, 0xF8, 0x7E, 0xFE,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x1E,
  0x0F, 0x83, 0xFE, 0x1E, 0x1F, 0x07, 0xFF, 0x0E, 0x1F, 0x0F, 0xFF, 0x0F,
  0x3E, 0x1F, 0x9F, 0x0F, 0x3E, 0x3F, 0x1F, 0x0F, 0x3C, 0x3E, 0x1F, 0x0F,
  0x7C, 0x3C, 0x1E, 0x0F, 0x78, 0x7C, 0x3E, 0x0F, 0x78, 0x7C, 0x3E, 0x1E,
  0xF8, 0xFC, 0x3E, 0x1E, 0xF8, 0xF8, 0x3C, 0x1E, 0xF8, 0xF8, 0x3C, 0x1E,
  0xF0, 0xF8, 0x7C, 0x1E, 0xF0, 0xF8, 0x7C, 0x3C, 0xF0, 0xF8, 0x78, 0x3C,
  0xF0, 0xF8, 0xF8, 0x3C, 0xF0, 0xF8, 0xF8, 0x78, 0xF0, 0xF9, 0xF8, 0xF8,
  0xF0, 0xFF, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x7F, 0x3F, 0xC0,
  0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x81, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xF7, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xFE, 0xFE, 0x0F, 0xFE, 0xFE, 0x1F,
  0xFE, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83,
  0xFC, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xF0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x80, 0x7F,
  0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xF7, 0xC3, 0xEF, 0xC0, 0xFE, 0xF8, 0xFD,
  0xF8, 0x1F, 0x9F, 0x1F, 0x7F, 0x03, 0xF3, 0xE7, 0xEF, 0xE0, 0x7E, 0x7C,
  0xF9, 0xFC, 0x1F, 0xCF, 0x9F, 0x3F, 0x03, 0xF9, 0xF7, 0xEF, 0xE0, 0x7F,
  0x3E, 0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0xC7, 0xF0,
  0x7F, 0x1F, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC7,
  0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x0F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF, 0xE1, 0xFC, 0x0F, 0xFE,
  0x1F, 0xC1, 0xFD, 0xF1, 0xFC, 0x1F, 0xDF, 0x1F, 0xC1, 0xFC, 0xF1, 0xFC,
  0x1F, 0xCF, 0x3F, 0x81, 0xFC, 0xFB, 0xF8, 0x1F, 0x8F, 0xBF, 0x83, 0xF8,
  0x7B, 0xF8, 0x3F, 0x87, 0xBF, 0x83, 0xF8, 0x7F, 0xF8, 0x3F, 0x87, 0xFF,
  0x03, 0xF8, 0x3F, 0xF0, 0x7F, 0x03, 0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x7F,
  0x03, 0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x01, 0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF8,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xDF, 0xC0, 0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x1F,
  0xE0, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC, 0xFE, 0x3F,
  0xE1, 0xF8, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x3F, 0xE3, 0xF8, 0xFE, 0x3F,
  0xE3, 0xF0, 0xFE, 0x7F, 0xE7, 0xF0, 0xFE, 0x7F, 0xE7, 0xF0, 0xFE, 0x7F,
  0xE7, 0xF0, 0xFE, 0xFF, 0xE7, 0xE0, 0xFE, 0xFF, 0xEF, 0xE0, 0xFE, 0xFF,
  0xEF, 0xE0, 0xFF, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFD, 0xF7,
  0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xE7,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x7E,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0xBF, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0x9E, 0x0F, 0x9E, 0x1F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFC, 0xFE, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0xFC, 0x7F,
  0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF,
  0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xDF, 0x80, 0xF9, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F, 0xC7,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xE7, 0xF8, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC3,
  0xF3, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0xFC, 0x1F,
  0x9F, 0xC7, 0xF3, 0xFD, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0x9F, 0xC0, 0xFF, 0xBF, 0x83, 0xFF, 0x7E, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xE1, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8,
  0xFC, 0x0F, 0xFB, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x02, 0x03, 0xFC,
  0x1E, 0x3F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xF8, 0x7F, 0x3F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x7F,
  0x3F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7E, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE0,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xC0, 0x01, 0xE0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF,
  0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xDF, 0xE0, 0x3F, 0x7F, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xCF,
  0xC1, 0xF0, 0x1F, 0xBF, 0xCF, 0xF8, 0x3F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF8, 0x3F, 0x1F, 0x87, 0xF0, 0xFE, 0x7F, 0x0F, 0xE1,
  0xFC, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x0F,
  0xE7, 0xE0, 0xFC, 0x1F, 0x9F, 0xC3, 0xF8, 0x7F, 0x3F, 0x87, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE1, 0xFC, 0xFE, 0x1F, 0xC3, 0xF9, 0xF8, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x0F, 0xCF, 0xE1, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8, 0x7F, 0x3F,
  0x87, 0xF0, 0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xCF, 0x80, 0xFD, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x87,
  0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0,
  0x7F, 0x3F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF,
  0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x87,
  0xE7, 0xF0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF3, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x87,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xEF,
  0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x7F, 0xDF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7E, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xF7, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0x0F,
  0xDF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0xFE,
  0x3F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFC, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x83,
  0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x7E, 0x03, 0xF3,
  0xF0, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xE7, 0xE1, 0xFC, 0x7E,
  0x1F, 0xC7, 0xE3, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x7F, 0x07,
  0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0xFC, 0x3E, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0xC7, 0xE1, 0xFB, 0xF1,
  0xF8, 0x7E, 0xFC, 0x7E, 0x3F, 0xBF, 0x3F, 0x8F, 0xCF, 0xCF, 0xE3, 0xF3,
  0xF7, 0xFD, 0xFC, 0xFD, 0xFF, 0x7E, 0x3F, 0x7F, 0xDF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xEF, 0xFF, 0xF0, 0xFB, 0xDF, 0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD,
  0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xF1,
  0xFE, 0x07, 0xF1, 0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xF3, 0xF8, 0x03, 0xF7,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xEF,
  0xC0, 0x0F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0x83,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0xFE,
  0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0,
  0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xE0,
  0x00, 0x80, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x18, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE3, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xE3, 0xFF, 0x9F, 0x0F, 0xFC, 0xF0, 0x3F, 0xC0, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 33, 12, 1, -33 },
  { 51, 14, 13, 14, 2, -35 },
  { 74, 22, 33, 23, 1, -33 },
  { 165, 21, 42, 23, 1, -38 },
  { 276, 22, 33, 29, 4, -33 },
  { 367, 23, 33, 26, 1, -33 },
  { 462, 7, 13, 7, 2, -35 },
  { 474, 14, 46, 14, 2, -36 },
  { 555, 15, 46, 14, -2, -36 },
  { 642, 20, 20, 21, 2, -33 },
  { 692, 19, 24, 21, 1, -27 },
  { 749, 10, 14, 11, -3, -6 },
  { 767, 12, 6, 17, 3, -17 },
  { 776, 8, 7, 13, 1, -7 },
  { 783, 20, 36, 14, -3, -33 },
  { 873, 20, 33, 23, 2, -33 },
  { 956, 14, 33, 23, 5, -33 },
  { 1014, 22, 33, 23, 0, -33 },
  { 1105, 22, 33, 23, 0, -33 },
  { 1196, 21, 33, 23, 1, -33 },
  { 1283, 22, 33, 23, 1, -33 },
  { 1374, 19, 33, 23, 2, -33 },
  { 1453, 22, 33, 23, 2, -33 },
  { 1544, 21, 33, 23, 1, -33 },
  { 1631, 19, 33, 23, 3, -33 },
  { 1710, 11, 25, 13, 1, -25 },
  { 1745, 13, 33, 12, -2, -25 },
  { 1799, 18, 22, 20, 1, -25 },
  { 1849, 19, 16, 23, 2, -22 },
  { 1887, 18, 22, 20, 1, -25 },
  { 1937, 18, 33, 20, 3, -33 },
  { 2012, 32, 42, 34, 1, -32 },
  { 2180, 26, 33, 27, -2, -33 },
  { 2288, 25, 33, 25, 0, -33 },
  { 2392, 24, 33, 26, 2, -33 },
  { 2491, 24, 33, 25, 0, -33 },
  { 2590, 24, 33, 22, 0, -33 },
  { 2689, 24, 33, 21, 0, -33 },
  { 2788, 24, 33, 26, 2, -33 },
  { 2887, 28, 33, 27, 0, -33 },
  { 3003, 13, 33, 12, 0, -33 },
  { 3057, 23, 33, 22, 0, -33 },
  { 3152, 29, 33, 25, 0, -33 },
  { 3272, 19, 33, 21, 0, -33 },
  { 3351, 35, 33, 34, 0, -33 },
  { 3496, 28, 33, 27, 0, -33 },
  { 3612, 24, 33, 27, 2, -33 },
  { 3711, 25, 33, 26, 0, -33 },
  { 3815, 24, 39, 27, 2, -33 },
  { 3932, 25, 33, 25, 0, -33 },
  { 4036, 24, 33, 24, 1, -33 },
  { 4135, 24, 33, 25, 3, -33 },
  { 4234, 26, 33, 26, 1, -33 },
  { 4342, 26, 33, 26, 3, -33 },
  { 4450, 32, 33, 33, 4, -33 },
  { 4582, 30, 33, 25, -2, -33 },
  { 4706, 24, 33, 24, 4, -33 },
  { 4805, 27, 33, 24, -1, -33 },
  { 4917, 16, 46, 12, -1, -38 },
  { 5009, 12, 36, 17, 3, -33 },
  { 5063, 16, 46, 12, -3, -38 },
  { 5155, 16, 16, 18, 1, -33 },
  { 5187, 18, 5, 18, -3, 0 },
  { 5199, 10, 7, 15, 5, -35 },
  { 5208, 20, 24, 21, 0, -24 },
  { 5268, 21, 35, 22, 0, -35 },
  { 5360, 19, 24, 21, 1, -24 },
  { 5417, 23, 35, 22, 1, -35 },
  { 5518, 19, 24, 21, 1, -24 },
  { 5575, 17, 35, 15, 1, -35 },
  { 5650, 22, 33, 23, 0, -24 },
  { 5741, 20, 35, 22, 0, -35 },
  { 5829, 12, 34, 11, 0, -34 },
  { 5880, 17, 43, 11, -5, -34 },
  { 5972, 23, 35, 22, 0, -35 },
  { 6073, 13, 35, 11, 0, -35 },
  { 6130, 31, 24, 33, 0, -24 },
  { 6223, 20, 24, 22, 0, -24 },
  { 6283, 20, 24, 22, 1, -24 },
  { 6343, 23, 33, 22, -2, -24 },
  { 6438, 21, 33, 22, 1, -24 },
  { 6525, 16, 24, 15, 0, -24 },
  { 6573, 20, 24, 20, 0, -24 },
  { 6633, 13, 30, 14, 2, -30 },
  { 6682, 21, 24, 22, 1, -24 },
  { 6745, 20, 24, 20, 2, -24 },
  { 6805, 26, 24, 28, 3, -24 },
  { 6883, 24, 24, 20, -2, -24 },
  { 6955, 23, 33, 20, -1, -24 },
  { 7050, 21, 24, 20, -1, -24 },
  { 7113, 14, 44, 13, 1, -36 },
  { 7190, 10, 39, 11, 1, -33 },
  { 7239, 14, 44, 13, -2, -36 },
  { 7316, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC46PT7B_H_
