#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC62PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0x08, 0x00, 0x1F, 0x87, 0xE7, 0xF1, 0xFC,
  0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xE1, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x3F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x02,
  0x07, 0xF1, 0xF8, 0x0E, 0x1F, 0x87, 0xE0, 0x7C, 0x7E, 0x1F, 0x83, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0xFC,
  0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x07, 0xC3, 0xF3, 0xF0, 0x1F, 0x8F,
  0xDF, 0x80, 0x7F, 0xFF, 0x7E, 0x01, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xDF,
  0x80, 0x07, 0xFE, 0x7C, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x06, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0xFF, 0x00, 0x03, 0xF7, 0xFE, 0x00, 0x1F, 0xBF, 0xFC, 0x00,
  0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0x1F, 0x80, 0xFC,
  0xFC, 0x3E, 0x03, 0xF7, 0xE0, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x7E,
  0x0F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x87,
  0xE7, 0xE0, 0x7E, 0x1F, 0x8F, 0x81, 0xF8, 0xFE, 0x0C, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFF, 0xC7, 0xF9, 0xFF, 0xFF, 0xCF, 0xF7, 0xFC, 0xFF, 0xBF, 0xCF,
  0xF9, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFC, 0xFF,
  0x83, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xC7, 0xFC,
  0x0F, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xC0, 0x7F, 0xF8,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0x80, 0x7C, 0x06, 0x3C, 0x0F, 0x83, 0xCF, 0xF1, 0xF3, 0xF9, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xDF, 0x00, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x3F, 0x00, 0x7F,
  0x87, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x01, 0xF0,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03,
  0xE0, 0x06, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x0F, 0xF1, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xE7, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0x7F, 0xCF, 0x0F, 0xF9, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83,
  0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0,
  0x07, 0xF3, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x3F,
  0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x3F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0x7F,
  0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0x80, 0xFF, 0xDF, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFF, 0x07, 0xFE,
  0x7F, 0xE3, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x9F, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F,
  0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF,
  0x07, 0xFC, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xDF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x81,
  0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE3,
  0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x81, 0xFC, 0x03, 0xFF, 0x01,
  0xF0, 0x3F, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0xFF, 0x83, 0xE1,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7C, 0x3F, 0x03, 0xFF, 0xFE, 0x0F, 0x8F, 0xC0,
  0xFE, 0x1F, 0xC1, 0xF1, 0xF8, 0x3F, 0x83, 0xF0, 0x3E, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xCF, 0xC1, 0xFC, 0x0F, 0xC0, 0xF9, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xC0, 0xFD,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xBF, 0x07, 0xE0, 0x3F, 0x03, 0xEF, 0xE1,
  0xFC, 0x0F, 0xC0, 0x7D, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xBF, 0x07, 0xF0,
  0x3F, 0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0xFC, 0x1F, 0xC1, 0xF8,
  0x0F, 0x9F, 0x83, 0xF0, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x7E, 0x0F, 0xC1, 0xFC, 0x0F, 0x8F, 0xC1, 0xFC, 0x3F, 0x83, 0xE1, 0xF8,
  0x3F, 0x8F, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0x3F, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0x80, 0xFF, 0x9F,
  0xFE, 0x03, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0x7E, 0x00, 0x70, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0x1F,
  0xF0, 0x3F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xC7, 0xFC, 0x0F, 0xFF, 0xE7,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE3, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x7F, 0x7F, 0xC0, 0x7F, 0xDF,
  0xC0, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0x83, 0xF9, 0xFE, 0x01, 0xFF, 0x7F,
  0x07, 0xF7, 0xFC, 0x03, 0xFE, 0xFE, 0x1F, 0xEF, 0xF8, 0x07, 0xFC, 0xFC,
  0x3F, 0x9F, 0xF0, 0x1F, 0xF1, 0xF8, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xF1,
  0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xE3, 0xF9, 0xFF, 0x00, 0xFF, 0x8F, 0xEF,
  0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xDF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xE1,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFD, 0xF8, 0x3F, 0xE0, 0x1F, 0xF7,
  0xE0, 0xFF, 0x80, 0xFF, 0xDF, 0x87, 0xFE, 0x03, 0xFF, 0x7F, 0x1F, 0xF8,
  0x0F, 0xFC, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xF1, 0xFF, 0x00, 0xFF, 0x8F,
  0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0x9F, 0xF0, 0x1F, 0xF8, 0x7E, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFB, 0xFF, 0x01, 0xFF, 0x07, 0xEF, 0xF8, 0x07, 0xFC, 0x1F,
  0xBF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFB, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x1F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xFE, 0x3F,
  0xE0, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0xF9, 0xFF, 0x03,
  0xFE, 0x7F, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xFF, 0xE7, 0xFC, 0x07, 0xF9,
  0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xBF, 0xE0, 0x1F, 0xEF, 0xFF,
  0xF7, 0xFC, 0x03, 0xFD, 0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F,
  0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xE7,
  0xC0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF1, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xF3, 0xFE, 0x7F, 0xE0, 0xFF,
  0x9F, 0xF8, 0x7F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x81,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF9, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFF, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFE, 0x0F,
  0xF1, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0x01,
  0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC,
  0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0x01, 0xFF, 0x00, 0x3F,
  0xC7, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xBF, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F,
  0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x0F,
  0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x03, 0x01, 0xFF, 0x81, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x01,
  0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x43, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0x00, 0xFF, 0xC0, 0x0F, 0x83,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x07, 0xFC, 0x3F,
  0xF8, 0x07, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xC7, 0xFE,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF,
  0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFB, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE,
  0x04, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xCF, 0xF0, 0x7F,
  0xFC, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xE7, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x83, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF7, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE1, 0xFF,
  0x1F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x20, 0x00,
  0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xC0, 0x0F, 0xF9, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8,
  0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7,
  0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE1, 0xFF,
  0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0x83,
  0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0x83, 0xFC, 0xFF, 0x0F,
  0xF8, 0x7F, 0xCF, 0xF0, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x0F, 0xF3, 0xFF, 0x8F,
  0xF0, 0xFF, 0x3F, 0xF9, 0xFF, 0x0F, 0xF3, 0xFF, 0x9F, 0xE0, 0xFF, 0x7F,
  0xF9, 0xFE, 0x0F, 0xF7, 0xFF, 0x9F, 0xE0, 0xFE, 0xFF, 0xFB, 0xFC, 0x0F,
  0xEF, 0xFF, 0xBF, 0xC0, 0xFE, 0xFD, 0xFB, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF,
  0x80, 0xFF, 0xFD, 0xFF, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF9,
  0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xC3, 0xFF, 0x80, 0xFE, 0x3F, 0xFE, 0x07, 0xF3, 0xFF, 0xF8,
  0x3F, 0x1F, 0xFF, 0xC3, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0xE3, 0xF0, 0x3F, 0xFF, 0x3F, 0x81, 0xFF, 0xF1, 0xFC,
  0x07, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 45, 16, 1, -44 },
  { 91, 19, 17, 19, 3, -47 },
  { 132, 31, 44, 31, 1, -44 },
  { 303, 28, 58, 31, 2, -51 },
  { 506, 30, 46, 39, 5, -45 },
  { 679, 31, 46, 35, 1, -45 },
  { 858, 10, 17, 10, 3, -47 },
  { 880, 19, 63, 19, 3, -49 },
  { 1030, 20, 63, 19, -3, -49 },
  { 1188, 27, 27, 28, 3, -44 },
  { 1280, 27, 32, 28, 1, -37 },
  { 1388, 13, 19, 15, -3, -8 },
  { 1419, 16, 7, 24, 4, -22 },
  { 1433, 11, 10, 18, 1, -9 },
  { 1447, 27, 48, 19, -4, -44 },
  { 1609, 27, 46, 31, 2, -45 },
  { 1765, 19, 44, 31, 7, -44 },
  { 1870, 30, 45, 31, 0, -45 },
  { 2039, 29, 46, 31, 1, -45 },
  { 2206, 29, 44, 31, 1, -44 },
  { 2366, 30, 45, 31, 1, -44 },
  { 2535, 26, 45, 31, 2, -44 },
  { 2682, 30, 44, 31, 2, -44 },
  { 2847, 29, 46, 31, 1, -45 },
  { 3014, 25, 45, 31, 4, -45 },
  { 3155, 15, 34, 17, 1, -33 },
  { 3219, 18, 44, 16, -3, -33 },
  { 3318, 25, 30, 27, 1, -34 },
  { 3412, 27, 21, 31, 2, -30 },
  { 3483, 25, 29, 27, 1, -33 },
  { 3574, 24, 46, 27, 4, -45 },
  { 3712, 43, 57, 46, 1, -43 },
  { 4019, 35, 44, 36, -3, -44 },
  { 4212, 33, 44, 34, 0, -44 },
  { 4394, 33, 46, 34, 2, -45 },
  { 4584, 33, 44, 34, 0, -44 },
  { 4766, 33, 44, 29, 0, -44 },
  { 4948, 32, 44, 29, 0, -44 },
  { 5124, 33, 46, 35, 2, -45 },
  { 5314, 38, 44, 37, 0, -44 },
  { 5523, 17, 44, 17, 0, -44 },
  { 5617, 31, 45, 30, 0, -44 },
  { 5792, 39, 44, 33, 0, -44 },
  { 6007, 26, 44, 29, 0, -44 },
  { 6150, 47, 44, 46, 0, -44 },
  { 6409, 38, 44, 37, 0, -44 },
  { 6618, 33, 46, 36, 2, -45 },
  { 6808, 34, 44, 34, 0, -44 },
  { 6995, 33, 53, 36, 2, -45 },
  { 7214, 34, 44, 34, 0, -44 },
  { 7401, 32, 46, 33, 1, -45 },
  { 7585, 31, 44, 33, 5, -44 },
  { 7756, 34, 45, 35, 2, -44 },
  { 7948, 34, 44, 35, 5, -44 },
  { 8135, 43, 44, 45, 5, -44 },
  { 8372, 39, 44, 34, -2, -44 },
  { 8587, 32, 44, 33, 5, -44 },
  { 8763, 36, 44, 32, -1, -44 },
  { 8961, 21, 62, 16, -1, -52 },
  { 9124, 15, 48, 23, 5, -44 },
  { 9214, 21, 62, 16, -3, -52 },
  { 9377, 21, 22, 24, 2, -44 },
  { 9435, 24, 7, 24, -4, 0 },
  { 9456, 14, 9, 20, 6, -46 },
  { 9472, 26, 35, 28, 0, -34 },
  { 9586, 28, 48, 30, 0, -47 },
  { 9754, 26, 35, 28, 1, -34 },
  { 9868, 31, 48, 30, 1, -47 },
  { 10054, 27, 35, 29, 1, -34 },
  { 10173, 23, 48, 20, 1, -48 },
  { 10311, 31, 47, 30, -1, -34 },
  { 10494, 29, 47, 30, -1, -47 },
  { 10665, 17, 47, 15, 0, -47 },
  { 10765, 24, 60, 15, -7, -47 },
  { 10945, 32, 47, 29, 0, -47 },
  { 11133, 17, 47, 15, 0, -47 },
  { 11233, 42, 34, 44, 0, -34 },
  { 11412, 29, 34, 30, -1, -34 },
  { 11536, 27, 35, 30, 1, -34 },
  { 11655, 30, 47, 30, -2, -34 },
  { 11832, 28, 47, 30, 1, -34 },
  { 11997, 22, 34, 20, 0, -34 },
  { 12091, 26, 35, 27, 0, -34 },
  { 12205, 18, 42, 19, 2, -41 },
  { 12300, 29, 34, 30, 1, -33 },
  { 12424, 26, 33, 27, 3, -33 },
  { 12532, 36, 33, 38, 4, -33 },
  { 12681, 31, 33, 27, -2, -33 },
  { 12809, 31, 46, 27, -1, -33 },
  { 12988, 28, 33, 27, -1, -33 },
  { 13104, 19, 59, 18, 1, -48 },
  { 13245, 13, 52, 15, 1, -44 },
  { 13330, 19, 59, 18, -2, -48 },
  { 13471, 29, 14, 33, 2, -25 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC62PT7B_H_
