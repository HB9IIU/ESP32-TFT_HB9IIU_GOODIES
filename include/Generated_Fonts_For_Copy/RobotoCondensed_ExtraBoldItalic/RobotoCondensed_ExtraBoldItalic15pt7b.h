#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC15PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x66, 0x0C, 0xC0, 0xDD, 0xBB, 0x0A, 0x1A, 0x16,
  0x7F, 0x34, 0x3C, 0x28, 0xFE, 0x78, 0x50, 0x50, 0x04, 0x18, 0x71, 0xF3,
  0x6E, 0x0C, 0x1E, 0x0D, 0xDD, 0xB3, 0xE3, 0x84, 0x00, 0x70, 0xA7, 0x5E,
  0xA6, 0x83, 0x0F, 0x95, 0x7A, 0xB4, 0x38, 0x1C, 0x3E, 0x36, 0x3C, 0x3C,
  0x38, 0x7B, 0xFE, 0xCE, 0xFE, 0x7E, 0xFE, 0x13, 0x66, 0x4C, 0xCC, 0x88,
  0x88, 0xCC, 0x40, 0x10, 0x86, 0x31, 0x8C, 0x63, 0x18, 0xCC, 0x66, 0x31,
  0x00, 0x10, 0x4D, 0xDF, 0x73, 0x61, 0x00, 0x18, 0x30, 0x63, 0xFF, 0xC6,
  0x0C, 0x18, 0x2D, 0xBC, 0xFF, 0xEC, 0x04, 0x18, 0x30, 0x41, 0x82, 0x0C,
  0x10, 0x60, 0xC1, 0x06, 0x00, 0x39, 0xFE, 0xF3, 0xCF, 0x3C, 0xF7, 0xDB,
  0xE7, 0x00, 0x1F, 0xF3, 0x76, 0x66, 0x66, 0xE0, 0x1C, 0x7D, 0x9B, 0x30,
  0xE1, 0x86, 0x18, 0x71, 0xFB, 0xF0, 0x1C, 0x7D, 0x98, 0x31, 0xC3, 0x83,
  0x07, 0xCD, 0xF9, 0xE0, 0x06, 0x1C, 0x78, 0xF3, 0xC5, 0x9B, 0x7F, 0xFE,
  0x38, 0x60, 0x3E, 0x7C, 0xC3, 0x07, 0xCF, 0x83, 0x87, 0xEC, 0xF8, 0xE0,
  0x18, 0xE6, 0x38, 0xFB, 0xFC, 0xF3, 0xDF, 0xE7, 0x00, 0xFF, 0xF8, 0x30,
  0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC3, 0x00, 0x1C, 0x7C, 0xDB, 0xB3, 0xC7,
  0x9B, 0x76, 0xEC, 0xF9, 0xE0, 0x39, 0xFC, 0xF3, 0xCF, 0xF6, 0xC6, 0x3B,
  0xCE, 0x00, 0x73, 0x00, 0x00, 0xE6, 0x39, 0x80, 0x00, 0x00, 0xC4, 0x63,
  0x10, 0x04, 0x77, 0xB8, 0xF0, 0xE0, 0x80, 0xFF, 0xF0, 0x3E, 0xF8, 0x41,
  0xC3, 0xC3, 0x7F, 0xC8, 0x00, 0x7B, 0xED, 0xC7, 0x18, 0xC6, 0x18, 0x03,
  0x84, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x33, 0xB4, 0xD6, 0xB6, 0xF6, 0xD6,
  0x92, 0xDE, 0xDB, 0xF1, 0x00, 0x32, 0x03, 0xC0, 0x07, 0x03, 0x83, 0xC1,
  0xE1, 0xB0, 0xD8, 0xEC, 0x7E, 0x7F, 0xB1, 0xD8, 0xE0, 0x3E, 0x3F, 0x73,
  0x73, 0x7E, 0x7E, 0x66, 0x66, 0xE6, 0xFE, 0xFC, 0x3C, 0xFD, 0x9E, 0x3C,
  0x18, 0x30, 0x67, 0xCD, 0xF9, 0xE0, 0x3C, 0x3E, 0x77, 0x73, 0x63, 0x67,
  0x67, 0x66, 0xE6, 0xFC, 0xF8, 0x3F, 0x3F, 0x70, 0x70, 0x7E, 0x7C, 0x60,
  0x60, 0xE0, 0xFC, 0xFC, 0x3F, 0x3E, 0x70, 0x70, 0x60, 0x7C, 0x7C, 0x60,
  0xE0, 0xE0, 0xC0, 0x3C, 0xFD, 0x9E, 0x3C, 0x1B, 0xF7, 0xE3, 0xCF, 0xF9,
  0xE0, 0x31, 0x98, 0xDC, 0x6E, 0x77, 0xF3, 0xF9, 0x8C, 0xC6, 0xE3, 0x73,
  0xB1, 0x80, 0x33, 0x37, 0x66, 0x66, 0x6E, 0xC0, 0x06, 0x06, 0x06, 0x06,
  0x0E, 0x0E, 0x0C, 0x0C, 0xCC, 0xFC, 0x78, 0x33, 0x9B, 0x9D, 0x8F, 0xC7,
  0xC3, 0xE1, 0xF0, 0xD8, 0xEE, 0x77, 0x31, 0x80, 0x30, 0xC7, 0x1C, 0x61,
  0x86, 0x18, 0xE3, 0xFF, 0xC0, 0x38, 0xE7, 0x1D, 0xE7, 0xBC, 0xF7, 0x9E,
  0xF7, 0x9A, 0xB3, 0x76, 0xEE, 0xDD, 0xBB, 0x37, 0x00, 0x31, 0x98, 0xDE,
  0x6F, 0x76, 0xB3, 0x59, 0xBC, 0xDE, 0xE7, 0x73, 0xB1, 0x80, 0x3C, 0x7E,
  0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x3E, 0x3F, 0x73,
  0x73, 0x63, 0x7F, 0x7C, 0x60, 0xE0, 0xE0, 0xC0, 0x3C, 0x7E, 0x66, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x0C, 0x08, 0x3E, 0x3F, 0x73,
  0x73, 0x67, 0x7E, 0x7C, 0x6C, 0xEE, 0xEE, 0xC6, 0x1E, 0x3F, 0x73, 0x70,
  0x38, 0x3C, 0x0E, 0xE6, 0xE6, 0x7E, 0x3C, 0xFF, 0xFE, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x33, 0x99, 0x9C, 0xCE, 0x66, 0x33,
  0x19, 0x9C, 0xCC, 0x66, 0x3F, 0x0F, 0x00, 0xE3, 0xE7, 0xE6, 0x66, 0x6C,
  0x6C, 0x7C, 0x78, 0x78, 0x70, 0x70, 0xCC, 0xD9, 0x9B, 0x33, 0x6E, 0xCD,
  0xD9, 0xBB, 0x3D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3, 0x98, 0x00, 0x39, 0xC6,
  0x61, 0xB8, 0x6C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x37, 0x1D, 0xC6, 0x30,
  0xE7, 0x66, 0x6E, 0x6C, 0x78, 0x78, 0x30, 0x30, 0x70, 0x70, 0x60, 0x7F,
  0x7F, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xFE, 0xFE, 0x39, 0xCC,
  0xE6, 0x31, 0x8C, 0x63, 0x39, 0x8C, 0x73, 0x80, 0xCC, 0xE6, 0x66, 0x66,
  0x67, 0x33, 0x39, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x8C, 0xE6, 0x73, 0x80,
  0x18, 0xE2, 0x9A, 0x4C, 0xFF, 0xF0, 0x63, 0x3D, 0xF6, 0xDF, 0xEF, 0x3F,
  0xDB, 0x30, 0x61, 0xC3, 0x07, 0xCF, 0xD9, 0xB3, 0xEF, 0xDB, 0xF6, 0xC0,
  0x3D, 0xF6, 0xF8, 0xE3, 0x37, 0xDE, 0x07, 0x06, 0x06, 0x06, 0x36, 0x7E,
  0x6E, 0xEC, 0xCC, 0xCC, 0xFC, 0x7C, 0x3C, 0xF9, 0x9B, 0x3F, 0xFC, 0x1F,
  0x1C, 0x1C, 0xF3, 0x0C, 0x79, 0xE6, 0x18, 0x61, 0x86, 0x38, 0x3E, 0xFD,
  0x9F, 0x3C, 0xF9, 0xBF, 0x3E, 0x0D, 0xF3, 0xC0, 0x30, 0x61, 0xC3, 0x07,
  0xCF, 0xDB, 0xB7, 0xED, 0x9B, 0x36, 0x60, 0x33, 0x06, 0x66, 0x66, 0xEC,
  0xC0, 0x0C, 0x30, 0x07, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0xF3, 0x80,
  0x30, 0x30, 0x70, 0x60, 0x66, 0x6C, 0x7C, 0x78, 0xF8, 0xF8, 0xCC, 0xCC,
  0x33, 0x37, 0x66, 0x66, 0x6E, 0xCC, 0x7D, 0xDF, 0xF6, 0xED, 0xB3, 0x6C,
  0xFB, 0x3C, 0xDF, 0x36, 0x7C, 0xFD, 0xBB, 0x7E, 0xD9, 0xB3, 0x66, 0x3C,
  0xF9, 0x9F, 0x3E, 0xF9, 0x9F, 0x3C, 0x3E, 0x3F, 0x33, 0x33, 0x37, 0x76,
  0x7E, 0x6C, 0x60, 0x60, 0xE0, 0x3E, 0xFD, 0x9F, 0x7C, 0xD9, 0xBF, 0x3E,
  0x1C, 0x30, 0x60, 0x7B, 0xD8, 0xC6, 0x73, 0x18, 0x39, 0xF6, 0xDC, 0x3B,
  0x3F, 0xDE, 0x31, 0x9E, 0xF6, 0x31, 0x8C, 0x73, 0x80, 0x66, 0xCD, 0x9B,
  0x7E, 0xDD, 0xBF, 0x3E, 0xCF, 0x6D, 0xB6, 0xF3, 0xCE, 0x18, 0xDB, 0x6D,
  0xBE, 0xDF, 0xCE, 0xE7, 0x73, 0x31, 0x98, 0x37, 0x36, 0x1E, 0x1C, 0x3C,
  0x3C, 0x7C, 0x6E, 0x66, 0xD9, 0xB3, 0xE7, 0x8F, 0x1C, 0x18, 0x61, 0xC3,
  0x00, 0x7E, 0xF8, 0x71, 0xC3, 0x0C, 0x3F, 0x7C, 0x08, 0xCC, 0x63, 0x13,
  0x98, 0x63, 0x18, 0xC6, 0x30, 0x80, 0x22, 0x22, 0x26, 0x64, 0x44, 0x4C,
  0xC0, 0x10, 0x86, 0x31, 0x18, 0x63, 0x31, 0x8C, 0x46, 0x31, 0x00, 0x72,
  0xFD, 0x38,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 1, -11 },
  { 9, 8, 11, 8, 0, -11 },
  { 20, 7, 14, 7, 0, -13 },
  { 33, 7, 11, 9, 1, -11 },
  { 43, 8, 11, 9, 0, -11 },
  { 54, 2, 4, 2, 1, -11 },
  { 55, 4, 15, 5, 1, -12 },
  { 63, 5, 15, 5, -1, -12 },
  { 73, 6, 7, 7, 1, -11 },
  { 79, 7, 8, 7, 0, -9 },
  { 86, 3, 5, 4, -1, -2 },
  { 88, 4, 2, 6, 1, -6 },
  { 89, 3, 2, 4, 0, -2 },
  { 90, 7, 12, 5, -1, -11 },
  { 101, 6, 11, 7, 1, -11 },
  { 110, 4, 11, 7, 2, -11 },
  { 116, 7, 11, 7, 0, -11 },
  { 126, 7, 11, 7, 0, -11 },
  { 136, 7, 11, 7, 0, -11 },
  { 146, 7, 11, 7, 0, -11 },
  { 156, 6, 11, 7, 1, -11 },
  { 165, 7, 11, 7, 1, -11 },
  { 175, 7, 11, 7, 0, -11 },
  { 185, 6, 11, 7, 1, -11 },
  { 194, 4, 8, 4, 0, -8 },
  { 198, 5, 11, 4, -1, -8 },
  { 205, 6, 7, 7, 0, -8 },
  { 211, 6, 5, 7, 1, -7 },
  { 215, 6, 7, 7, 0, -8 },
  { 221, 6, 11, 7, 1, -11 },
  { 230, 11, 13, 11, 0, -10 },
  { 248, 9, 11, 9, -1, -11 },
  { 261, 8, 11, 8, 0, -11 },
  { 272, 7, 11, 8, 1, -11 },
  { 282, 8, 11, 8, 0, -11 },
  { 293, 8, 11, 7, 0, -11 },
  { 304, 8, 11, 7, 0, -11 },
  { 315, 7, 11, 9, 1, -11 },
  { 325, 9, 11, 9, 0, -11 },
  { 338, 4, 11, 4, 0, -11 },
  { 344, 8, 11, 7, 0, -11 },
  { 355, 9, 11, 8, 0, -11 },
  { 368, 6, 11, 7, 0, -11 },
  { 377, 11, 11, 11, 0, -11 },
  { 393, 9, 11, 9, 0, -11 },
  { 406, 8, 11, 9, 1, -11 },
  { 417, 8, 11, 8, 0, -11 },
  { 428, 8, 13, 9, 1, -11 },
  { 441, 8, 11, 8, 0, -11 },
  { 452, 8, 11, 8, 0, -11 },
  { 463, 8, 11, 8, 1, -11 },
  { 474, 9, 11, 8, 0, -11 },
  { 487, 8, 11, 8, 1, -11 },
  { 498, 11, 11, 11, 1, -11 },
  { 514, 10, 11, 8, -1, -11 },
  { 528, 8, 11, 8, 1, -11 },
  { 539, 8, 11, 8, 0, -11 },
  { 550, 5, 15, 4, 0, -12 },
  { 560, 4, 12, 6, 1, -11 },
  { 566, 5, 15, 4, -1, -12 },
  { 576, 6, 5, 6, 0, -11 },
  { 580, 6, 2, 6, -1, 0 },
  { 582, 4, 2, 5, 1, -11 },
  { 583, 6, 8, 7, 0, -8 },
  { 589, 7, 12, 7, 0, -12 },
  { 600, 6, 8, 7, 0, -8 },
  { 606, 8, 12, 7, 0, -12 },
  { 618, 7, 8, 7, 0, -8 },
  { 625, 6, 12, 5, 0, -12 },
  { 634, 7, 11, 7, 0, -8 },
  { 644, 7, 12, 7, 0, -12 },
  { 655, 4, 11, 4, 0, -11 },
  { 661, 6, 14, 4, -2, -11 },
  { 672, 8, 12, 7, 0, -12 },
  { 684, 4, 12, 4, 0, -12 },
  { 690, 10, 8, 11, 0, -8 },
  { 700, 7, 8, 7, 0, -8 },
  { 707, 7, 8, 7, 0, -8 },
  { 714, 8, 11, 7, -1, -8 },
  { 725, 7, 11, 7, 0, -8 },
  { 735, 5, 8, 5, 0, -8 },
  { 740, 6, 8, 7, 0, -8 },
  { 746, 5, 10, 5, 0, -10 },
  { 753, 7, 8, 7, 0, -8 },
  { 760, 6, 8, 7, 1, -8 },
  { 766, 9, 8, 9, 1, -8 },
  { 775, 8, 8, 7, -1, -8 },
  { 783, 7, 11, 7, 0, -8 },
  { 793, 7, 8, 7, 0, -8 },
  { 800, 5, 15, 4, 0, -12 },
  { 810, 4, 13, 4, 0, -11 },
  { 817, 5, 15, 4, -1, -12 },
  { 827, 7, 3, 8, 0, -6 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC15PT7B_H_
