#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC32PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x0F,
  0x83, 0xC1, 0xC0, 0x73, 0xB9, 0xDC, 0xFE, 0x7E, 0x7F, 0x3B, 0x9D, 0xCE,
  0xC7, 0x00, 0x00, 0xE6, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0xDC,
  0x03, 0x9C, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x07, 0x38, 0x07, 0x70,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0x1D, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x3B, 0x80, 0x33, 0x80, 0x73, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0x7F, 0x81, 0xFF, 0x87,
  0xFF, 0x0F, 0x1E, 0x3E, 0x3C, 0x7C, 0x7C, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0x38, 0xEE, 0x71, 0xDC, 0xE7, 0x39, 0xDC, 0x73, 0xB8, 0xFF, 0xE0,
  0xFF, 0x80, 0xF7, 0x00, 0x1C, 0x00, 0x77, 0x81, 0xFF, 0x83, 0xFF, 0x8E,
  0xE7, 0x3B, 0xCE, 0x77, 0x1D, 0xCE, 0x3F, 0x1C, 0xE2, 0x1F, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0xF1, 0xFC, 0xF1, 0xFF, 0x79, 0xF7, 0xFC, 0xF3,
  0xFE, 0xF8, 0xFE, 0x7C, 0x7F, 0x1F, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7E, 0x7C, 0x73, 0x9C, 0xEF, 0x7B, 0x9C, 0xE0, 0x00, 0x40,
  0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x20, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x0E, 0x02, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x0E, 0x33, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0x01, 0xFC, 0x1E, 0xF1,
  0xE3, 0x87, 0x1C, 0x10, 0x40, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x3C, 0x78, 0xF3, 0xC7,
  0x9F, 0x3C, 0xF0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF0, 0xF3, 0xC3, 0xDF, 0x0F, 0x7C, 0x3D,
  0xF1, 0xF7, 0xC7, 0xDE, 0x1F, 0x78, 0x7F, 0xE1, 0xEF, 0x87, 0xBE, 0x1E,
  0xF8, 0xFB, 0xE3, 0xC7, 0x9F, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xF0,
  0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0x7F, 0xDF, 0xE6, 0x78, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F,
  0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7,
  0xC3, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x7D, 0xF0, 0xF9,
  0xF3, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x1E, 0xF8, 0x39, 0xE0, 0xF3, 0xC3, 0xCF, 0x87, 0x9F,
  0x1F, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xE1, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0xC0, 0x8F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0xF0, 0xF9, 0xE1, 0xF3, 0xE7, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7D, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7C,
  0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xE3, 0xE7, 0x8F, 0x9F,
  0xFC, 0x7F, 0xE0, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF,
  0x3E, 0x7C, 0xF8, 0xF3, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0x7F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xF1, 0xF3, 0xCF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3,
  0xEF, 0x9F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE7, 0xCF, 0xBC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF7, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x03, 0xE0, 0x1F, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00,
  0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3E, 0x7C, 0xF8, 0xE0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC0, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7F, 0x1F, 0xFF, 0xFC, 0xFE, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x40, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x9F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0,
  0x10, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xE0,
  0x1F, 0x03, 0xF8, 0xFF, 0xDF, 0xF0, 0xFE, 0x07, 0xC0, 0x38, 0x01, 0x00,
  0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x9F, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x38, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x03, 0xC0,
  0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x0F, 0x0F, 0x86, 0x1C,
  0x3F, 0x8E, 0x70, 0xFF, 0x1C, 0xE3, 0xCE, 0x39, 0xCF, 0x1C, 0x77, 0x1E,
  0x38, 0xEE, 0x38, 0xE1, 0x9C, 0xF1, 0xC7, 0x39, 0xE3, 0x8E, 0xF3, 0xCF,
  0x1D, 0xE7, 0x9C, 0x33, 0x8F, 0x38, 0xE7, 0x1F, 0xFF, 0x87, 0x1F, 0x7E,
  0x0E, 0x1C, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x08, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C,
  0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0xBE,
  0x01, 0xFF, 0x80, 0x7C, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x9F,
  0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xE1, 0xE0, 0xF1, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xFF, 0xCF, 0xFF,
  0xC7, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xE1, 0xF1, 0xF1, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0x1F, 0x0F, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x1F, 0xCF, 0x9F, 0xE7, 0x8F, 0xF7, 0xC7, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x3C, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x81, 0xF0, 0xF8, 0x1E,
  0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x0F,
  0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x7E, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE3, 0xBC, 0x3F, 0xE7, 0xBC, 0x3C, 0xE7, 0x7C, 0x3C, 0xEF, 0x7C, 0x7C,
  0xEF, 0x7C, 0x7C, 0xEE, 0x7C, 0x7C, 0xFE, 0x78, 0x7C, 0xFC, 0xF8, 0x7C,
  0xFC, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x71, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE1, 0xFC, 0x3E,
  0x1F, 0xC3, 0xE1, 0xFC, 0x3E, 0x1F, 0xC3, 0xE1, 0xFC, 0x3C, 0x3E, 0xE7,
  0xC3, 0xEE, 0x7C, 0x3E, 0xE7, 0xC3, 0xEE, 0x7C, 0x3E, 0xF7, 0x83, 0xE7,
  0xF8, 0x7C, 0x7F, 0x87, 0xC7, 0xF8, 0x7C, 0x7F, 0x87, 0xC3, 0xF8, 0x7C,
  0x3F, 0x07, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF9, 0xF0,
  0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F,
  0x87, 0xC1, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3C, 0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x04, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0x87, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xE0, 0xF9,
  0xF0, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE,
  0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0xF0, 0x7C,
  0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x0F, 0x8F, 0x83,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xC7, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xDF, 0x03, 0xE7,
  0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x03, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0xF8, 0x7F, 0xC3, 0xE3, 0xEF, 0x0F, 0x8F, 0xBC, 0x7E, 0x3E, 0xF1, 0xF8,
  0xF3, 0xC7, 0xE7, 0xCF, 0x3F, 0x9F, 0x3C, 0xFE, 0x78, 0xF3, 0xFB, 0xE3,
  0xDF, 0xEF, 0x8F, 0x7F, 0xBC, 0x3D, 0xFF, 0xF0, 0xFF, 0x7F, 0xC3, 0xFD,
  0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0x7C,
  0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xDF, 0x00, 0x3D, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x0F, 0xBE, 0x01, 0xF3, 0xE0,
  0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F,
  0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x78, 0x7C, 0x78,
  0xF8, 0x7C, 0xF8, 0x7D, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0xE0, 0x07, 0x80, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x3B, 0x8F,
  0x71, 0xCE, 0x79, 0xEE, 0x3F, 0xC3, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x78, 0xF8, 0xF0, 0xF1, 0xE0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFE, 0x3E, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7,
  0xCF, 0xBE, 0x3E, 0xF8, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0xF0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x78, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF1, 0xE3, 0xC3,
  0xC7, 0x87, 0x9F, 0x0F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF8, 0xF9, 0xE1, 0xF3,
  0xE3, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x79, 0xF0, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE3, 0xEF, 0x1E, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x07, 0xBE, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xE7, 0xCF,
  0x87, 0x9F, 0x1F, 0x3E, 0x3E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3,
  0xC7, 0x8F, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1E, 0xF0, 0x07, 0xC0,
  0xFF, 0x8F, 0xFC, 0xFF, 0xF7, 0xC7, 0xBC, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x84, 0x7F, 0xF1, 0xFF, 0xC7, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF1, 0xF0, 0x3E, 0x07, 0xC3,
  0xFE, 0xFF, 0xDF, 0xF0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x07,
  0x9E, 0x1F, 0xDE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0x7C,
  0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x41, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0xBC, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCF, 0x9F, 0x3C, 0x7C, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1, 0xE7, 0x87, 0xBE, 0x3E, 0xF8, 0xFB,
  0xE3, 0xEF, 0x8F, 0xBC, 0x3C, 0x07, 0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x00,
  0x00, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x60, 0x07, 0x80,
  0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x3F, 0x1E, 0x7E, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D,
  0xF0, 0x79, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x0F,
  0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0x1E, 0xF0, 0xF0, 0x7F, 0xEF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3E, 0x7C, 0x7C, 0xF1, 0xF1, 0xF3, 0xC7, 0xC7, 0xDF, 0x1F, 0x1E,
  0x7C, 0x7C, 0x79, 0xF1, 0xE3, 0xE7, 0xC7, 0x8F, 0x9E, 0x3E, 0x3E, 0x78,
  0xF8, 0xFB, 0xE3, 0xE3, 0xCF, 0x8F, 0x8F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF1,
  0xF0, 0x1E, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x3E, 0x7C, 0xF1, 0xF3,
  0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0x87, 0x9E, 0x1E, 0xF8, 0xFB,
  0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF0, 0xF0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0xFF, 0xF7, 0xCF, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x9F, 0x7F, 0xF9, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x0F,
  0x78, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E,
  0x3C, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D, 0xE0, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F,
  0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0xFB, 0xE1, 0xEF, 0x8F, 0xBE,
  0x3E, 0xF0, 0xFB, 0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3D, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x1E, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xC1, 0xFF, 0x8F, 0xBE,
  0x3C, 0x78, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x3C, 0x3C, 0xF0, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x1F,
  0x0F, 0x87, 0x83, 0xC7, 0xFF, 0xFF, 0xFE, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7F, 0x1F, 0x8F, 0xC3, 0xE0, 0x3C,
  0x3D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1, 0xE7, 0x8F, 0xBE,
  0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x3C, 0xF9, 0xF3, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3D, 0xE0, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xEF,
  0x3E, 0x79, 0xF3, 0xCF, 0x1F, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0xF1, 0xE3, 0xFC,
  0x79, 0xFF, 0x3E, 0x7B, 0xCF, 0x9E, 0xF3, 0xEF, 0xBD, 0xFB, 0xCF, 0x7E,
  0xF3, 0xFF, 0xBC, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x00,
  0x1F, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0x1E, 0x1F,
  0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x81, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xE3, 0xE1, 0xC0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0F, 0x07,
  0x81, 0xC0, 0x60, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xC1, 0x80, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x0F,
  0x87, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x38, 0x0C, 0x00, 0x1E, 0x00, 0x7E, 0x1D, 0xFE, 0x7B,
  0xFF, 0xEF, 0x3F, 0xDE, 0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 9, 9, 10, 2, -24 },
  { 38, 16, 23, 16, 0, -23 },
  { 84, 15, 29, 16, 1, -26 },
  { 139, 15, 23, 20, 3, -23 },
  { 183, 17, 23, 18, 0, -23 },
  { 232, 5, 9, 5, 2, -24 },
  { 238, 10, 32, 10, 1, -25 },
  { 278, 10, 32, 10, -1, -25 },
  { 318, 13, 14, 14, 2, -23 },
  { 341, 13, 16, 15, 1, -19 },
  { 367, 7, 10, 8, -2, -4 },
  { 376, 8, 4, 12, 2, -12 },
  { 380, 5, 5, 9, 1, -5 },
  { 384, 14, 25, 10, -2, -23 },
  { 428, 14, 23, 16, 1, -23 },
  { 469, 10, 23, 16, 3, -23 },
  { 498, 15, 23, 16, 0, -23 },
  { 542, 15, 23, 16, 0, -23 },
  { 586, 15, 23, 16, 0, -23 },
  { 630, 15, 23, 16, 1, -23 },
  { 674, 14, 23, 16, 1, -23 },
  { 715, 16, 23, 16, 1, -23 },
  { 761, 14, 23, 16, 1, -23 },
  { 802, 13, 23, 16, 2, -23 },
  { 840, 7, 18, 9, 1, -18 },
  { 856, 9, 24, 8, -1, -18 },
  { 883, 12, 15, 14, 1, -17 },
  { 906, 14, 10, 16, 1, -15 },
  { 924, 13, 15, 14, 0, -17 },
  { 949, 12, 23, 14, 2, -23 },
  { 984, 23, 29, 24, 0, -22 },
  { 1068, 18, 23, 19, -1, -23 },
  { 1120, 17, 23, 18, 0, -23 },
  { 1169, 17, 23, 18, 1, -23 },
  { 1218, 17, 23, 17, 0, -23 },
  { 1267, 17, 23, 15, 0, -23 },
  { 1316, 16, 23, 15, 0, -23 },
  { 1362, 17, 23, 18, 1, -23 },
  { 1411, 20, 23, 19, 0, -23 },
  { 1469, 9, 23, 9, 0, -23 },
  { 1495, 16, 23, 15, 0, -23 },
  { 1541, 20, 23, 17, 0, -23 },
  { 1599, 13, 23, 15, 0, -23 },
  { 1637, 24, 23, 24, 0, -23 },
  { 1706, 20, 23, 19, 0, -23 },
  { 1764, 17, 23, 19, 1, -23 },
  { 1813, 18, 23, 18, 0, -23 },
  { 1865, 17, 27, 19, 1, -23 },
  { 1923, 17, 23, 17, 0, -23 },
  { 1972, 16, 23, 17, 1, -23 },
  { 2018, 17, 23, 17, 2, -23 },
  { 2067, 18, 23, 18, 1, -23 },
  { 2119, 18, 23, 18, 2, -23 },
  { 2171, 22, 23, 23, 3, -23 },
  { 2235, 20, 23, 17, -1, -23 },
  { 2293, 16, 23, 17, 3, -23 },
  { 2339, 19, 23, 17, -1, -23 },
  { 2394, 11, 32, 8, -1, -27 },
  { 2438, 9, 25, 12, 2, -23 },
  { 2467, 11, 32, 8, -2, -27 },
  { 2511, 11, 11, 12, 1, -23 },
  { 2527, 12, 4, 12, -2, 0 },
  { 2533, 7, 5, 10, 3, -24 },
  { 2538, 14, 17, 15, 0, -17 },
  { 2568, 15, 24, 15, 0, -24 },
  { 2613, 13, 17, 14, 1, -17 },
  { 2641, 15, 24, 15, 1, -24 },
  { 2686, 13, 17, 15, 1, -17 },
  { 2714, 11, 24, 10, 1, -24 },
  { 2747, 16, 24, 16, 0, -17 },
  { 2795, 14, 24, 15, 0, -24 },
  { 2837, 9, 24, 8, 0, -24 },
  { 2864, 13, 31, 8, -4, -24 },
  { 2915, 16, 24, 15, 0, -24 },
  { 2963, 9, 24, 8, 0, -24 },
  { 2990, 22, 17, 23, 0, -17 },
  { 3037, 14, 17, 15, 0, -17 },
  { 3067, 13, 17, 15, 1, -17 },
  { 3095, 16, 24, 15, -1, -17 },
  { 3143, 14, 24, 15, 1, -17 },
  { 3185, 11, 17, 10, 0, -17 },
  { 3209, 14, 17, 14, 0, -17 },
  { 3239, 9, 21, 10, 1, -21 },
  { 3263, 14, 17, 15, 1, -17 },
  { 3293, 13, 17, 14, 2, -17 },
  { 3321, 18, 17, 20, 2, -17 },
  { 3360, 16, 17, 14, -1, -17 },
  { 3394, 16, 24, 14, -1, -17 },
  { 3442, 14, 17, 14, 0, -17 },
  { 3472, 9, 31, 9, 1, -25 },
  { 3507, 7, 27, 8, 0, -23 },
  { 3531, 10, 31, 9, -1, -25 },
  { 3570, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC32PT7B_H_
