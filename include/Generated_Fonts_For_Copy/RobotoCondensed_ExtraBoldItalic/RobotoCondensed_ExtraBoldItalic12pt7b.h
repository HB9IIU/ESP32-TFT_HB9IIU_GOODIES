#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC12PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x86, 0xC0, 0xB6, 0x80, 0x14, 0x62, 0x9F, 0x3B, 0xE5,
  0x14, 0x60, 0x08, 0xE6, 0xDB, 0x60, 0xC1, 0xB6, 0x59, 0xC2, 0x00, 0x62,
  0xAA, 0xBC, 0x20, 0xE5, 0x6F, 0x18, 0x38, 0xA6, 0x8E, 0x71, 0xDD, 0xF6,
  0x7C, 0xE0, 0x2D, 0x69, 0x24, 0x92, 0x20, 0x21, 0x11, 0x11, 0x13, 0x32,
  0x64, 0x25, 0x7C, 0xC9, 0x00, 0x31, 0x9F, 0xF2, 0x10, 0x6D, 0x60, 0xE0,
  0xF0, 0x08, 0x44, 0x23, 0x10, 0x88, 0x46, 0x00, 0x39, 0xB6, 0xDB, 0x4D,
  0x2C, 0x96, 0x70, 0x17, 0xB2, 0x26, 0x66, 0x60, 0x39, 0xB6, 0xC2, 0x18,
  0xC6, 0x38, 0xF8, 0x39, 0xB0, 0xC6, 0x38, 0x61, 0xB6, 0x70, 0x0C, 0x63,
  0x8E, 0x7B, 0x6F, 0x84, 0x10, 0x3D, 0x86, 0x1E, 0x58, 0x2D, 0x96, 0x70,
  0x19, 0xD8, 0xF7, 0xE7, 0x2F, 0x70, 0x7C, 0x30, 0x86, 0x10, 0xC3, 0x18,
  0x60, 0x39, 0xB6, 0xDA, 0x79, 0x6D, 0xB6, 0x70, 0x76, 0xB7, 0xBD, 0x78,
  0xDC, 0xC0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x00, 0x26, 0x6C, 0x09, 0xF9,
  0xC7, 0x08, 0x78, 0x07, 0x80, 0x43, 0x87, 0xE8, 0x00, 0x7F, 0x33, 0x64,
  0x0C, 0xC0, 0x1E, 0x18, 0x9B, 0x4A, 0xB5, 0x55, 0xAA, 0xF5, 0x3C, 0x80,
  0x20, 0x0E, 0x00, 0x0C, 0x18, 0x70, 0xF3, 0x67, 0xCF, 0xB3, 0x66, 0x7D,
  0xF6, 0x5B, 0x79, 0x3C, 0xFF, 0xF8, 0x3C, 0x79, 0x9B, 0x04, 0x18, 0x33,
  0x3E, 0x78, 0x79, 0xF6, 0x59, 0x6D, 0x3C, 0xF6, 0xF0, 0x7D, 0xF6, 0x18,
  0x79, 0x0C, 0x3E, 0xF8, 0x7D, 0xF6, 0x1E, 0x79, 0x0C, 0x30, 0xC0, 0x3C,
  0x7D, 0x9B, 0x04, 0x0B, 0x93, 0x3E, 0x78, 0x66, 0xCD, 0x9B, 0xF7, 0xE8,
  0xB1, 0x66, 0xCC, 0x6D, 0xB6, 0xB6, 0xC0, 0x0C, 0x30, 0xC2, 0x18, 0x6D,
  0xBE, 0x70, 0x66, 0xD9, 0xB3, 0xC7, 0x8F, 0x36, 0x6C, 0xCC, 0x63, 0x18,
  0xC6, 0x23, 0x1F, 0xF8, 0x73, 0xB9, 0xDC, 0xEE, 0xF5, 0x52, 0xBB, 0x6D,
  0xB6, 0xDB, 0x00, 0x66, 0xED, 0xDB, 0xB7, 0x6B, 0xB3, 0x66, 0xCC, 0x3C,
  0x7D, 0x9B, 0x34, 0x78, 0xD3, 0x3E, 0x78, 0x7C, 0xF9, 0x9B, 0x37, 0xCF,
  0x30, 0x60, 0xC0, 0x3C, 0x7D, 0x9B, 0x34, 0x78, 0xD3, 0x3E, 0x78, 0x18,
  0x20, 0x7C, 0xF9, 0x93, 0x26, 0xCF, 0x36, 0x6C, 0xCC, 0x39, 0xF6, 0x58,
  0x38, 0x7C, 0xDE, 0x78, 0xFF, 0xF3, 0x08, 0x61, 0x86, 0x18, 0x60, 0x66,
  0xCD, 0x9B, 0x26, 0xC9, 0xB3, 0x3E, 0x78, 0xCD, 0x9B, 0x26, 0xCD, 0x8A,
  0x1C, 0x30, 0x60, 0xDB, 0xDB, 0xDA, 0xFE, 0xEE, 0xEE, 0xEC, 0xCC, 0xCC,
  0x66, 0xD8, 0xB1, 0xC3, 0x87, 0x1E, 0x64, 0xCC, 0xCF, 0x65, 0x94, 0x71,
  0x86, 0x18, 0x60, 0x7E, 0xF8, 0x30, 0xC3, 0x06, 0x18, 0x7E, 0xF8, 0x36,
  0x66, 0x64, 0x4C, 0xCC, 0xCC, 0xDB, 0x6C, 0x93, 0x6C, 0x31, 0x33, 0x33,
  0x22, 0x66, 0x6E, 0x33, 0x55, 0xF8, 0x4C, 0x33, 0xC6, 0xFD, 0xEF, 0xE0,
  0x63, 0x1E, 0xF4, 0xA7, 0x3B, 0xF0, 0x33, 0xF3, 0x8C, 0x6D, 0xC0, 0x0C,
  0x37, 0xDF, 0xCB, 0x6D, 0xB6, 0x78, 0x3B, 0xD3, 0xFC, 0x79, 0xC0, 0x39,
  0x9C, 0xC6, 0x31, 0x08, 0xC0, 0x7D, 0xFC, 0xB2, 0xDB, 0x67, 0xAC, 0xF0,
  0x63, 0x1E, 0xF4, 0xEF, 0x7B, 0xD8, 0x2C, 0x36, 0x96, 0xD8, 0x13, 0x03,
  0x32, 0x26, 0x66, 0xEC, 0x61, 0x86, 0xDE, 0x71, 0xCD, 0x36, 0xD8, 0x6D,
  0xB6, 0xB6, 0xC0, 0x7F, 0x7F, 0x5B, 0xDB, 0xDB, 0xDB, 0xDB, 0x7B, 0xD3,
  0xBD, 0xEF, 0x60, 0x3B, 0xF3, 0x9D, 0xED, 0xC0, 0x7B, 0xD3, 0x9D, 0xEF,
  0xD8, 0x80, 0x7D, 0xEC, 0xB6, 0xDB, 0x67, 0x84, 0x10, 0x77, 0x4C, 0xCC,
  0xC0, 0x72, 0xD0, 0xE1, 0xED, 0xC0, 0x67, 0x66, 0x64, 0x46, 0x6D, 0xA4,
  0xB6, 0xDB, 0x67, 0x80, 0x95, 0xAD, 0x4E, 0x73, 0x00, 0xB5, 0x6A, 0xF7,
  0xCD, 0x9B, 0x24, 0x00, 0x79, 0xE7, 0x1C, 0x73, 0x4D, 0x00, 0x4D, 0x65,
  0x9C, 0x71, 0x86, 0x30, 0xC0, 0x78, 0xCC, 0x46, 0x63, 0xC0, 0x12, 0x26,
  0x6C, 0x44, 0x44, 0x40, 0x25, 0x24, 0x92, 0x52, 0x00, 0x4D, 0xB6, 0x52,
  0xDA, 0x00, 0x65, 0xFD, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 2, 1, -9 },
  { 38, 3, 12, 4, 1, -9 },
  { 43, 4, 12, 4, -1, -9 },
  { 49, 5, 5, 5, 1, -9 },
  { 53, 5, 6, 5, 0, -7 },
  { 57, 3, 4, 3, -1, -1 },
  { 59, 3, 1, 5, 1, -4 },
  { 60, 2, 2, 3, 0, -2 },
  { 61, 5, 10, 4, -1, -9 },
  { 68, 6, 9, 6, 0, -9 },
  { 75, 4, 9, 6, 1, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 0, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 5, 9, 6, 1, -9 },
  { 134, 3, 7, 3, 0, -7 },
  { 137, 4, 10, 3, -1, -7 },
  { 142, 5, 6, 5, 0, -7 },
  { 146, 6, 3, 6, 0, -5 },
  { 149, 5, 5, 5, 0, -6 },
  { 153, 4, 9, 5, 1, -9 },
  { 158, 9, 11, 9, 0, -8 },
  { 171, 7, 9, 7, -1, -9 },
  { 179, 6, 9, 7, 0, -9 },
  { 186, 7, 9, 7, 0, -9 },
  { 194, 6, 9, 7, 0, -9 },
  { 201, 6, 9, 6, 0, -9 },
  { 208, 6, 9, 6, 0, -9 },
  { 215, 7, 9, 7, 0, -9 },
  { 223, 7, 9, 7, 0, -9 },
  { 231, 3, 9, 3, 0, -9 },
  { 235, 6, 9, 6, 0, -9 },
  { 242, 7, 9, 6, 0, -9 },
  { 250, 5, 9, 6, 0, -9 },
  { 256, 9, 9, 9, 0, -9 },
  { 267, 7, 9, 7, 0, -9 },
  { 275, 7, 9, 7, 0, -9 },
  { 283, 7, 9, 7, 0, -9 },
  { 291, 7, 11, 7, 0, -9 },
  { 301, 7, 9, 7, 0, -9 },
  { 309, 6, 9, 6, 0, -9 },
  { 316, 6, 9, 6, 1, -9 },
  { 323, 7, 9, 7, 0, -9 },
  { 331, 7, 9, 7, 1, -9 },
  { 339, 8, 9, 9, 1, -9 },
  { 348, 7, 9, 7, 0, -9 },
  { 356, 6, 9, 6, 1, -9 },
  { 363, 7, 9, 6, 0, -9 },
  { 371, 4, 12, 3, 0, -10 },
  { 377, 3, 10, 4, 1, -9 },
  { 381, 4, 12, 3, -1, -10 },
  { 387, 4, 4, 5, 0, -9 },
  { 389, 5, 1, 5, -1, 0 },
  { 390, 3, 2, 4, 1, -9 },
  { 391, 5, 7, 5, 0, -7 },
  { 396, 5, 9, 6, 0, -9 },
  { 402, 5, 7, 5, 0, -7 },
  { 407, 6, 9, 6, 0, -9 },
  { 414, 5, 7, 6, 0, -7 },
  { 419, 5, 9, 4, 0, -9 },
  { 425, 6, 9, 6, 0, -7 },
  { 432, 5, 9, 6, 0, -9 },
  { 438, 3, 10, 3, 0, -10 },
  { 442, 4, 12, 3, -1, -10 },
  { 448, 6, 9, 6, 0, -9 },
  { 455, 3, 9, 3, 0, -9 },
  { 459, 8, 7, 9, 0, -7 },
  { 466, 5, 7, 6, 0, -7 },
  { 471, 5, 7, 6, 0, -7 },
  { 476, 5, 9, 6, 0, -7 },
  { 482, 6, 9, 6, 0, -7 },
  { 489, 4, 7, 4, 0, -7 },
  { 493, 5, 7, 5, 0, -7 },
  { 498, 4, 8, 4, 0, -8 },
  { 502, 6, 7, 6, 0, -7 },
  { 508, 5, 7, 5, 1, -7 },
  { 513, 7, 7, 7, 1, -7 },
  { 520, 6, 7, 5, 0, -7 },
  { 526, 6, 9, 5, 0, -7 },
  { 533, 5, 7, 5, 0, -7 },
  { 538, 4, 11, 3, 0, -9 },
  { 544, 3, 11, 3, 0, -9 },
  { 549, 3, 11, 3, 0, -9 },
  { 554, 6, 3, 6, 0, -5 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC12PT7B_H_
