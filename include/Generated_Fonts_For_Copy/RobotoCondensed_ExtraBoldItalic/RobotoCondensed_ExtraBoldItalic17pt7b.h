#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC17PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x39, 0x8C, 0x03, 0x38, 0xC0, 0xDE, 0xF7, 0xA9,
  0x00, 0x0D, 0x05, 0x82, 0xC3, 0x47, 0xF0, 0xB0, 0xD1, 0xFC, 0x2C, 0x34,
  0x1E, 0x0B, 0x00, 0x04, 0x04, 0x1E, 0x3F, 0x33, 0x33, 0x30, 0x3C, 0x1E,
  0x06, 0x66, 0x66, 0x7E, 0x3C, 0x10, 0x10, 0x30, 0x3C, 0x16, 0xCB, 0xC5,
  0xC3, 0xE0, 0x7C, 0x3A, 0x3D, 0x36, 0x93, 0xC0, 0xC0, 0x1E, 0x0F, 0x0D,
  0xC6, 0xC3, 0xE1, 0xE1, 0xF6, 0xFF, 0xEF, 0x73, 0x9F, 0xCF, 0x60, 0x7F,
  0xC0, 0x08, 0xCC, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x0C, 0x40,
  0x10, 0x61, 0x82, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x30, 0xC6, 0x38,
  0x40, 0x18, 0x33, 0x5B, 0xE3, 0x8D, 0x12, 0x00, 0x1C, 0x1C, 0x18, 0x7E,
  0xFE, 0x18, 0x38, 0x30, 0x36, 0x66, 0xC0, 0xFF, 0x7D, 0x80, 0x06, 0x0C,
  0x30, 0x60, 0x83, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0x3C, 0xFD,
  0x9F, 0x3E, 0x79, 0xF3, 0xE7, 0xCD, 0x9B, 0xE3, 0x80, 0x1B, 0xFF, 0x63,
  0x18, 0xCE, 0x73, 0x18, 0xC0, 0x1E, 0x3F, 0x77, 0x73, 0x07, 0x06, 0x0C,
  0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x3F, 0x73, 0x03, 0x07, 0x1E, 0x1E,
  0x06, 0xE6, 0xE6, 0x7E, 0x38, 0x07, 0x07, 0x0F, 0x1E, 0x36, 0x36, 0x66,
  0xFF, 0xFE, 0x0C, 0x0C, 0x0C, 0x3F, 0x3F, 0x30, 0x30, 0x7C, 0x7E, 0x06,
  0x07, 0xE6, 0x66, 0x7E, 0x38, 0x0C, 0x79, 0xC3, 0x0F, 0xDF, 0xB3, 0xE7,
  0xCF, 0x9B, 0xF3, 0xC0, 0x7F, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x70, 0x70, 0xE0, 0xE0, 0x1E, 0x3F, 0x33, 0x33, 0x37, 0x3E, 0x3E, 0x66,
  0xE6, 0xE6, 0x7E, 0x3C, 0x3C, 0xF9, 0xBF, 0x3E, 0x7D, 0xFF, 0xBE, 0x0C,
  0x71, 0xE3, 0x00, 0x33, 0x30, 0x00, 0x06, 0xE6, 0x19, 0xC6, 0x00, 0x00,
  0x00, 0x31, 0x98, 0xC4, 0x00, 0x02, 0x1C, 0xFB, 0x8F, 0x0F, 0x87, 0x02,
  0xFF, 0xFC, 0x07, 0xEF, 0xC0, 0x20, 0xE0, 0xF0, 0x71, 0xEF, 0x9C, 0x40,
  0x38, 0xFB, 0xB8, 0x61, 0xC7, 0x0C, 0x38, 0x00, 0xC1, 0x83, 0x00, 0x07,
  0xC0, 0xEE, 0x18, 0x23, 0x03, 0x23, 0x96, 0x79, 0x4D, 0x94, 0x9B, 0xD9,
  0x3D, 0xB2, 0xDF, 0x6C, 0xDC, 0xC0, 0x06, 0x00, 0x7E, 0x01, 0xE0, 0x03,
  0x01, 0xE0, 0x78, 0x3E, 0x0D, 0x87, 0x61, 0x98, 0xE6, 0x3F, 0x9F, 0xF7,
  0x1F, 0x87, 0x3F, 0x1F, 0xCC, 0xEE, 0x77, 0x3B, 0xF9, 0xFC, 0xC6, 0x63,
  0x73, 0xBF, 0xDF, 0x80, 0x1E, 0x3F, 0x9C, 0xDC, 0x6E, 0x07, 0x03, 0x01,
  0x80, 0xC7, 0x63, 0x3F, 0x8F, 0x00, 0x3E, 0x1F, 0x8C, 0xEE, 0x77, 0x3B,
  0x9D, 0xCE, 0xC7, 0x63, 0x73, 0xBF, 0x9F, 0x80, 0x3F, 0x9F, 0xCC, 0x0E,
  0x07, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x70, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F,
  0x8C, 0x0E, 0x07, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x00,
  0x1E, 0x1F, 0x9C, 0xDC, 0x7E, 0x07, 0x7B, 0x3D, 0x8E, 0xC7, 0x73, 0xBF,
  0x8F, 0x80, 0x38, 0xCC, 0x33, 0x1D, 0xC7, 0x71, 0xDF, 0xE7, 0xF9, 0x86,
  0x63, 0xB8, 0xEE, 0x3B, 0x8C, 0x39, 0xCC, 0x67, 0x39, 0xCC, 0x63, 0x39,
  0xC0, 0x03, 0x03, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0xEE, 0xEE, 0x7C,
  0x78, 0x39, 0xC6, 0x70, 0xCE, 0x3B, 0x87, 0xE0, 0xF8, 0x1F, 0x83, 0xF0,
  0x66, 0x1C, 0xE3, 0x9C, 0x73, 0x80, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0xFF, 0xF0, 0x38, 0x79, 0xE3, 0xCF, 0x3C, 0xF9, 0xE7,
  0xCF, 0x3E, 0xF9, 0xB7, 0xCD, 0xEE, 0x6F, 0x67, 0x73, 0x3B, 0xB9, 0xCD,
  0xC0, 0x38, 0xCE, 0x33, 0x9D, 0xE7, 0x7D, 0xDF, 0x67, 0xD9, 0x96, 0x67,
  0xB9, 0xEE, 0x7B, 0x8C, 0x1E, 0x1F, 0x9C, 0xDC, 0x7E, 0x3F, 0x1F, 0x0D,
  0x86, 0xC7, 0x73, 0x3F, 0x8F, 0x80, 0x3F, 0x1F, 0xCC, 0x6E, 0x37, 0x1B,
  0x9D, 0xFC, 0xFC, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x1E, 0x1F, 0x9C, 0xDC,
  0x7E, 0x3F, 0x1F, 0x0D, 0x86, 0xC7, 0x73, 0x3F, 0x8F, 0x80, 0xE0, 0x20,
  0x3F, 0x1F, 0xCC, 0xEE, 0x37, 0x3B, 0x9D, 0xFC, 0xFC, 0x66, 0x73, 0x39,
  0xDC, 0xE0, 0x1F, 0x1F, 0x8E, 0xE6, 0x73, 0x81, 0xE0, 0x38, 0x0E, 0xE3,
  0x33, 0x9F, 0x87, 0x80, 0x7F, 0xFF, 0xC7, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x0C, 0x0E, 0x00, 0x39, 0xCC, 0x73, 0x19, 0xC6, 0x71,
  0x9C, 0xE7, 0x39, 0x8E, 0x63, 0x19, 0xC7, 0xF0, 0xF0, 0xE1, 0xB8, 0xE6,
  0x39, 0x9C, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x7C, 0x1E, 0x03, 0x80, 0xE0,
  0xE6, 0x7E, 0x67, 0xEE, 0x6E, 0xE6, 0xEE, 0xE7, 0xEC, 0x7E, 0xC7, 0xFC,
  0x77, 0x87, 0x38, 0x73, 0x86, 0x30, 0x18, 0xE3, 0xB8, 0x77, 0x0F, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x07, 0x61, 0xCE, 0x39, 0xC0, 0xE3,
  0xB1, 0x99, 0xCE, 0xC7, 0xE1, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x00, 0x3F, 0x8F, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x18, 0x0F, 0xF3, 0xFC, 0x38, 0xE3, 0x0C, 0x31, 0xC7, 0x1C, 0x61, 0x86,
  0x38, 0xE3, 0x8C, 0x38, 0xE0, 0xE7, 0x18, 0xC6, 0x39, 0xCE, 0x71, 0x8C,
  0x63, 0x80, 0x1C, 0xF1, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x31,
  0xC7, 0x3C, 0xE0, 0x18, 0x73, 0xCF, 0x6D, 0xB0, 0xFD, 0xF8, 0xED, 0x80,
  0x3C, 0xFD, 0x98, 0x33, 0xFF, 0xFB, 0xFE, 0x7C, 0x38, 0x30, 0x30, 0x30,
  0x7E, 0x7E, 0x67, 0x67, 0x67, 0x66, 0xE6, 0xFE, 0xDC, 0x3C, 0xFD, 0x9B,
  0x3E, 0x1C, 0x3B, 0xBE, 0x38, 0x03, 0x81, 0x80, 0xC0, 0x63, 0xF3, 0xF9,
  0x9C, 0xCC, 0xE6, 0x73, 0x3B, 0x8F, 0xC7, 0xE0, 0x1C, 0x3E, 0x66, 0x7F,
  0xFE, 0xE0, 0xE4, 0x7E, 0x3C, 0x0E, 0x38, 0xE1, 0xC7, 0xCF, 0x8C, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x00, 0x3B, 0x7F, 0x67, 0x67, 0xE6, 0xE6, 0xE6,
  0x7E, 0x7E, 0x0E, 0xFC, 0x78, 0x30, 0x30, 0x30, 0x70, 0x7E, 0x7E, 0x67,
  0x66, 0x66, 0xE6, 0xE6, 0xEE, 0xCE, 0x11, 0xCC, 0x07, 0x39, 0xCC, 0x63,
  0x39, 0xCE, 0x00, 0x04, 0x1C, 0x30, 0x00, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x86, 0x3C, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x73, 0xF1,
  0xB8, 0xF8, 0x7C, 0x3E, 0x3B, 0x1D, 0xCC, 0xE0, 0x39, 0x8C, 0x67, 0x39,
  0xCC, 0x63, 0x39, 0xCE, 0x00, 0x7E, 0xE7, 0xFE, 0x77, 0x76, 0x66, 0x66,
  0x66, 0x66, 0xEE, 0xEE, 0xEE, 0xCE, 0xE0, 0x7E, 0x7E, 0x67, 0x66, 0x66,
  0xE6, 0xEE, 0xEE, 0xCE, 0x1C, 0x7E, 0x67, 0x67, 0xE7, 0xE6, 0xE6, 0x7E,
  0x38, 0x3F, 0x1F, 0x8C, 0xE6, 0x73, 0x3B, 0x99, 0xCC, 0xFE, 0x6E, 0x30,
  0x18, 0x1C, 0x00, 0x3B, 0x7F, 0x67, 0x66, 0xE6, 0xE6, 0xEE, 0x7E, 0x7E,
  0x0C, 0x0C, 0x0C, 0x7D, 0xF7, 0xD8, 0x61, 0x8E, 0x38, 0xC0, 0x3C, 0xFD,
  0x9B, 0x83, 0xC3, 0xB3, 0xFE, 0x78, 0x76, 0xFF, 0xEE, 0xEC, 0xCE, 0xE0,
  0x73, 0x77, 0x67, 0x67, 0x66, 0xE6, 0xEE, 0x7E, 0x7E, 0xCF, 0x9B, 0x76,
  0xED, 0x9F, 0x1C, 0x38, 0x60, 0xCD, 0xF7, 0x6D, 0xDB, 0x7E, 0xFF, 0x3F,
  0xCE, 0xE3, 0xB8, 0xCE, 0x00, 0x3B, 0x9F, 0x87, 0x83, 0xC1, 0xC1, 0xF0,
  0xD8, 0xEC, 0x66, 0x00, 0x67, 0x66, 0x6E, 0x6C, 0x7C, 0x7C, 0x38, 0x38,
  0x30, 0x70, 0xE0, 0xC0, 0x7E, 0x7E, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xFC,
  0xFC, 0x08, 0x63, 0x8C, 0x30, 0xC3, 0x18, 0xE1, 0x86, 0x18, 0x61, 0x86,
  0x08, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0x10, 0x61, 0x86, 0x18,
  0x61, 0x87, 0x1C, 0xC3, 0x0C, 0x31, 0x86, 0x10, 0x63, 0xEF, 0x7C, 0x60,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 5, 5, 1, -13 },
  { 13, 9, 12, 9, 0, -12 },
  { 27, 8, 16, 8, 0, -14 },
  { 43, 9, 12, 11, 1, -12 },
  { 57, 9, 12, 10, 0, -12 },
  { 71, 2, 5, 3, 1, -13 },
  { 73, 5, 17, 5, 1, -13 },
  { 84, 6, 17, 5, -1, -13 },
  { 97, 7, 7, 8, 1, -12 },
  { 104, 8, 8, 8, 0, -10 },
  { 112, 4, 5, 4, -1, -2 },
  { 115, 4, 2, 6, 1, -6 },
  { 116, 3, 3, 5, 0, -3 },
  { 118, 7, 13, 5, -1, -12 },
  { 130, 7, 12, 8, 1, -12 },
  { 141, 5, 12, 8, 2, -12 },
  { 149, 8, 12, 8, 0, -12 },
  { 161, 8, 12, 8, 0, -12 },
  { 173, 8, 12, 8, 0, -12 },
  { 185, 8, 12, 8, 0, -12 },
  { 197, 7, 12, 8, 1, -12 },
  { 208, 8, 12, 8, 1, -12 },
  { 220, 8, 12, 8, 0, -12 },
  { 232, 7, 12, 8, 1, -12 },
  { 243, 4, 10, 5, 0, -10 },
  { 248, 5, 13, 4, -1, -10 },
  { 257, 7, 8, 7, 0, -9 },
  { 264, 7, 5, 8, 1, -8 },
  { 269, 7, 8, 7, 0, -9 },
  { 276, 7, 12, 7, 1, -12 },
  { 287, 12, 16, 13, 0, -12 },
  { 311, 10, 12, 10, -1, -12 },
  { 326, 9, 12, 9, 0, -12 },
  { 340, 9, 12, 9, 1, -12 },
  { 354, 9, 12, 9, 0, -12 },
  { 368, 9, 12, 8, 0, -12 },
  { 382, 9, 12, 8, 0, -12 },
  { 396, 9, 12, 10, 1, -12 },
  { 410, 10, 12, 10, 0, -12 },
  { 425, 5, 12, 5, 0, -12 },
  { 433, 8, 12, 8, 0, -12 },
  { 445, 11, 12, 9, 0, -12 },
  { 462, 7, 12, 8, 0, -12 },
  { 473, 13, 12, 13, 0, -12 },
  { 493, 10, 12, 10, 0, -12 },
  { 508, 9, 12, 10, 1, -12 },
  { 522, 9, 12, 9, 0, -12 },
  { 536, 9, 14, 10, 1, -12 },
  { 552, 9, 12, 9, 0, -12 },
  { 566, 9, 12, 9, 0, -12 },
  { 580, 9, 12, 9, 1, -12 },
  { 594, 10, 12, 9, 0, -12 },
  { 609, 10, 12, 10, 1, -12 },
  { 624, 12, 12, 12, 1, -12 },
  { 642, 11, 12, 9, -1, -12 },
  { 659, 9, 12, 9, 1, -12 },
  { 673, 10, 12, 9, 0, -12 },
  { 688, 6, 17, 4, 0, -14 },
  { 701, 5, 13, 6, 1, -12 },
  { 710, 6, 17, 4, -1, -14 },
  { 723, 6, 6, 7, 0, -12 },
  { 728, 7, 2, 7, -1, 0 },
  { 730, 3, 3, 6, 2, -13 },
  { 732, 7, 9, 8, 0, -9 },
  { 740, 8, 13, 8, 0, -13 },
  { 753, 7, 9, 8, 0, -9 },
  { 761, 9, 13, 8, 0, -13 },
  { 776, 8, 9, 8, 0, -9 },
  { 785, 7, 13, 5, 0, -13 },
  { 797, 8, 12, 8, 0, -9 },
  { 809, 8, 13, 8, 0, -13 },
  { 822, 5, 13, 4, 0, -13 },
  { 831, 7, 16, 4, -2, -13 },
  { 845, 9, 13, 8, 0, -13 },
  { 860, 5, 13, 4, 0, -13 },
  { 869, 12, 9, 12, 0, -9 },
  { 883, 8, 9, 8, 0, -9 },
  { 892, 8, 9, 8, 0, -9 },
  { 901, 9, 12, 8, -1, -9 },
  { 915, 8, 12, 8, 0, -9 },
  { 927, 6, 9, 6, 0, -9 },
  { 934, 7, 9, 7, 0, -9 },
  { 942, 4, 11, 5, 1, -11 },
  { 948, 8, 9, 8, 0, -9 },
  { 957, 7, 9, 8, 1, -9 },
  { 965, 10, 9, 10, 1, -9 },
  { 977, 9, 9, 8, -1, -9 },
  { 988, 8, 12, 7, 0, -9 },
  { 1000, 8, 9, 8, 0, -9 },
  { 1009, 6, 16, 5, 0, -13 },
  { 1021, 4, 14, 4, 0, -12 },
  { 1028, 6, 16, 5, -1, -13 },
  { 1040, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC17PT7B_H_
