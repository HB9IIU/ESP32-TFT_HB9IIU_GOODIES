#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC24PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xC0, 0x00,
  0x0C, 0x3C, 0x78, 0x60, 0x76, 0x66, 0x66, 0x66, 0x6E, 0xEC, 0xCC, 0x03,
  0x70, 0x36, 0x06, 0x60, 0x6E, 0x06, 0xC3, 0xFF, 0x3F, 0xF0, 0xD8, 0x1D,
  0x81, 0x98, 0x7F, 0xEF, 0xFC, 0x33, 0x03, 0x70, 0x36, 0x06, 0x60, 0x6E,
  0x00, 0x03, 0x00, 0x60, 0x3C, 0x0F, 0xE3, 0xFC, 0x73, 0x9E, 0x7B, 0xCF,
  0x38, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xFF,
  0x8F, 0xE0, 0xF8, 0x0C, 0x01, 0x80, 0x38, 0x0F, 0x83, 0xB1, 0xF7, 0x6C,
  0xDD, 0x9B, 0x3F, 0xC3, 0xF8, 0x06, 0x01, 0xB8, 0x7F, 0x9F, 0xB3, 0x66,
  0xCC, 0xF9, 0x98, 0x3F, 0x03, 0xC0, 0x07, 0x80, 0xFC, 0x1F, 0xE1, 0xCE,
  0x1C, 0xE1, 0xDC, 0x1F, 0xC1, 0xF8, 0x1E, 0x73, 0xF7, 0x77, 0xF7, 0x7F,
  0xF3, 0xEF, 0x3E, 0x7F, 0xE7, 0xFE, 0x3E, 0xF0, 0x77, 0x76, 0x6E, 0xE0,
  0x02, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x10,
  0x08, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0x80,
  0x06, 0x01, 0x80, 0x61, 0xDF, 0xFF, 0xC3, 0xC1, 0xE0, 0xDC, 0x73, 0x08,
  0x80, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFB, 0xFE, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x39, 0xDC, 0xE7, 0x73, 0x00, 0x7E,
  0xFB, 0xF0, 0x77, 0x77, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0C, 0x00, 0x0F, 0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xDC,
  0x77, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xB9, 0xEF, 0xF1,
  0xFC, 0x3C, 0x00, 0x06, 0x3F, 0xFF, 0xED, 0xC3, 0x8F, 0x1E, 0x3C, 0x70,
  0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0x07, 0x80, 0xFE, 0x1F, 0xE3, 0xCE,
  0x38, 0xE3, 0x8E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x07, 0x81, 0xFC, 0x1F,
  0xE3, 0xCE, 0x38, 0xE0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x01,
  0xC0, 0x1C, 0xF1, 0xCF, 0x3C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x00, 0xE0,
  0x3C, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0xC7, 0x70, 0xEE, 0x3B, 0xCE, 0x79,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x1F, 0xE7,
  0xFC, 0xFF, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0xC3, 0xFC, 0x7F, 0x80, 0x78,
  0x0F, 0x01, 0xEE, 0x39, 0xCF, 0x3F, 0xE3, 0xF8, 0x3C, 0x00, 0x03, 0x83,
  0xE1, 0xF8, 0xF8, 0x38, 0x1E, 0x07, 0x73, 0xFE, 0xFF, 0xFC, 0xFE, 0x3F,
  0x8F, 0xE3, 0xFC, 0xE7, 0xF9, 0xFC, 0x3E, 0x00, 0x7F, 0xEF, 0xFD, 0xFF,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xF8, 0xFF,
  0x1C, 0xE7, 0x9C, 0xF3, 0x9E, 0x71, 0xFC, 0x3F, 0x0F, 0xF3, 0xCE, 0x71,
  0xCE, 0x39, 0xCF, 0x3F, 0xE3, 0xF8, 0x3E, 0x00, 0x1E, 0x1F, 0x9F, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0xFF, 0xDF, 0xC0, 0xE0, 0xF0, 0xF3,
  0xF1, 0xF0, 0xE0, 0x00, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x01, 0xC7,
  0x1C, 0x70, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1,
  0xC3, 0x8E, 0x1C, 0x70, 0x40, 0x00, 0x40, 0x70, 0xFC, 0xFE, 0x7E, 0x1C,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xC0, 0x10, 0x7F, 0xDF, 0xF7, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0xFF, 0x80, 0x20, 0x0E, 0x03, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF0, 0x7C, 0x7F, 0x7F, 0x1F, 0x06, 0x02, 0x00, 0x3E, 0x3F,
  0xBF, 0xDC, 0xFE, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x00,
  0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1,
  0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC7, 0x8C, 0xC7, 0xE6, 0x67, 0x33, 0x73,
  0x39, 0xB3, 0x9C, 0xD9, 0xCC, 0x7C, 0xC6, 0x3E, 0x67, 0x37, 0x33, 0x9B,
  0x99, 0xD9, 0xCF, 0x7C, 0x63, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x08,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x79, 0xE1, 0xE7,
  0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xE7, 0x83, 0x9E, 0x0E, 0xF0, 0x38, 0x1F,
  0xC0, 0xFF, 0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0xFE,
  0x7F, 0xC3, 0xFF, 0x1E, 0x3C, 0xF1, 0xE7, 0x0F, 0x38, 0xF3, 0xFF, 0x9F,
  0xF8, 0xFF, 0x80, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x78, 0x77, 0x07,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x0E, 0xF1, 0xEF, 0x1E,
  0x7F, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x79, 0xE3,
  0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x78, 0x73, 0xC3, 0x9E, 0x3C, 0xF1,
  0xE7, 0x0E, 0x38, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0x87, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0xFC, 0x7F, 0xC7, 0xFC, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x78, 0xE7, 0x87, 0x38,
  0x3D, 0xC0, 0x1E, 0x00, 0xF3, 0xF7, 0x9F, 0xBC, 0xFD, 0xE1, 0xEF, 0x0E,
  0x78, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x1E, 0x1E, 0x38, 0x38, 0x70,
  0x71, 0xE0, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0E, 0x3C, 0x1C, 0x78,
  0x78, 0xF0, 0xF0, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1,
  0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0xF3, 0xCF, 0x38, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x1E, 0x3E, 0x38, 0xF8,
  0x71, 0xE1, 0xE7, 0x83, 0xDE, 0x07, 0xFC, 0x0E, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x03, 0xDE, 0x07, 0x1C, 0x0E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x7B, 0x3F, 0x9E, 0xDD,
  0xE7, 0xB7, 0x71, 0xED, 0x9C, 0x73, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x38, 0xF3, 0x8E, 0x00, 0x1E, 0x1E, 0x3C, 0x38, 0x78, 0x71, 0xF1,
  0xE3, 0xF3, 0xC7, 0xE7, 0x8E, 0xCF, 0x1D, 0x9C, 0x7B, 0xB8, 0xF7, 0xF1,
  0xE7, 0xE3, 0xCF, 0xC7, 0x1F, 0x8E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x79, 0xE7, 0x87, 0x38, 0x3D, 0xC1,
  0xFE, 0x0E, 0xF0, 0x77, 0x83, 0xBC, 0x3D, 0xE1, 0xEF, 0x0E, 0x78, 0xF1,
  0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x78, 0xF3,
  0xC3, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x79, 0xE7, 0x87, 0xB8, 0x3D, 0xC1, 0xFE, 0x0E, 0xF0, 0x77,
  0x83, 0xBC, 0x3D, 0xE1, 0xEF, 0x0E, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x78,
  0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x1E, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0,
  0xF7, 0x87, 0x1C, 0x38, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE0, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x79, 0xE1, 0xC7, 0x0E, 0x3C, 0xF1, 0xFF, 0x87, 0xF8,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x00, 0x38, 0x79, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x87,
  0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x39, 0xE3, 0xCE,
  0x1E, 0x79, 0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xF0, 0x7F, 0x87, 0xBC,
  0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xF1, 0xCF, 0x0E, 0x78, 0x73, 0x83, 0xBC,
  0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x80, 0x3C, 0x00,
  0xF1, 0xC7, 0x79, 0xE7, 0xBC, 0xF3, 0xDE, 0x79, 0xCF, 0x7C, 0xE7, 0xBE,
  0xF3, 0xDF, 0x71, 0xFF, 0xB8, 0xEF, 0xFC, 0x77, 0xFC, 0x3F, 0x7E, 0x1F,
  0xBF, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x00, 0x1E, 0x1E, 0x3C, 0x78, 0x38, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0xF7, 0x01,
  0xEE, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0x0F,
  0x71, 0xE7, 0x1C, 0x73, 0xC7, 0x38, 0x7F, 0x83, 0xF0, 0x3F, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x00, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xE3, 0x8F, 0x3C, 0xF1, 0xC7, 0x1C,
  0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8F, 0x3C, 0xF0, 0x1F, 0x1F, 0x1F, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x0E, 0x1E, 0x1E, 0x3E,
  0x36, 0x76, 0x77, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x71, 0xE3, 0x87,
  0x0F, 0x0F, 0xF3, 0xFD, 0xE7, 0x01, 0xC7, 0xF7, 0xFD, 0xEF, 0xF3, 0xBC,
  0xEF, 0xF9, 0xFE, 0x3B, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x7F, 0x0F, 0xF1, 0xFF, 0x39, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x1E, 0xE3,
  0xBC, 0x77, 0xFE, 0xFF, 0x9D, 0xE0, 0x0F, 0x07, 0xE3, 0xFD, 0xE7, 0x71,
  0xDC, 0x07, 0x03, 0xC0, 0xF3, 0xDC, 0xE7, 0xF9, 0xFC, 0x1E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEE, 0x3F, 0xE3, 0xFE, 0x79,
  0xE7, 0x1E, 0x71, 0xE7, 0x1C, 0xF1, 0xCF, 0x3C, 0xF3, 0xC7, 0xFC, 0x7F,
  0x83, 0xB8, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xE7, 0x1E, 0xE3, 0xDF, 0xFB,
  0xFE, 0x70, 0x0E, 0x11, 0xFE, 0x1F, 0xC1, 0xF0, 0x0F, 0x1F, 0x3F, 0x3C,
  0x38, 0xFE, 0xFE, 0xFE, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xE0, 0xE0, 0x1E, 0xF3, 0xFE, 0x3F, 0xE7, 0x9E, 0x71, 0xE7, 0x1E, 0x71,
  0xEF, 0x1C, 0xF1, 0xC7, 0x1C, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x38, 0x47,
  0x8F, 0xF8, 0xFF, 0x07, 0xC0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x77, 0x0F, 0xF1, 0xFE, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x1C, 0xE7,
  0xBC, 0xF7, 0x9E, 0xF3, 0xDC, 0x70, 0x08, 0x71, 0xC7, 0x00, 0xF3, 0x8E,
  0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xF3, 0xC0, 0x01, 0x01, 0xC0, 0xE0,
  0x70, 0x00, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x87, 0xC7, 0xC3, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xDF, 0x39, 0xE3, 0xBC, 0x3F, 0x87,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xF7, 0x8F, 0x38, 0xF3, 0xCE,
  0x3C, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xE3, 0xC7,
  0x0E, 0x1C, 0x78, 0xF1, 0xE0, 0x3B, 0x8E, 0x3F, 0xFF, 0x3F, 0xFF, 0x79,
  0xE7, 0x79, 0xE7, 0x79, 0xC7, 0x79, 0xCF, 0x71, 0xCF, 0x73, 0xCF, 0xF3,
  0xCE, 0xF3, 0xCE, 0xF3, 0x8E, 0xE3, 0x9E, 0x3B, 0x87, 0xF8, 0xFF, 0xBC,
  0xF7, 0x9E, 0xF3, 0x9C, 0x73, 0x8E, 0x73, 0xDE, 0x7B, 0xCF, 0x79, 0xCE,
  0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x1E, 0xE3, 0xDC, 0x7F, 0x8F,
  0xF1, 0xCE, 0x79, 0xFE, 0x1F, 0xC1, 0xE0, 0x1D, 0xC1, 0xFE, 0x1F, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x38, 0xE7, 0x9E, 0x7F, 0xE7,
  0xFC, 0x77, 0x87, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0xE7,
  0xFC, 0xFF, 0xBC, 0xF7, 0x1E, 0xE3, 0xDC, 0x77, 0x8E, 0xF3, 0xDE, 0x79,
  0xFF, 0x3F, 0xC3, 0xB8, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3B,
  0x3F, 0x3F, 0x7F, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0,
  0x0F, 0x0F, 0xE3, 0xFD, 0xE7, 0x78, 0x0F, 0x03, 0xF0, 0x3E, 0x07, 0xB8,
  0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x3C, 0x70, 0xE7, 0xFF, 0xDF, 0x9E, 0x38,
  0x70, 0xE3, 0xC7, 0x8F, 0x1F, 0x3E, 0x3C, 0x71, 0xDC, 0x77, 0x1F, 0xCF,
  0xF3, 0xFC, 0xFE, 0x3B, 0x8E, 0xE7, 0xB9, 0xEF, 0xFB, 0xFE, 0x77, 0x00,
  0xF3, 0xFC, 0xFF, 0x39, 0xDE, 0x77, 0x1D, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x00, 0xF3, 0x1F, 0xDE, 0xFF, 0x7B, 0xBD, 0xEE,
  0xEF, 0xBB, 0xBF, 0xCE, 0xFF, 0x1F, 0xFC, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x1C, 0x70, 0x71, 0xC0, 0x1C, 0xF1, 0xCE, 0x1D, 0xE1, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3B, 0xC7, 0xBC, 0xF1, 0xC0,
  0x3C, 0xF3, 0xCF, 0x3C, 0xE1, 0xDE, 0x1D, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x02, 0x07, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xF0, 0x70, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x10, 0x1C, 0x61, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x38, 0x08,
  0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x0F, 0x06, 0x1E,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x40, 0x38, 0xEF,
  0x9F, 0xFF, 0x73, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 8, 7, 7, 1, -18 },
  { 23, 12, 17, 12, 0, -17 },
  { 49, 11, 21, 12, 1, -19 },
  { 78, 11, 17, 15, 2, -17 },
  { 102, 12, 17, 14, 0, -17 },
  { 128, 4, 7, 4, 1, -18 },
  { 132, 8, 24, 8, 1, -19 },
  { 156, 8, 24, 8, -1, -19 },
  { 180, 10, 10, 11, 1, -17 },
  { 193, 10, 13, 11, 1, -14 },
  { 210, 5, 7, 6, -1, -3 },
  { 215, 7, 3, 9, 1, -9 },
  { 218, 4, 4, 7, 0, -4 },
  { 220, 11, 18, 7, -2, -17 },
  { 245, 10, 17, 12, 1, -17 },
  { 267, 7, 17, 12, 3, -17 },
  { 282, 12, 17, 12, 0, -17 },
  { 308, 12, 17, 12, 0, -17 },
  { 334, 11, 17, 12, 0, -17 },
  { 358, 11, 17, 12, 1, -17 },
  { 382, 10, 17, 12, 1, -17 },
  { 404, 11, 17, 12, 1, -17 },
  { 428, 11, 17, 12, 1, -17 },
  { 452, 9, 17, 12, 2, -17 },
  { 472, 6, 13, 7, 0, -13 },
  { 482, 7, 17, 6, -1, -13 },
  { 497, 10, 11, 10, 0, -13 },
  { 511, 10, 9, 12, 1, -12 },
  { 523, 10, 12, 11, 0, -13 },
  { 538, 9, 17, 11, 2, -17 },
  { 558, 17, 22, 18, 0, -17 },
  { 605, 14, 17, 14, -1, -17 },
  { 635, 13, 17, 13, 0, -17 },
  { 663, 12, 17, 13, 1, -17 },
  { 689, 13, 17, 13, 0, -17 },
  { 717, 13, 17, 11, 0, -17 },
  { 745, 12, 17, 11, 0, -17 },
  { 771, 13, 17, 14, 1, -17 },
  { 799, 15, 17, 14, 0, -17 },
  { 831, 7, 17, 6, 0, -17 },
  { 846, 12, 17, 11, 0, -17 },
  { 872, 15, 17, 13, 0, -17 },
  { 904, 10, 17, 11, 0, -17 },
  { 926, 18, 17, 18, 0, -17 },
  { 965, 15, 17, 14, 0, -17 },
  { 997, 13, 17, 14, 1, -17 },
  { 1025, 13, 17, 13, 0, -17 },
  { 1053, 13, 20, 14, 1, -17 },
  { 1086, 13, 17, 13, 0, -17 },
  { 1114, 13, 17, 13, 0, -17 },
  { 1142, 12, 17, 13, 2, -17 },
  { 1168, 13, 17, 13, 1, -17 },
  { 1196, 13, 17, 14, 2, -17 },
  { 1224, 17, 17, 17, 2, -17 },
  { 1261, 15, 17, 13, -1, -17 },
  { 1293, 12, 17, 13, 2, -17 },
  { 1319, 13, 17, 12, 0, -17 },
  { 1347, 9, 24, 6, -1, -20 },
  { 1374, 6, 18, 9, 2, -17 },
  { 1388, 8, 24, 6, -1, -20 },
  { 1412, 8, 9, 9, 1, -17 },
  { 1421, 9, 3, 9, -1, 0 },
  { 1425, 6, 4, 8, 2, -18 },
  { 1428, 10, 13, 11, 0, -13 },
  { 1445, 11, 18, 12, 0, -18 },
  { 1470, 10, 13, 11, 0, -13 },
  { 1487, 12, 18, 12, 0, -18 },
  { 1514, 11, 13, 11, 0, -13 },
  { 1532, 8, 18, 8, 1, -18 },
  { 1550, 12, 18, 12, 0, -13 },
  { 1577, 11, 18, 12, 0, -18 },
  { 1602, 6, 18, 6, 0, -18 },
  { 1616, 9, 23, 6, -3, -18 },
  { 1642, 12, 18, 11, 0, -18 },
  { 1669, 7, 18, 6, 0, -18 },
  { 1685, 16, 13, 17, 0, -13 },
  { 1711, 11, 13, 12, 0, -13 },
  { 1729, 11, 13, 12, 0, -13 },
  { 1747, 12, 18, 12, -1, -13 },
  { 1774, 11, 18, 12, 0, -13 },
  { 1799, 8, 13, 8, 0, -13 },
  { 1812, 10, 13, 11, 0, -13 },
  { 1829, 7, 16, 7, 1, -16 },
  { 1843, 10, 13, 12, 1, -13 },
  { 1860, 10, 13, 11, 1, -13 },
  { 1877, 14, 13, 15, 1, -13 },
  { 1900, 12, 13, 11, -1, -13 },
  { 1920, 12, 18, 11, -1, -13 },
  { 1947, 11, 13, 11, 0, -13 },
  { 1965, 8, 23, 7, 0, -19 },
  { 1988, 6, 20, 6, 0, -17 },
  { 2003, 8, 23, 7, -1, -19 },
  { 2026, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC24PT7B_H_
