#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC18PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x19, 0xCE, 0x60, 0x19, 0xC6, 0x00, 0x5E, 0xF7,
  0xBD, 0x00, 0x0D, 0x86, 0x82, 0xC7, 0xF3, 0xF8, 0xF0, 0x58, 0x68, 0xFF,
  0x7F, 0x9B, 0x0D, 0x05, 0x80, 0x02, 0x03, 0x03, 0x83, 0xE3, 0xB9, 0x9C,
  0xC0, 0x70, 0x1E, 0x07, 0x01, 0xCC, 0xE6, 0x73, 0xF0, 0xF0, 0x20, 0x10,
  0x00, 0x70, 0xF2, 0x92, 0x96, 0xFC, 0xE8, 0x18, 0x3E, 0x2F, 0x7B, 0xDB,
  0x9F, 0x0E, 0x0E, 0x0F, 0x8E, 0xC6, 0x63, 0x71, 0xF0, 0xF6, 0xFB, 0xEF,
  0xF7, 0xB9, 0xCF, 0xE3, 0xB8, 0x7B, 0x6C, 0x08, 0xCC, 0x66, 0x31, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0x61, 0x00, 0x10, 0x61, 0x83, 0x0C, 0x30,
  0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x18, 0xE3, 0x00, 0x08, 0x18, 0xDA,
  0xFF, 0x38, 0x68, 0xEC, 0x48, 0x0C, 0x0C, 0x1C, 0x7F, 0x7F, 0x18, 0x18,
  0x38, 0x38, 0x37, 0x76, 0xEC, 0xFF, 0x80, 0x7D, 0x80, 0x03, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x1C,
  0x3E, 0x76, 0x67, 0xE7, 0xE6, 0xE6, 0xC6, 0xCE, 0xCE, 0xCC, 0xFC, 0x78,
  0x09, 0xEF, 0xBE, 0x38, 0xE3, 0x0C, 0x31, 0xC7, 0x1C, 0x60, 0x1E, 0x1F,
  0x8C, 0xEE, 0x70, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0xEF,
  0xE0, 0x1E, 0x1F, 0x9C, 0xE0, 0x70, 0x70, 0xF0, 0x78, 0x0E, 0x07, 0x73,
  0xB9, 0x8F, 0xC3, 0xC0, 0x03, 0x83, 0x83, 0xC1, 0xE1, 0xF1, 0xB8, 0xD8,
  0xCC, 0xFF, 0x7F, 0x83, 0x81, 0xC0, 0xC0, 0x1F, 0x9F, 0xCC, 0x06, 0x03,
  0xE3, 0xF8, 0x1C, 0x0E, 0x07, 0x73, 0x99, 0x8F, 0xC3, 0xC0, 0x0E, 0x7C,
  0xE3, 0x8F, 0xDF, 0xFB, 0xE3, 0xC7, 0x9F, 0x3F, 0xE7, 0x80, 0x7F, 0xFF,
  0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x0E,
  0x1F, 0x8E, 0xE6, 0x73, 0x31, 0xF8, 0xF8, 0xEE, 0x67, 0x73, 0x99, 0x8F,
  0xC3, 0xC0, 0x1C, 0x7E, 0x76, 0xE6, 0xE6, 0xE6, 0xEE, 0x7E, 0x7E, 0x0C,
  0x3C, 0x78, 0x60, 0x31, 0xCC, 0x00, 0x00, 0x0C, 0xE3, 0x00, 0x19, 0xC6,
  0x00, 0x00, 0x00, 0x31, 0x9C, 0xC6, 0x20, 0x01, 0x0E, 0x3E, 0x7C, 0x60,
  0xF8, 0x3E, 0x0C, 0x04, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x20, 0x30, 0x7C,
  0x1F, 0x06, 0x3E, 0x78, 0xE0, 0x80, 0x3C, 0xFF, 0xBF, 0x70, 0xE3, 0x8E,
  0x18, 0x30, 0x01, 0x83, 0x06, 0x00, 0x03, 0xC0, 0x77, 0x86, 0x0C, 0x60,
  0x32, 0x39, 0xB3, 0xED, 0xB3, 0x69, 0x93, 0xD9, 0x96, 0xCD, 0xB3, 0xF9,
  0x9F, 0x84, 0x00, 0x30, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0x61, 0xDC, 0x67, 0x3F, 0xCF, 0xF7, 0x1D, 0xC7, 0xE0,
  0xC0, 0x3F, 0x0F, 0xE3, 0x9C, 0xC7, 0x73, 0x9F, 0xE7, 0xF1, 0xCE, 0x63,
  0x98, 0xEE, 0x73, 0xFC, 0xFE, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x3F,
  0x03, 0x81, 0x80, 0xC0, 0x63, 0xB9, 0xDF, 0xC7, 0xC0, 0x3E, 0x0F, 0xE3,
  0xB8, 0xC6, 0x71, 0xDC, 0x67, 0x19, 0xCE, 0x63, 0x98, 0xEE, 0x73, 0xF8,
  0xFC, 0x00, 0x3F, 0x9F, 0xCE, 0x06, 0x07, 0x03, 0xF9, 0xFC, 0xE0, 0x60,
  0x30, 0x38, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xCE, 0x06, 0x07, 0x03, 0x81,
  0xFC, 0xFE, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x00, 0x1F, 0x1F, 0xDC, 0xEC,
  0x3E, 0x07, 0x03, 0xBF, 0xDF, 0xC3, 0x63, 0xB9, 0xDF, 0xE3, 0xC0, 0x38,
  0xE7, 0x1C, 0xE3, 0x98, 0x67, 0x0C, 0xFF, 0x9F, 0xF3, 0x8E, 0x61, 0xCC,
  0x33, 0x86, 0x71, 0xCE, 0x38, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x73, 0x19,
  0xCE, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07,
  0x73, 0x3B, 0x8F, 0x87, 0x80, 0x39, 0xE7, 0x38, 0xEE, 0x1B, 0x87, 0x70,
  0xFC, 0x1F, 0x83, 0xF0, 0x76, 0x0C, 0xE3, 0x9C, 0x73, 0x8E, 0x38, 0x38,
  0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0xFF, 0xE0, 0x3C,
  0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0x9F,
  0x6C, 0x6D, 0xB1, 0xBD, 0xCE, 0x77, 0x39, 0x9C, 0xE6, 0x60, 0x38, 0xE7,
  0x1C, 0xE3, 0x9E, 0x67, 0xCC, 0xFB, 0x9D, 0x73, 0xBE, 0x67, 0xCC, 0xF3,
  0x8E, 0x71, 0xCE, 0x38, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x1F, 0x1F, 0x8F,
  0xC7, 0xC3, 0xE1, 0xB9, 0xDF, 0xC3, 0xC0, 0x3F, 0x0F, 0xE3, 0x9C, 0xC7,
  0x71, 0xDC, 0x77, 0x39, 0xFE, 0x7E, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xB9,
  0xCF, 0xC3, 0xE0, 0x38, 0x18, 0x3F, 0x0F, 0xE3, 0x9C, 0xC7, 0x71, 0xDC,
  0xE7, 0xF1, 0xF8, 0x77, 0x19, 0xCE, 0x73, 0x9C, 0xE3, 0x00, 0x0F, 0x0F,
  0xE3, 0x98, 0xC7, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xB8, 0xE6, 0x71,
  0xFC, 0x3E, 0x00, 0x7F, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0x71, 0xB9, 0xD8, 0xEC, 0x7E, 0x3F,
  0x1F, 0x8D, 0xCE, 0xC7, 0x63, 0xBB, 0x9F, 0xC7, 0xC0, 0xE1, 0xD8, 0x76,
  0x39, 0x8E, 0x73, 0x1D, 0xC7, 0x61, 0xF8, 0x7E, 0x1F, 0x03, 0xC0, 0xE0,
  0x38, 0x00, 0xCE, 0x7C, 0xE6, 0xCE, 0xED, 0xEE, 0xDE, 0xCD, 0xEC, 0xFF,
  0xCF, 0x7C, 0xF7, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x00, 0x1C, 0xE1,
  0xCE, 0x1D, 0xC0, 0xDC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03,
  0xB8, 0x3B, 0x87, 0x38, 0x71, 0xC0, 0x61, 0xDC, 0xE7, 0x31, 0xDC, 0x76,
  0x0F, 0x83, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x3F,
  0xCF, 0xF0, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0xFC, 0xFF, 0x00, 0x3C, 0xF3, 0x8C, 0x30, 0xC7, 0x1C, 0x71, 0xC6,
  0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0xE3, 0x18, 0xC7, 0x39, 0xCE, 0x31,
  0x8C, 0x73, 0x9C, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8C,
  0x30, 0xC7, 0x1C, 0xF3, 0x80, 0x18, 0xE7, 0x9A, 0xCB, 0x30, 0xFF, 0xFC,
  0xE6, 0x70, 0x1C, 0x3E, 0x77, 0x07, 0x3E, 0x7E, 0xEE, 0xEE, 0xFE, 0x7E,
  0x38, 0x38, 0x30, 0x30, 0x3E, 0x7F, 0x77, 0x73, 0x67, 0x67, 0xE7, 0xE7,
  0xFE, 0xDC, 0x1C, 0x3E, 0x77, 0x67, 0x60, 0xE0, 0xE6, 0xEE, 0x7C, 0x38,
  0x01, 0x81, 0xC0, 0xE0, 0x73, 0xB3, 0xF9, 0xDC, 0xCE, 0xE7, 0x73, 0xB9,
  0x9C, 0xC7, 0xE3, 0xB0, 0x1E, 0x3E, 0x77, 0x67, 0x7F, 0xFF, 0xE0, 0x60,
  0x7E, 0x3C, 0x0E, 0x3C, 0xE1, 0xC7, 0xCF, 0x8C, 0x18, 0x70, 0xE1, 0xC3,
  0x06, 0x0C, 0x00, 0x3F, 0xBF, 0x9C, 0xCC, 0x66, 0x77, 0x3B, 0x9D, 0xCE,
  0x7E, 0x3B, 0x03, 0x81, 0xCF, 0xC3, 0xC0, 0x38, 0x38, 0x30, 0x30, 0x7E,
  0x7F, 0x77, 0x77, 0x67, 0x67, 0xE6, 0xE6, 0xE6, 0xEE, 0x11, 0xCC, 0x03,
  0x39, 0xCE, 0x73, 0x19, 0xCE, 0x70, 0x04, 0x1C, 0x30, 0x00, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0xF1, 0xC0, 0x38, 0x1C,
  0x0C, 0x06, 0x07, 0x3B, 0xB9, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x1D, 0xCE,
  0xE7, 0x30, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x70, 0x7E,
  0xE7, 0xFF, 0x77, 0x37, 0x73, 0x67, 0x76, 0x77, 0x66, 0x7E, 0x67, 0xEE,
  0x6E, 0xE6, 0x7E, 0x7F, 0x77, 0x77, 0x67, 0x67, 0xE6, 0xE6, 0xE6, 0xEE,
  0x1E, 0x3F, 0x77, 0x63, 0x67, 0xE7, 0xE7, 0x66, 0x7E, 0x3C, 0x3F, 0x1F,
  0xCE, 0xE7, 0x33, 0x39, 0x9C, 0xCE, 0xE7, 0x7F, 0x3F, 0x18, 0x0C, 0x06,
  0x07, 0x00, 0x3B, 0x3F, 0x9D, 0xCC, 0xEE, 0x77, 0x3B, 0x9D, 0xCC, 0x7E,
  0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x7D, 0xF7, 0xDC, 0x61, 0x8E, 0x38,
  0xE3, 0x80, 0x3C, 0x7E, 0x77, 0x70, 0x78, 0x3E, 0x0E, 0xCE, 0xFC, 0x78,
  0x73, 0xBF, 0xE6, 0x73, 0x9C, 0xC6, 0x39, 0xC0, 0x73, 0xB9, 0x9C, 0xCE,
  0xE6, 0x73, 0x3B, 0x9D, 0xCC, 0x7E, 0x3B, 0x00, 0xEF, 0xDF, 0xB7, 0x6F,
  0xDF, 0x1E, 0x38, 0x70, 0xE0, 0xCC, 0xF3, 0x7D, 0xDF, 0x76, 0xD5, 0xBD,
  0xEF, 0x73, 0x9C, 0xE7, 0x39, 0x80, 0x3B, 0x9D, 0xC7, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x6C, 0x77, 0x33, 0x80, 0x73, 0x3B, 0x9D, 0xCF, 0xC7, 0xE3,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x00, 0x7F, 0x7F,
  0x0E, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0xFE, 0xFC, 0x0C, 0x71, 0x8E, 0x30,
  0xC3, 0x18, 0xE1, 0x86, 0x18, 0x61, 0x86, 0x1C, 0x20, 0x13, 0x33, 0x22,
  0x26, 0x66, 0x64, 0x44, 0xC0, 0x10, 0x61, 0x86, 0x18, 0x61, 0x87, 0x1C,
  0xE3, 0x0C, 0x30, 0xC6, 0x38, 0x40, 0x73, 0xFB, 0xDE, 0xCE,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 5, 5, 6, 1, -14 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 9, 17, 9, 0, -15 },
  { 49, 8, 13, 11, 2, -13 },
  { 62, 9, 13, 10, 0, -13 },
  { 77, 3, 5, 3, 1, -14 },
  { 79, 5, 18, 6, 1, -14 },
  { 91, 6, 18, 6, -1, -14 },
  { 105, 8, 8, 8, 1, -13 },
  { 113, 8, 9, 8, 0, -10 },
  { 122, 4, 6, 4, -1, -2 },
  { 125, 5, 2, 7, 1, -6 },
  { 127, 3, 3, 5, 0, -3 },
  { 129, 8, 14, 6, -1, -13 },
  { 143, 8, 13, 9, 1, -13 },
  { 156, 6, 13, 9, 2, -13 },
  { 166, 9, 13, 9, 0, -13 },
  { 181, 9, 13, 9, 0, -13 },
  { 196, 9, 13, 9, 0, -13 },
  { 211, 9, 13, 9, 0, -13 },
  { 226, 7, 13, 9, 1, -13 },
  { 238, 8, 13, 9, 1, -13 },
  { 251, 9, 13, 9, 0, -13 },
  { 266, 8, 13, 9, 1, -13 },
  { 279, 5, 10, 5, 0, -10 },
  { 286, 5, 14, 5, -1, -10 },
  { 295, 8, 9, 8, 0, -10 },
  { 304, 7, 5, 9, 1, -8 },
  { 309, 8, 9, 8, 0, -10 },
  { 318, 7, 13, 8, 1, -13 },
  { 330, 13, 16, 13, 0, -12 },
  { 356, 10, 13, 11, -1, -13 },
  { 373, 10, 13, 10, 0, -13 },
  { 390, 9, 13, 10, 1, -13 },
  { 405, 10, 13, 10, 0, -13 },
  { 422, 9, 13, 9, 0, -13 },
  { 437, 9, 13, 8, 0, -13 },
  { 452, 9, 13, 10, 1, -13 },
  { 467, 11, 13, 11, 0, -13 },
  { 485, 5, 13, 5, 0, -13 },
  { 494, 9, 13, 9, 0, -13 },
  { 509, 11, 13, 10, 0, -13 },
  { 527, 7, 13, 8, 0, -13 },
  { 539, 14, 13, 13, 0, -13 },
  { 562, 11, 13, 11, 0, -13 },
  { 580, 9, 13, 11, 1, -13 },
  { 595, 10, 13, 10, 0, -13 },
  { 612, 9, 15, 11, 1, -13 },
  { 629, 10, 13, 10, 0, -13 },
  { 646, 10, 13, 10, 0, -13 },
  { 663, 9, 13, 10, 1, -13 },
  { 678, 9, 13, 10, 1, -13 },
  { 693, 10, 13, 10, 1, -13 },
  { 710, 12, 13, 13, 2, -13 },
  { 730, 12, 13, 10, -1, -13 },
  { 750, 10, 13, 10, 1, -13 },
  { 767, 10, 13, 9, 0, -13 },
  { 784, 6, 18, 5, 0, -15 },
  { 798, 5, 14, 7, 1, -13 },
  { 807, 6, 18, 5, -1, -15 },
  { 821, 6, 6, 7, 1, -13 },
  { 826, 7, 2, 7, -1, 0 },
  { 828, 4, 3, 6, 2, -14 },
  { 830, 8, 10, 8, 0, -10 },
  { 840, 8, 14, 9, 0, -14 },
  { 854, 8, 10, 8, 0, -10 },
  { 864, 9, 14, 9, 0, -14 },
  { 880, 8, 10, 8, 0, -10 },
  { 890, 7, 14, 6, 0, -14 },
  { 903, 9, 14, 9, 0, -10 },
  { 919, 8, 14, 9, 0, -14 },
  { 933, 5, 14, 4, 0, -14 },
  { 942, 7, 18, 4, -2, -14 },
  { 958, 9, 14, 8, 0, -14 },
  { 974, 5, 14, 4, 0, -14 },
  { 983, 12, 10, 13, 0, -10 },
  { 998, 8, 10, 9, 0, -10 },
  { 1008, 8, 10, 9, 0, -10 },
  { 1018, 9, 14, 9, -1, -10 },
  { 1034, 9, 14, 9, 0, -10 },
  { 1050, 6, 10, 6, 0, -10 },
  { 1058, 8, 10, 8, 0, -10 },
  { 1068, 5, 12, 5, 1, -12 },
  { 1076, 9, 10, 9, 0, -10 },
  { 1088, 7, 10, 8, 1, -10 },
  { 1097, 10, 10, 11, 1, -10 },
  { 1110, 9, 10, 8, -1, -10 },
  { 1122, 9, 14, 8, 0, -10 },
  { 1138, 8, 10, 8, 0, -10 },
  { 1148, 6, 17, 5, 0, -14 },
  { 1161, 4, 15, 4, 0, -13 },
  { 1169, 6, 17, 5, -1, -14 },
  { 1182, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC18PT7B_H_
