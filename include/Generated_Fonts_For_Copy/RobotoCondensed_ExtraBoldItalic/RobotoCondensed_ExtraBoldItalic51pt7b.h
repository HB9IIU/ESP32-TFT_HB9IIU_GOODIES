#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC51PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0x78, 0x00,
  0x3E, 0x3E, 0xFC, 0x7D, 0xF8, 0xFB, 0xE3, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x1F, 0x3C, 0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x3E, 0x01, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xCF, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xE7, 0xC0, 0x83, 0xE3, 0xE0, 0xF1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xF8, 0x7C, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x7C, 0x1E, 0x1F, 0x7C,
  0x0F, 0x1F, 0xBE, 0x07, 0xDF, 0xBE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xDF,
  0x00, 0x3F, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x07, 0xDF, 0x3E, 0x07, 0xDF, 0x0F, 0x03, 0xEF, 0x87, 0x83,
  0xE7, 0xC3, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF9,
  0xF0, 0x7C, 0x7C, 0x70, 0x3E, 0x7E, 0x08, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xE3, 0xFF, 0xC3, 0xF3, 0xFF, 0xF1,
  0xF9, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0xFF, 0x3F,
  0xFF, 0x7F, 0x8F, 0xFF, 0xBF, 0x87, 0xFF, 0x9F, 0xC1, 0xFF, 0xCF, 0xE0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xC1, 0xFF, 0x1F, 0xE0,
  0x08, 0x00, 0x00, 0x3E, 0x7C, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7D, 0xFB,
  0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xC1, 0xE0, 0xEF, 0x8F,
  0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x1E,
  0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x01, 0x80, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE1, 0xFC,
  0x1F, 0x00, 0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07, 0xF7,
  0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0,
  0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0xBF, 0x81, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7D, 0xFE, 0x71, 0xFC, 0x81, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7F, 0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFC, 0x0F, 0xE7,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x8F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFD, 0xF8, 0x1F, 0xDF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xF3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0xFF,
  0x3F, 0x8F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1,
  0xFC, 0x07, 0xF3, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7,
  0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x8F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x07, 0xFB, 0xFC, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xF9, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F, 0x03, 0xC0,
  0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0x8F, 0xF7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0xF8, 0x0F,
  0xF8, 0x1E, 0x3F, 0x07, 0xFF, 0xC3, 0xC7, 0xC1, 0xFF, 0xF8, 0x79, 0xF8,
  0x3F, 0xFF, 0x0F, 0x3E, 0x0F, 0xC7, 0xE1, 0xE7, 0xC3, 0xF0, 0xF8, 0x3D,
  0xF0, 0x7C, 0x1F, 0x07, 0xBE, 0x1F, 0x83, 0xE0, 0xF7, 0xC3, 0xF0, 0xFC,
  0x3E, 0xF8, 0x7C, 0x1F, 0x07, 0xFE, 0x1F, 0x83, 0xE0, 0xFF, 0xC3, 0xF0,
  0x7C, 0x1E, 0xF8, 0x7E, 0x0F, 0x83, 0xDF, 0x0F, 0x83, 0xE0, 0x7B, 0xE1,
  0xF0, 0x7C, 0x1F, 0x7C, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC3, 0xF0, 0xF9,
  0xE0, 0xF8, 0x7E, 0x1E, 0x3C, 0x1F, 0x9F, 0xC7, 0xC7, 0xC3, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0x07, 0xF9, 0xFF, 0x03, 0xE0, 0x7E,
  0x1F, 0xC0, 0x7C, 0x02, 0x00, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xBF, 0xE0, 0x01, 0xFD, 0xFE, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE,
  0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x7F, 0x83, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x9F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0x7F,
  0x83, 0xFF, 0xCF, 0xF0, 0x7F, 0xF9, 0xFE, 0x0F, 0xFF, 0x3F, 0xC1, 0xFF,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0xCF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F,
  0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF,
  0x80, 0x07, 0xF1, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xF8,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFB, 0xE0, 0xFF,
  0xFC, 0x07, 0xF7, 0xC1, 0xFB, 0xF8, 0x1F, 0xEF, 0x83, 0xFF, 0xF0, 0x3F,
  0xDF, 0x0F, 0xDF, 0xE0, 0x7F, 0x3E, 0x1F, 0xBF, 0x80, 0xFE, 0x7C, 0x7E,
  0x7F, 0x01, 0xFC, 0xFC, 0xFC, 0xFE, 0x03, 0xF9, 0xFB, 0xF3, 0xFC, 0x0F,
  0xF3, 0xF7, 0xE7, 0xF8, 0x1F, 0xE7, 0xEF, 0x8F, 0xE0, 0x3F, 0xC7, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xFE, 0x7F, 0x80, 0xFE, 0x1F, 0xF8, 0xFF, 0x01,
  0xFC, 0x3F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x87, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0x80, 0xFF, 0x03,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x3F,
  0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0xFF, 0xF8, 0x7F, 0x81, 0xFF,
  0xF0, 0xFF, 0x03, 0xFF, 0xE1, 0xFE, 0x07, 0xF3, 0xE3, 0xFC, 0x1F, 0xE7,
  0xC7, 0xF0, 0x3F, 0xCF, 0x8F, 0xE0, 0x7F, 0x9F, 0x3F, 0xC0, 0xFF, 0x3F,
  0x7F, 0x81, 0xFC, 0x3E, 0xFF, 0x03, 0xF8, 0x7D, 0xFE, 0x0F, 0xF0, 0xFB,
  0xF8, 0x1F, 0xE1, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0x83, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0,
  0x7F, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01,
  0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0xF0,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xF8,
  0x1F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07,
  0xF8, 0x7F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xF9, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFC,
  0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0x83, 0xFD,
  0xFE, 0x0F, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x9F, 0xE3, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0x8F, 0xE1, 0xFE,
  0x7F, 0xF1, 0xFC, 0x1F, 0xCF, 0xFE, 0x7F, 0x83, 0xFB, 0xFF, 0xCF, 0xE0,
  0x7F, 0x7F, 0xF9, 0xFC, 0x0F, 0xEF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xEF,
  0xE0, 0x3F, 0xFE, 0xFD, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFB,
  0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x7F,
  0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF9, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xBC, 0x07,
  0xEF, 0x01, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3,
  0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x81, 0xF0, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF9, 0xFC, 0x7F, 0x87, 0xF1, 0xFC,
  0x1F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xBF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF,
  0x3F, 0xC1, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7,
  0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF, 0x0F, 0xE7,
  0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC7,
  0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xF1, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x7F, 0xCF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFE, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x81, 0xF9, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x60, 0x7F, 0x87,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0x00, 0xFF,
  0x00, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFB, 0xF0, 0x07,
  0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F,
  0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC3, 0xFF, 0x0F, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0xC0, 0xFE, 0x3F,
  0xE0, 0x3F, 0x9F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xC0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF8,
  0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xE3, 0xE0, 0x3E, 0x01, 0xFD, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xE7, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFC, 0xFF, 0xC7, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC1,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0x7F,
  0x8F, 0xE0, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8,
  0x3F, 0x8F, 0xF0, 0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0x83,
  0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3,
  0xE0, 0x1F, 0xDF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE,
  0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFF,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x9F, 0xE0,
  0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F,
  0xE0, 0xFF, 0x7F, 0x81, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0xC1, 0xFC, 0x7F,
  0x0F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x01, 0xFD,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x1F,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xCF, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xF9, 0xFC, 0x3F, 0xFB, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0x3F,
  0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8,
  0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x03,
  0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F,
  0x8F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE7, 0xC3, 0xFB, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xF6, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F,
  0xE1, 0xFE, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0x8F,
  0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF9, 0xFE,
  0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1,
  0xFE, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F,
  0xC7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xDF, 0xC0, 0x3F, 0x00, 0x00,
  0x7F, 0x03, 0xFD, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F,
  0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF3, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x80,
  0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0x83, 0xFB, 0xF8, 0x7E, 0x0F, 0xEF, 0xE1,
  0xF8, 0x7F, 0xBF, 0x87, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0xFE,
  0x1F, 0xCF, 0xE7, 0xF8, 0xFE, 0x3F, 0x9F, 0xE3, 0xF8, 0xFE, 0x7F, 0xCF,
  0xC3, 0xFB, 0xFF, 0x7F, 0x0F, 0xCF, 0xFD, 0xFC, 0x3F, 0x7F, 0xF7, 0xE0,
  0xFD, 0xF7, 0xFF, 0x83, 0xF7, 0xDF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF0, 0x3F,
  0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC,
  0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF9,
  0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC, 0x01, 0xF9, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xE0, 0x7C, 0xFF, 0xE0, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7,
  0xEF, 0xFF, 0xFF, 0xBF, 0x9F, 0xFF, 0x7E, 0x1F, 0xFE, 0xF8, 0x1F, 0xF9,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 36, 13, 1, -36 },
  { 60, 15, 14, 16, 3, -38 },
  { 87, 25, 36, 26, 1, -36 },
  { 200, 24, 46, 25, 1, -41 },
  { 338, 25, 36, 32, 4, -36 },
  { 451, 25, 37, 29, 1, -36 },
  { 567, 7, 14, 8, 3, -38 },
  { 580, 16, 51, 16, 2, -40 },
  { 682, 16, 51, 16, -2, -40 },
  { 784, 21, 22, 23, 3, -36 },
  { 842, 22, 27, 23, 1, -31 },
  { 917, 11, 16, 13, -3, -6 },
  { 939, 13, 6, 19, 3, -19 },
  { 949, 8, 8, 15, 1, -8 },
  { 957, 22, 39, 16, -3, -36 },
  { 1065, 22, 36, 25, 2, -36 },
  { 1164, 16, 36, 25, 5, -36 },
  { 1236, 24, 36, 25, 0, -36 },
  { 1344, 24, 36, 25, 1, -36 },
  { 1452, 23, 36, 25, 1, -36 },
  { 1556, 24, 36, 25, 1, -36 },
  { 1664, 21, 36, 25, 2, -36 },
  { 1759, 24, 36, 25, 2, -36 },
  { 1867, 24, 36, 25, 1, -36 },
  { 1975, 21, 36, 25, 3, -36 },
  { 2070, 12, 28, 14, 1, -28 },
  { 2112, 15, 38, 13, -2, -28 },
  { 2184, 20, 25, 22, 1, -28 },
  { 2247, 22, 16, 25, 2, -24 },
  { 2291, 20, 24, 22, 1, -27 },
  { 2351, 20, 36, 22, 3, -36 },
  { 2441, 35, 46, 38, 1, -35 },
  { 2643, 29, 36, 30, -2, -36 },
  { 2774, 27, 36, 28, 0, -36 },
  { 2896, 27, 36, 28, 2, -36 },
  { 3018, 27, 36, 28, 0, -36 },
  { 3140, 27, 36, 24, 0, -36 },
  { 3262, 26, 36, 24, 0, -36 },
  { 3379, 27, 36, 29, 2, -36 },
  { 3501, 31, 36, 30, 0, -36 },
  { 3641, 14, 36, 14, 0, -36 },
  { 3704, 25, 36, 24, 0, -36 },
  { 3817, 32, 36, 27, 0, -36 },
  { 3961, 21, 36, 24, 0, -36 },
  { 4056, 39, 36, 38, 0, -36 },
  { 4232, 31, 36, 30, 0, -36 },
  { 4372, 27, 36, 30, 2, -36 },
  { 4494, 28, 36, 28, 0, -36 },
  { 4620, 27, 43, 30, 2, -36 },
  { 4766, 28, 36, 28, 0, -36 },
  { 4892, 26, 36, 27, 1, -36 },
  { 5009, 26, 36, 27, 4, -36 },
  { 5126, 28, 36, 28, 2, -36 },
  { 5252, 28, 36, 29, 4, -36 },
  { 5378, 35, 36, 37, 4, -36 },
  { 5536, 32, 36, 28, -2, -36 },
  { 5680, 27, 36, 27, 4, -36 },
  { 5802, 29, 36, 26, -1, -36 },
  { 5933, 17, 51, 13, -1, -42 },
  { 6042, 13, 39, 19, 4, -36 },
  { 6106, 18, 51, 13, -3, -42 },
  { 6221, 18, 18, 20, 1, -36 },
  { 6262, 20, 6, 20, -3, 0 },
  { 6277, 11, 8, 17, 5, -39 },
  { 6288, 22, 27, 23, 0, -27 },
  { 6363, 23, 38, 24, 0, -38 },
  { 6473, 21, 27, 23, 1, -27 },
  { 6544, 25, 38, 25, 1, -38 },
  { 6663, 22, 27, 24, 1, -27 },
  { 6738, 19, 39, 16, 1, -39 },
  { 6831, 25, 37, 25, 0, -27 },
  { 6947, 24, 38, 24, -1, -38 },
  { 7061, 14, 38, 13, 0, -38 },
  { 7128, 20, 48, 12, -6, -38 },
  { 7248, 26, 38, 24, 0, -38 },
  { 7372, 14, 38, 13, 0, -38 },
  { 7439, 35, 27, 37, 0, -27 },
  { 7558, 23, 27, 24, 0, -27 },
  { 7636, 22, 27, 25, 1, -27 },
  { 7711, 25, 37, 24, -2, -27 },
  { 7827, 23, 37, 25, 1, -27 },
  { 7934, 18, 27, 17, 0, -27 },
  { 7995, 22, 27, 22, 0, -27 },
  { 8070, 14, 34, 15, 2, -34 },
  { 8130, 23, 27, 24, 1, -27 },
  { 8208, 22, 27, 22, 2, -27 },
  { 8283, 30, 27, 31, 3, -27 },
  { 8385, 26, 27, 23, -2, -27 },
  { 8473, 25, 37, 22, -1, -27 },
  { 8589, 24, 27, 23, -1, -27 },
  { 8670, 16, 49, 15, 1, -40 },
  { 8768, 11, 43, 13, 1, -36 },
  { 8828, 16, 49, 15, -2, -40 },
  { 8926, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC51PT7B_H_
