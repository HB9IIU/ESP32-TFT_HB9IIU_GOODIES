#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC10PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0xB0, 0x66, 0x60, 0x29, 0x9E, 0xAF, 0x32, 0x80, 0x11,
  0x9E, 0x83, 0x0B, 0x4E, 0x40, 0xC5, 0xB8, 0x47, 0x54, 0xC0, 0x33, 0x9C,
  0xDF, 0xE9, 0xE0, 0xE0, 0x12, 0x44, 0x4C, 0xC4, 0x44, 0x48, 0x96, 0xD2,
  0x90, 0x23, 0xC8, 0xA0, 0x22, 0xF6, 0x60, 0x69, 0x00, 0xC0, 0x30, 0x18,
  0x84, 0x42, 0x21, 0x08, 0x32, 0xD6, 0xBD, 0x69, 0x80, 0x3D, 0xB4, 0x90,
  0x72, 0xC6, 0x62, 0x23, 0xC0, 0x72, 0xC6, 0x61, 0x69, 0xC0, 0x19, 0xDC,
  0xAF, 0x18, 0xC0, 0x7A, 0x1C, 0x21, 0x69, 0x80, 0x33, 0x1C, 0xBD, 0xE9,
  0xC0, 0x78, 0xC4, 0x62, 0x31, 0x00, 0x33, 0xD6, 0xED, 0x69, 0xC0, 0x6B,
  0xBB, 0xE6, 0xC0, 0x48, 0x01, 0x80, 0x50, 0x3A, 0x1E, 0xE2, 0x70, 0x3C,
  0x43, 0x78, 0xF4, 0xBD, 0x20, 0x1C, 0x45, 0x7D, 0x5A, 0xB5, 0x6F, 0x60,
  0x70, 0x11, 0xCE, 0xF5, 0xFE, 0x20, 0x7A, 0x52, 0xED, 0xEF, 0xC0, 0x39,
  0xA4, 0xD0, 0xC3, 0x67, 0x00, 0x72, 0x52, 0x9D, 0xEF, 0xC0, 0x7A, 0x10,
  0xEC, 0x63, 0xC0, 0x7A, 0x10, 0xEC, 0x63, 0x00, 0x39, 0xB4, 0x16, 0xC9,
  0x67, 0x00, 0x65, 0x34, 0xDF, 0xCB, 0x2D, 0x80, 0x6D, 0x25, 0xB0, 0x18,
  0xC6, 0x21, 0x79, 0x80, 0x6D, 0x65, 0x1C, 0xD3, 0x4D, 0x80, 0x64, 0x44,
  0xCC, 0xF0, 0x66, 0x66, 0x66, 0x6A, 0xEE, 0xD6, 0xD4, 0x65, 0xB6, 0xD7,
  0xDB, 0x6D, 0x80, 0x39, 0xB4, 0xD3, 0xC9, 0x67, 0x00, 0x79, 0x24, 0x92,
  0xF3, 0x0C, 0x00, 0x39, 0xB4, 0xD3, 0xC9, 0x67, 0x06, 0x7A, 0x52, 0xED,
  0x6B, 0x60, 0x3B, 0x58, 0x61, 0xED, 0xC0, 0xFB, 0x18, 0xC4, 0x23, 0x00,
  0x6D, 0x34, 0x92, 0xCB, 0x67, 0x00, 0x9C, 0xF5, 0xEE, 0x71, 0x00, 0xB7,
  0x6A, 0xF7, 0xED, 0x9B, 0x36, 0x00, 0x6D, 0xE3, 0x0C, 0x71, 0x4D, 0x80,
  0x9E, 0xBC, 0xC4, 0x23, 0x00, 0x7C, 0x61, 0x0C, 0x63, 0x0F, 0x00, 0x6D,
  0x25, 0xB6, 0x98, 0xAF, 0xF5, 0x33, 0x32, 0x22, 0x66, 0x64, 0x26, 0x55,
  0xF0, 0xD0, 0x75, 0x7F, 0xF0, 0x62, 0x10, 0xE5, 0xEB, 0x56, 0x7D, 0xCD,
  0x60, 0x08, 0xC6, 0xFD, 0x6B, 0x5E, 0x75, 0xFD, 0x70, 0x36, 0x6E, 0x44,
  0xCC, 0x7E, 0xF5, 0xA7, 0x5B, 0x80, 0x64, 0x47, 0xDD, 0xDB, 0x0C, 0x25,
  0xB6, 0x03, 0x02, 0x26, 0x66, 0x4C, 0x62, 0x10, 0xB7, 0x73, 0xD6, 0x6D,
  0x25, 0xB6, 0x7E, 0xAF, 0x5E, 0xAB, 0x40, 0x75, 0xDD, 0xB0, 0x76, 0xB5,
  0xA7, 0x00, 0x72, 0xF5, 0xAB, 0x42, 0x00, 0x7E, 0xB5, 0xAF, 0x18, 0xC0,
  0x66, 0xCC, 0x80, 0x75, 0x6B, 0xE0, 0x6F, 0xA5, 0x90, 0x5A, 0xF5, 0xAF,
  0x00, 0x52, 0x9C, 0xC6, 0x00, 0xAF, 0xFD, 0xEB, 0x00, 0x53, 0x98, 0xCF,
  0x00, 0x5A, 0x9C, 0xC6, 0x23, 0x00, 0x73, 0x6C, 0xF0, 0x25, 0xA5, 0x12,
  0xC8, 0x55, 0x6A, 0x49, 0x24, 0xD6, 0x90, 0x6F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 4, 3, 3, 0, -8 },
  { 6, 5, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 5, 7, 6, 1, -7 },
  { 22, 5, 7, 6, 0, -7 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 4, 10, 3, 0, -8 },
  { 33, 3, 10, 3, 0, -8 },
  { 37, 5, 4, 4, 0, -7 },
  { 40, 4, 5, 5, 0, -6 },
  { 43, 3, 3, 2, -1, -1 },
  { 45, 2, 1, 4, 1, -3 },
  { 46, 2, 2, 3, 0, -2 },
  { 47, 5, 8, 3, -1, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 4, 7, 5, 1, -7 },
  { 99, 3, 6, 3, 0, -6 },
  { 102, 2, 8, 3, 0, -6 },
  { 104, 4, 4, 4, 0, -5 },
  { 106, 5, 3, 5, 0, -5 },
  { 108, 4, 4, 4, 0, -5 },
  { 110, 3, 7, 4, 1, -7 },
  { 113, 7, 9, 7, 0, -7 },
  { 121, 5, 7, 6, 0, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 6, 7, 6, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 5, 7, 5, 0, -7 },
  { 152, 6, 7, 6, 0, -7 },
  { 158, 6, 7, 6, 0, -7 },
  { 164, 3, 7, 3, 0, -7 },
  { 167, 5, 7, 5, 0, -7 },
  { 172, 6, 7, 5, 0, -7 },
  { 178, 4, 7, 5, 0, -7 },
  { 182, 8, 7, 7, 0, -7 },
  { 189, 6, 7, 6, 0, -7 },
  { 195, 6, 7, 6, 0, -7 },
  { 201, 6, 7, 6, 0, -7 },
  { 207, 6, 8, 6, 0, -7 },
  { 213, 5, 7, 5, 0, -7 },
  { 218, 5, 7, 5, 0, -7 },
  { 223, 5, 7, 5, 1, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 5, 7, 6, 1, -7 },
  { 239, 7, 7, 7, 1, -7 },
  { 246, 6, 7, 5, 0, -7 },
  { 252, 5, 7, 5, 1, -7 },
  { 257, 6, 7, 5, 0, -7 },
  { 263, 3, 10, 3, 0, -8 },
  { 267, 2, 8, 4, 1, -7 },
  { 269, 4, 10, 3, -1, -8 },
  { 274, 4, 4, 4, 0, -7 },
  { 276, 4, 1, 4, -1, 0 },
  { 277, 2, 2, 3, 1, -8 },
  { 278, 4, 5, 5, 0, -5 },
  { 281, 5, 8, 5, 0, -8 },
  { 286, 4, 5, 4, 0, -5 },
  { 289, 5, 8, 5, 0, -8 },
  { 294, 4, 5, 5, 0, -5 },
  { 297, 4, 8, 3, 0, -8 },
  { 301, 5, 7, 5, 0, -5 },
  { 306, 4, 8, 5, 0, -8 },
  { 310, 3, 8, 2, 0, -8 },
  { 313, 4, 10, 2, -1, -8 },
  { 318, 5, 8, 5, 0, -8 },
  { 323, 3, 8, 2, 0, -8 },
  { 326, 7, 5, 7, 0, -5 },
  { 331, 4, 5, 5, 0, -5 },
  { 334, 5, 5, 5, 0, -5 },
  { 338, 5, 7, 5, 0, -5 },
  { 343, 5, 7, 5, 0, -5 },
  { 348, 4, 5, 3, 0, -5 },
  { 351, 4, 5, 4, 0, -5 },
  { 354, 3, 7, 3, 0, -7 },
  { 357, 5, 5, 5, 0, -5 },
  { 361, 5, 5, 4, 0, -5 },
  { 365, 5, 5, 6, 1, -5 },
  { 369, 5, 5, 4, 0, -5 },
  { 373, 5, 7, 4, 0, -5 },
  { 378, 4, 5, 4, 0, -5 },
  { 381, 3, 10, 3, 0, -8 },
  { 385, 2, 8, 2, 0, -7 },
  { 387, 3, 10, 3, 0, -8 },
  { 391, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC10PT7B_H_
