#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC16PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x67, 0x31, 0x8C, 0x02, 0x38, 0x80, 0xDE, 0xB5, 0x60,
  0x0B, 0x0A, 0x1A, 0x16, 0x7F, 0x34, 0x3C, 0xFE, 0x28, 0x68, 0x58, 0x50,
  0x04, 0x04, 0x1E, 0x3E, 0x37, 0x37, 0x30, 0x38, 0x1C, 0x0E, 0xE6, 0x6E,
  0x7C, 0x38, 0x10, 0x10, 0x70, 0x5A, 0xDA, 0xD6, 0x7C, 0x08, 0x18, 0x36,
  0x2F, 0x6B, 0x4B, 0x0E, 0x1C, 0x3E, 0x36, 0x36, 0x3C, 0x38, 0x7B, 0x7F,
  0xEF, 0xEE, 0x7E, 0x7F, 0xFE, 0x11, 0xCC, 0xC6, 0x23, 0x18, 0xC6, 0x31,
  0x08, 0x63, 0x08, 0x40, 0x10, 0x86, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33,
  0x19, 0x9C, 0x40, 0x18, 0x23, 0x5B, 0xE7, 0x1B, 0x12, 0x00, 0x18, 0x30,
  0x63, 0xFF, 0xE7, 0x0C, 0x18, 0x36, 0x66, 0xC0, 0xFF, 0x5D, 0x80, 0x06,
  0x08, 0x30, 0x61, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x00, 0x38,
  0xF9, 0xB7, 0x7C, 0xF9, 0xB3, 0x66, 0xCD, 0xBB, 0xE3, 0x80, 0x1B, 0xBD,
  0x63, 0x19, 0xCC, 0x63, 0x18, 0xC0, 0x1C, 0x3E, 0x77, 0x67, 0x06, 0x0E,
  0x0C, 0x18, 0x30, 0x70, 0xFE, 0xFE, 0x1C, 0x3E, 0x77, 0x07, 0x06, 0x1E,
  0x1C, 0x06, 0x06, 0xEE, 0x7C, 0x78, 0x07, 0x0E, 0x0E, 0x1E, 0x36, 0x3E,
  0x6E, 0xFE, 0xFE, 0x0C, 0x0C, 0x1C, 0x3F, 0x3F, 0x30, 0x30, 0x7C, 0x7E,
  0x06, 0x06, 0x06, 0xEE, 0x7C, 0x38, 0x1C, 0xF7, 0x18, 0xDB, 0xFC, 0xF3,
  0xCF, 0x7F, 0x9C, 0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xC3,
  0x86, 0x00, 0x1E, 0x3E, 0x37, 0x37, 0x36, 0x3E, 0x3C, 0x66, 0xE6, 0xEE,
  0x7C, 0x38, 0x38, 0xF9, 0xB7, 0x7C, 0xF9, 0xBF, 0x3E, 0x1C, 0x71, 0xC7,
  0x00, 0x27, 0x30, 0x00, 0x4E, 0x60, 0x11, 0xC6, 0x00, 0x00, 0x06, 0x33,
  0x18, 0x80, 0x02, 0x18, 0xF3, 0x8E, 0x0F, 0x07, 0x02, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x40, 0xE0, 0xF0, 0x71, 0xCF, 0x38, 0x40, 0x7B, 0xFC, 0xC3,
  0x1C, 0xE7, 0x18, 0x01, 0x0E, 0x18, 0x07, 0x83, 0x98, 0x41, 0x9B, 0x96,
  0xDA, 0xD2, 0x56, 0x4E, 0xD9, 0xDB, 0x7B, 0x6B, 0x36, 0x60, 0x04, 0x00,
  0xEC, 0x0F, 0x80, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0xFC, 0x6E, 0x73,
  0x3F, 0xBF, 0xDC, 0x7C, 0x30, 0x3E, 0x1F, 0x8C, 0xEE, 0x77, 0x33, 0xF9,
  0xF8, 0xCE, 0x67, 0x73, 0xBF, 0x9F, 0x80, 0x1C, 0x7E, 0x67, 0xE3, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC6, 0xCE, 0xFC, 0x78, 0x3E, 0x1F, 0x8C, 0xCE, 0x67,
  0x33, 0x19, 0x8C, 0xC6, 0x67, 0x73, 0x3F, 0x9F, 0x00, 0x3F, 0x3F, 0x30,
  0x70, 0x70, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xFE, 0xFE, 0x3F, 0x3F, 0x30,
  0x70, 0x70, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x1E, 0x7E, 0x67,
  0xE3, 0xE0, 0xCF, 0xCF, 0xC6, 0xC6, 0xC6, 0xFE, 0x7C, 0x31, 0xCC, 0x73,
  0x19, 0xC6, 0x71, 0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x38, 0xCE, 0x33, 0x8C,
  0x31, 0x8C, 0x67, 0x39, 0x8C, 0x63, 0x39, 0xC0, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0xCE, 0xEC, 0x7C, 0x78, 0x31, 0xCC, 0xE3, 0x71,
  0xD8, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x39, 0x8E, 0x63, 0x9C, 0x30,
  0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0xFF, 0xE0, 0x38, 0x73,
  0x8F, 0x38, 0xF7, 0x8F, 0x69, 0xE6, 0x9E, 0x6B, 0x66, 0xF6, 0x6E, 0xEE,
  0xEE, 0xEE, 0xCE, 0xCC, 0x31, 0xCE, 0x73, 0x99, 0xE6, 0x79, 0x9F, 0x66,
  0xF9, 0xBE, 0x67, 0x39, 0xCE, 0x73, 0x9C, 0x1C, 0x7E, 0x67, 0xE3, 0xC3,
  0xC3, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x3E, 0x1F, 0x8C, 0xEE, 0x77,
  0x3B, 0x19, 0xFC, 0xFC, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x1C, 0x7E, 0x67,
  0xE3, 0xC3, 0xC3, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x7C, 0x0E, 0x04, 0x3E,
  0x1F, 0x8C, 0xEE, 0x77, 0x33, 0x19, 0xFC, 0xF8, 0x6E, 0x77, 0x39, 0x9C,
  0xE0, 0x1E, 0x1F, 0x8C, 0xCE, 0x73, 0x01, 0xE0, 0x78, 0x0E, 0xE7, 0x73,
  0x1F, 0x87, 0x80, 0xFF, 0xFF, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x31, 0x98, 0xCC, 0xEE, 0x77, 0x3B, 0x19, 0x8C, 0xC6,
  0x63, 0x33, 0x9F, 0x87, 0x80, 0xE3, 0xF1, 0xB9, 0xCC, 0xE6, 0x63, 0x71,
  0xB0, 0xD8, 0x7C, 0x3C, 0x1E, 0x0E, 0x00, 0xE6, 0x7D, 0xCF, 0xBB, 0xF7,
  0x6F, 0xED, 0xFF, 0xBF, 0xE7, 0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x73, 0x80,
  0x39, 0xC3, 0x38, 0x66, 0x0F, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3F,
  0x07, 0x61, 0xCC, 0x39, 0xC0, 0xE3, 0x33, 0x99, 0x8D, 0xC6, 0xC1, 0xE0,
  0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x3F, 0xBF, 0xC1, 0xC0, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x3F, 0x9F, 0xC0, 0x39, 0xCC, 0x67,
  0x39, 0x8C, 0x63, 0x39, 0xCE, 0x63, 0x9C, 0xEE, 0x66, 0x66, 0x67, 0x77,
  0x33, 0x30, 0x1C, 0xE1, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x71,
  0xCE, 0x38, 0x18, 0x63, 0x8B, 0x6D, 0xB0, 0xFF, 0xF0, 0xCC, 0x3C, 0xFD,
  0xB8, 0x77, 0xDD, 0xB3, 0x7E, 0x6C, 0x30, 0x60, 0xC3, 0xE7, 0xEC, 0xD9,
  0xB3, 0x67, 0xDF, 0xF6, 0xE0, 0x3C, 0xFD, 0x9B, 0x0E, 0x1C, 0x3B, 0x3E,
  0x78, 0x03, 0x03, 0x07, 0x3F, 0x7E, 0x66, 0x66, 0xE6, 0xEE, 0xEE, 0x7C,
  0x7C, 0x3C, 0xFD, 0x9B, 0xFF, 0xFC, 0x39, 0x3E, 0x3C, 0x1C, 0xF3, 0x1E,
  0x78, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0x3B, 0x7F, 0x66, 0x66, 0xE6, 0xE6,
  0xEE, 0x7E, 0x7C, 0x0C, 0xFC, 0xF8, 0x30, 0x60, 0xC3, 0xE7, 0xEC, 0xD9,
  0xB3, 0xEF, 0xDF, 0x36, 0x60, 0x33, 0x07, 0x76, 0x66, 0x6E, 0xEC, 0x0C,
  0x30, 0x07, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x33, 0xCE, 0x00, 0x30,
  0x30, 0x30, 0x77, 0x7E, 0x6C, 0x78, 0x78, 0x7C, 0xEC, 0xCC, 0xCE, 0x33,
  0x37, 0x76, 0x66, 0x6E, 0xEC, 0x7F, 0xCF, 0xFD, 0x99, 0xB3, 0x76, 0xEF,
  0xDD, 0xBB, 0x36, 0x66, 0xCC, 0xC0, 0x6C, 0xFD, 0x9B, 0x36, 0x7D, 0xFB,
  0xE6, 0xCC, 0x3C, 0xFD, 0x9B, 0x3E, 0x7C, 0xFB, 0xBE, 0x38, 0x36, 0x3F,
  0x33, 0x33, 0x33, 0x73, 0x77, 0x7E, 0x6E, 0x60, 0x60, 0xE0, 0x3F, 0x7E,
  0x66, 0x66, 0xE6, 0xEE, 0xEE, 0x7C, 0x7C, 0x0C, 0x0C, 0x1C, 0x7D, 0xE7,
  0x18, 0x63, 0x8E, 0x30, 0xC0, 0x3C, 0xFD, 0xBB, 0x83, 0x83, 0xB3, 0x7E,
  0x78, 0x66, 0xFF, 0xEE, 0xCC, 0xCE, 0xE0, 0x77, 0x66, 0x66, 0x66, 0x66,
  0xEE, 0xEE, 0x7C, 0x7C, 0xCD, 0x9B, 0x76, 0xCD, 0x9E, 0x3C, 0x38, 0x60,
  0xC9, 0xED, 0xF6, 0xDF, 0x6F, 0xF7, 0x73, 0xB9, 0xDC, 0xCC, 0x00, 0x33,
  0x3F, 0x1E, 0x1E, 0x1C, 0x3C, 0x3E, 0x76, 0x66, 0x66, 0x66, 0x6E, 0x6C,
  0x7C, 0x78, 0x78, 0x30, 0x30, 0x60, 0xE0, 0xC0, 0x7E, 0xFC, 0x30, 0xC3,
  0x8E, 0x18, 0x7E, 0xFC, 0x08, 0xCC, 0x63, 0x18, 0xDC, 0xC3, 0x18, 0xC6,
  0x31, 0x84, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0xCC, 0x10, 0xC6, 0x31,
  0x8C, 0x63, 0x31, 0x8C, 0x66, 0x31, 0x00, 0x67, 0xEE, 0x74, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 5, 1, -12 },
  { 12, 8, 12, 8, 0, -12 },
  { 24, 8, 16, 8, 0, -14 },
  { 40, 8, 12, 10, 1, -12 },
  { 52, 8, 12, 9, 0, -12 },
  { 64, 2, 4, 2, 1, -12 },
  { 65, 5, 17, 5, 1, -13 },
  { 76, 5, 17, 5, -1, -13 },
  { 87, 7, 7, 7, 1, -12 },
  { 94, 7, 8, 7, 0, -9 },
  { 101, 4, 5, 4, -1, -2 },
  { 104, 4, 2, 6, 1, -6 },
  { 105, 3, 3, 5, 0, -3 },
  { 107, 7, 13, 5, -1, -12 },
  { 119, 7, 12, 8, 1, -12 },
  { 130, 5, 12, 8, 2, -12 },
  { 138, 8, 12, 8, 0, -12 },
  { 150, 8, 12, 8, 0, -12 },
  { 162, 8, 12, 8, 0, -12 },
  { 174, 8, 12, 8, 0, -12 },
  { 186, 6, 12, 8, 1, -12 },
  { 195, 7, 12, 8, 1, -12 },
  { 206, 8, 12, 8, 0, -12 },
  { 218, 7, 12, 8, 1, -12 },
  { 229, 4, 9, 4, 0, -9 },
  { 234, 5, 12, 4, -1, -9 },
  { 242, 7, 8, 7, 0, -9 },
  { 249, 6, 6, 8, 1, -8 },
  { 254, 7, 8, 7, 0, -9 },
  { 261, 6, 12, 7, 1, -12 },
  { 270, 11, 15, 12, 0, -11 },
  { 291, 9, 12, 9, -1, -12 },
  { 305, 9, 12, 9, 0, -12 },
  { 319, 8, 12, 9, 1, -12 },
  { 331, 9, 12, 9, 0, -12 },
  { 345, 8, 12, 8, 0, -12 },
  { 357, 8, 12, 7, 0, -12 },
  { 369, 8, 12, 9, 1, -12 },
  { 381, 10, 12, 10, 0, -12 },
  { 396, 5, 12, 4, 0, -12 },
  { 404, 8, 12, 8, 0, -12 },
  { 416, 10, 12, 9, 0, -12 },
  { 431, 7, 12, 7, 0, -12 },
  { 442, 12, 12, 12, 0, -12 },
  { 460, 10, 12, 9, 0, -12 },
  { 475, 8, 12, 9, 1, -12 },
  { 487, 9, 12, 9, 0, -12 },
  { 501, 8, 14, 9, 1, -12 },
  { 515, 9, 12, 9, 0, -12 },
  { 529, 9, 12, 8, 0, -12 },
  { 543, 8, 12, 9, 1, -12 },
  { 555, 9, 12, 9, 0, -12 },
  { 569, 9, 12, 9, 1, -12 },
  { 583, 11, 12, 12, 1, -12 },
  { 600, 11, 12, 9, -1, -12 },
  { 617, 9, 12, 9, 1, -12 },
  { 631, 9, 12, 8, 0, -12 },
  { 645, 5, 16, 4, 0, -13 },
  { 655, 4, 13, 6, 1, -12 },
  { 662, 6, 16, 4, -1, -13 },
  { 674, 6, 6, 6, 0, -12 },
  { 679, 6, 2, 6, -1, 0 },
  { 681, 3, 2, 5, 2, -12 },
  { 682, 7, 9, 7, 0, -9 },
  { 690, 7, 12, 8, 0, -12 },
  { 701, 7, 9, 7, 0, -9 },
  { 709, 8, 12, 8, 0, -12 },
  { 721, 7, 9, 7, 0, -9 },
  { 729, 6, 12, 5, 0, -12 },
  { 738, 8, 12, 8, 0, -9 },
  { 750, 7, 12, 8, 0, -12 },
  { 761, 4, 12, 4, 0, -12 },
  { 767, 6, 15, 4, -2, -12 },
  { 779, 8, 12, 8, 0, -12 },
  { 791, 4, 12, 4, 0, -12 },
  { 797, 11, 9, 11, 0, -9 },
  { 810, 7, 9, 8, 0, -9 },
  { 818, 7, 9, 8, 0, -9 },
  { 826, 8, 12, 8, -1, -9 },
  { 838, 8, 12, 8, 0, -9 },
  { 850, 6, 9, 5, 0, -9 },
  { 857, 7, 9, 7, 0, -9 },
  { 865, 4, 11, 5, 1, -11 },
  { 871, 8, 9, 8, 0, -9 },
  { 880, 7, 9, 7, 1, -9 },
  { 888, 9, 9, 10, 1, -9 },
  { 899, 8, 9, 7, -1, -9 },
  { 908, 8, 12, 7, 0, -9 },
  { 920, 7, 9, 7, 0, -9 },
  { 928, 5, 16, 5, 0, -13 },
  { 938, 4, 14, 4, 0, -12 },
  { 945, 5, 15, 5, -1, -12 },
  { 955, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC16PT7B_H_
