#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC53PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x3E, 0x3F,
  0x3E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8,
  0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3C, 0x7C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x0F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF8,
  0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE7,
  0xE0, 0xE3, 0xE1, 0xF0, 0x79, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x7E, 0x7C,
  0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0xBE, 0x0F, 0x8F, 0x9F, 0x07,
  0xCF, 0xDF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0x80, 0x7F, 0xEF, 0x80,
  0x0F, 0xEF, 0x80, 0x01, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xEF, 0xF0, 0x03, 0xEF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xF7, 0xFF, 0x81, 0xF7, 0xE7, 0xC0, 0xFB, 0xE1, 0xE0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C,
  0x3E, 0x1F, 0x7E, 0x1F, 0x0F, 0x9E, 0x07, 0xCF, 0xC2, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x3F,
  0xFE, 0x1F, 0x87, 0xFF, 0xE3, 0xF1, 0xFF, 0xFC, 0xFE, 0x7F, 0xBF, 0xDF,
  0xCF, 0xE7, 0xFB, 0xFB, 0xFC, 0x7F, 0xFE, 0x7F, 0x8F, 0xFF, 0xCF, 0xF0,
  0xFF, 0xF1, 0xFE, 0x1F, 0xFE, 0x3F, 0xC1, 0xFF, 0x87, 0xF8, 0x3F, 0xF0,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x06, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x02, 0x03, 0xC0, 0xDF, 0x0F, 0x1F, 0x7F, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0x9F, 0x00, 0xFE, 0x7C, 0x03, 0xF0, 0xF8,
  0x1F, 0x83, 0xE0, 0x3C, 0x0F, 0xC0, 0x60, 0x1C, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7C, 0x01, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x9F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x1C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFD,
  0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE,
  0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0xC0,
  0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F,
  0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF1, 0xFC,
  0xC1, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFB, 0xFC, 0x03, 0xF3, 0xFC, 0x03, 0xF3, 0xF8, 0x07,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F,
  0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xF8, 0x7F, 0x80, 0x18, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE1,
  0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x3E, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFB, 0xFF, 0x7F,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFB,
  0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF1, 0xFE, 0x07, 0xFB, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC,
  0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xF8,
  0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xDF, 0xE0, 0xFF,
  0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F,
  0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE3, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xBF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFE,
  0x03, 0xE0, 0x04, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0x7F, 0x87, 0xFB, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0x07, 0xC0, 0xFF, 0xF8, 0x78,
  0x7E, 0x0F, 0xFF, 0xC3, 0xC3, 0xE0, 0xFF, 0xFE, 0x1F, 0x1F, 0x07, 0xE3,
  0xF0, 0xF9, 0xF8, 0x7E, 0x1F, 0x07, 0xCF, 0x83, 0xE0, 0xF8, 0x3E, 0x7C,
  0x3F, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x7E, 0x0F, 0x3E, 0x1F, 0x83, 0xF0,
  0x79, 0xF0, 0xFC, 0x1F, 0x03, 0xDF, 0x87, 0xE0, 0xF8, 0x3E, 0xF8, 0x3E,
  0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x7E, 0x0F, 0xBE, 0x1F, 0x83, 0xE0, 0x79,
  0xF0, 0xFC, 0x1F, 0x03, 0xCF, 0x87, 0xE0, 0xF8, 0x3E, 0x7C, 0x3F, 0x0F,
  0xC1, 0xE3, 0xE1, 0xF8, 0x7E, 0x1F, 0x1F, 0x0F, 0xC7, 0xE0, 0xF0, 0xF8,
  0x7F, 0x7F, 0x8F, 0x87, 0xC1, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF,
  0x81, 0xF0, 0x7F, 0xCF, 0xF8, 0x0F, 0x81, 0xFC, 0x3F, 0x80, 0x7C, 0x01,
  0x00, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F,
  0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xFE, 0x7F,
  0x83, 0xFF, 0xE7, 0xF8, 0x3F, 0xFC, 0xFF, 0x87, 0xFF, 0xCF, 0xF0, 0x7F,
  0xFC, 0xFF, 0x07, 0xFF, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF,
  0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xF9, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xEF, 0xC1, 0xFB, 0xF8, 0x0F, 0xEF, 0xC3, 0xFB, 0xF8, 0x1F, 0xEF, 0xC3,
  0xF7, 0xF8, 0x1F, 0xEF, 0xC3, 0xF7, 0xF8, 0x1F, 0xEF, 0xC7, 0xE7, 0xF8,
  0x1F, 0xE7, 0xC7, 0xE7, 0xF0, 0x1F, 0xC7, 0xCF, 0xCF, 0xF0, 0x3F, 0xC7,
  0xCF, 0xCF, 0xF0, 0x3F, 0xC7, 0xCF, 0xCF, 0xF0, 0x3F, 0xC7, 0xDF, 0x8F,
  0xF0, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x3F, 0xC7, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC7, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFE,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0x01, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0x1F, 0xE0, 0x3F,
  0xDF, 0x0F, 0xF0, 0x1F, 0xEF, 0x87, 0xF8, 0x0F, 0xF7, 0xC3, 0xFC, 0x07,
  0xFB, 0xF1, 0xFE, 0x07, 0xF8, 0xF9, 0xFE, 0x03, 0xFC, 0x7C, 0xFF, 0x01,
  0xFE, 0x3E, 0x7F, 0x80, 0xFF, 0x1F, 0xBF, 0xC0, 0x7F, 0x8F, 0xDF, 0xE0,
  0x7F, 0xC3, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0xF8,
  0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0xFE, 0x03, 0xFC, 0x0F, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3,
  0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x7F,
  0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x81, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xF8,
  0x1F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFF, 0x3F, 0x83, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x83, 0xFC, 0x7F, 0x0F, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFF, 0x0F, 0xF0, 0xFE, 0x3F,
  0xF8, 0xFF, 0x07, 0xF1, 0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xFE, 0x3F, 0xC1,
  0xFC, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0xFC,
  0xFF, 0x03, 0xFB, 0xFF, 0xE7, 0xF0, 0x1F, 0xDF, 0xFF, 0x7F, 0x80, 0xFE,
  0xFD, 0xFB, 0xFC, 0x07, 0xFF, 0xEF, 0xDF, 0xC0, 0x3F, 0xFF, 0x7F, 0xFE,
  0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFC,
  0xFF, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF7, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F,
  0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x7E, 0x7E,
  0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xBF,
  0x03, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFE, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x8F, 0xF1, 0xFE,
  0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFE, 0x7F, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF7,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFE, 0xFF, 0xF0, 0xFE, 0x7F, 0xE0, 0xFE, 0x3F, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F,
  0x83, 0xFD, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xFC,
  0x3F, 0xCF, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x81, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC,
  0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC3, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x0F,
  0xE7, 0xF8, 0x1F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x18, 0x1F, 0xE0, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xC7, 0xF0, 0x3F, 0xFB, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x21, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x30, 0x0F, 0xF0, 0x0F, 0x0F, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0xF0,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x05, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xE1, 0xFF, 0x83,
  0xFC, 0x7F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xE3, 0xFE, 0x01, 0xFC, 0xFF,
  0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x83, 0xF8, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF1, 0xFE,
  0x0F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFE,
  0x0F, 0xE3, 0xFC, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xE3, 0xF8,
  0x3F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xC1, 0xFC,
  0x7F, 0x83, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x07, 0xF8,
  0xFF, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x0F,
  0xEF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F,
  0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFB,
  0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x1F,
  0xE3, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xE0, 0x3F, 0xCF, 0xE0, 0x0F, 0xE0, 0x40,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x03, 0xFC, 0x7F, 0x07, 0xFE, 0x7F, 0x0F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0,
  0x01, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC7, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC3, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x10,
  0x00, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xEF,
  0xF0, 0x03, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F,
  0xBF, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xC1,
  0xFF, 0xFC, 0x1F, 0x83, 0xFB, 0xF8, 0x3F, 0x0F, 0xF7, 0xF0, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0x3F, 0x9F, 0xC7, 0xF8, 0x7F, 0x3F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x7F, 0xC7, 0xF1, 0xFC, 0xFF, 0x9F, 0xC3,
  0xFB, 0xFF, 0x3F, 0x87, 0xF7, 0xFE, 0x7F, 0x0F, 0xEF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF,
  0xF7, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x01, 0x00, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0x1F, 0xF8, 0x1F, 0x3F,
  0xFC, 0x3F, 0x7F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7F, 0xFE, 0xFC,
  0x3F, 0xFE, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0x00,
  0x03, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 39, 14, 1, -38 },
  { 70, 16, 14, 16, 3, -40 },
  { 98, 26, 38, 27, 1, -38 },
  { 222, 25, 50, 26, 1, -44 },
  { 379, 25, 40, 33, 5, -39 },
  { 504, 27, 40, 30, 1, -39 },
  { 639, 8, 15, 8, 3, -40 },
  { 654, 17, 54, 17, 2, -42 },
  { 769, 17, 54, 17, -2, -42 },
  { 884, 22, 23, 24, 3, -38 },
  { 948, 23, 27, 24, 1, -31 },
  { 1026, 12, 16, 13, -3, -6 },
  { 1050, 14, 6, 20, 3, -19 },
  { 1061, 9, 9, 15, 1, -8 },
  { 1072, 24, 41, 16, -4, -38 },
  { 1195, 23, 40, 26, 2, -39 },
  { 1310, 16, 38, 26, 6, -38 },
  { 1386, 25, 39, 26, 0, -39 },
  { 1508, 24, 40, 26, 1, -39 },
  { 1628, 24, 38, 26, 1, -38 },
  { 1742, 25, 39, 26, 1, -38 },
  { 1864, 22, 39, 26, 2, -38 },
  { 1972, 25, 38, 26, 2, -38 },
  { 2091, 24, 40, 26, 1, -39 },
  { 2211, 22, 39, 26, 3, -39 },
  { 2319, 13, 30, 15, 1, -29 },
  { 2368, 15, 39, 14, -2, -29 },
  { 2442, 21, 26, 23, 1, -29 },
  { 2511, 23, 17, 26, 2, -25 },
  { 2560, 21, 25, 23, 1, -28 },
  { 2626, 21, 40, 23, 3, -39 },
  { 2731, 37, 49, 39, 1, -37 },
  { 2958, 30, 38, 31, -2, -38 },
  { 3101, 28, 38, 29, 0, -38 },
  { 3234, 28, 40, 29, 2, -39 },
  { 3374, 28, 38, 29, 0, -38 },
  { 3507, 28, 38, 25, 0, -38 },
  { 3640, 27, 38, 24, 0, -38 },
  { 3769, 28, 40, 30, 2, -39 },
  { 3909, 33, 38, 31, 0, -38 },
  { 4066, 15, 38, 14, 0, -38 },
  { 4138, 26, 39, 25, 0, -38 },
  { 4265, 33, 38, 29, 0, -38 },
  { 4422, 22, 38, 25, 0, -38 },
  { 4527, 40, 38, 39, 0, -38 },
  { 4717, 33, 38, 31, 0, -38 },
  { 4874, 28, 40, 31, 2, -39 },
  { 5014, 29, 38, 29, 0, -38 },
  { 5152, 28, 46, 31, 2, -39 },
  { 5313, 29, 38, 29, 0, -38 },
  { 5451, 27, 40, 28, 1, -39 },
  { 5586, 27, 38, 28, 4, -38 },
  { 5715, 29, 39, 30, 2, -38 },
  { 5857, 29, 38, 30, 4, -38 },
  { 5995, 37, 38, 38, 4, -38 },
  { 6171, 34, 38, 29, -2, -38 },
  { 6333, 28, 38, 28, 4, -38 },
  { 6466, 31, 38, 27, -1, -38 },
  { 6614, 18, 53, 14, -1, -44 },
  { 6734, 13, 41, 20, 4, -38 },
  { 6801, 18, 53, 14, -3, -44 },
  { 6921, 18, 19, 20, 2, -38 },
  { 6964, 20, 6, 20, -3, 0 },
  { 6979, 12, 8, 17, 5, -40 },
  { 6991, 23, 30, 24, 0, -29 },
  { 7078, 24, 41, 25, 0, -40 },
  { 7201, 22, 30, 24, 1, -29 },
  { 7284, 26, 41, 25, 1, -40 },
  { 7418, 23, 30, 25, 1, -29 },
  { 7505, 19, 41, 17, 1, -41 },
  { 7603, 26, 40, 26, 0, -29 },
  { 7733, 25, 40, 25, -1, -40 },
  { 7858, 14, 39, 13, 0, -39 },
  { 7927, 20, 50, 13, -6, -39 },
  { 8052, 27, 40, 25, 0, -40 },
  { 8187, 15, 40, 13, 0, -40 },
  { 8262, 36, 29, 38, 0, -29 },
  { 8393, 24, 29, 25, 0, -29 },
  { 8480, 23, 30, 25, 1, -29 },
  { 8567, 26, 40, 25, -2, -29 },
  { 8697, 24, 40, 25, 1, -29 },
  { 8817, 19, 29, 17, 0, -29 },
  { 8886, 22, 30, 23, 0, -29 },
  { 8969, 15, 36, 16, 2, -35 },
  { 9037, 24, 29, 25, 1, -28 },
  { 9124, 22, 28, 23, 3, -28 },
  { 9201, 31, 28, 32, 3, -28 },
  { 9310, 27, 28, 23, -2, -28 },
  { 9405, 26, 39, 23, -1, -28 },
  { 9532, 24, 28, 23, -1, -28 },
  { 9616, 16, 50, 15, 1, -41 },
  { 9716, 11, 45, 13, 1, -38 },
  { 9778, 16, 50, 15, -2, -41 },
  { 9878, 24, 12, 28, 2, -22 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC53PT7B_H_
