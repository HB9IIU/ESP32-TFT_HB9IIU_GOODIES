#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC48PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x78, 0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x79,
  0xF0, 0x00, 0xF9, 0xE0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC7,
  0x80, 0x03, 0xC7, 0x80, 0x07, 0xCF, 0x80, 0x07, 0x8F, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x3E,
  0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xCF, 0x83, 0x0F, 0x0F, 0x0F, 0xBE, 0x1E,
  0x1E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xC3, 0xE3, 0xEF,
  0x07, 0xCF, 0xBE, 0x07, 0xFF, 0xF8, 0x0F, 0xFD, 0xE0, 0x0F, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x0F, 0xBF, 0xC0, 0x1E, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF7, 0xCF, 0x83,
  0xDF, 0x1F, 0x0F, 0xBE, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0xF0, 0xF9, 0xE1,
  0xE1, 0xF7, 0xC3, 0xE3, 0xC7, 0x07, 0xCF, 0x84, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0x1F, 0xFE, 0x3F, 0x3F, 0xFE, 0x3F, 0x7F, 0xFF, 0x7E, 0x7F, 0x7F,
  0x7E, 0xFE, 0x3F, 0xFE, 0xFE, 0x3F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F,
  0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFC, 0x07, 0xF1,
  0xFE, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F,
  0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x10, 0x1E, 0x00, 0xE1, 0xE1, 0xCF,
  0xCF, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF3, 0xC0, 0x3F,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x38, 0x1C, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x06, 0x00, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x07,
  0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7E, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x7C, 0x03, 0xF8, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFD, 0xE3, 0xF2, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0x9F, 0xC0, 0x7E, 0xFE,
  0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xC3, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0x8F, 0xF0, 0x0E, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xF8,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFB,
  0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xE7, 0xE1, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x1F, 0xC7, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0x8F, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFF, 0x0F, 0xE7, 0xFB, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xDF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0x01, 0xF8,
  0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x07, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0xF0, 0x00, 0x00,
  0x60, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x08, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7,
  0xF7, 0xF8, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x78, 0x07, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x83, 0xE0,
  0x3F, 0x03, 0xE1, 0xF0, 0x7F, 0xE0, 0xF1, 0xF0, 0x7F, 0xF8, 0x78, 0xF8,
  0x7F, 0xFC, 0x3C, 0xF8, 0x3F, 0x3E, 0x1E, 0x7C, 0x3F, 0x1F, 0x0F, 0x3C,
  0x3F, 0x0F, 0x87, 0xBE, 0x1F, 0x07, 0x83, 0xDF, 0x0F, 0x87, 0xC1, 0xEF,
  0x0F, 0x83, 0xE0, 0xFF, 0x87, 0xC1, 0xF0, 0xFF, 0xC3, 0xE0, 0xF0, 0x7B,
  0xE3, 0xF0, 0xF8, 0x3D, 0xF1, 0xF8, 0x7C, 0x1E, 0xF0, 0xF8, 0x3E, 0x1F,
  0x78, 0x7C, 0x3E, 0x0F, 0x3C, 0x3E, 0x1F, 0x07, 0x9E, 0x1F, 0x0F, 0x87,
  0x8F, 0x0F, 0xCF, 0xC7, 0xC7, 0x83, 0xFF, 0xFF, 0xC3, 0xC1, 0xFE, 0xFF,
  0xC1, 0xE0, 0x7F, 0x3F, 0xC0, 0xF0, 0x1E, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x3F, 0xC3,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x07,
  0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x7F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F,
  0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xFF, 0x7F, 0x87,
  0xFF, 0xBF, 0xC3, 0xFF, 0xDF, 0xC1, 0xFF, 0xEF, 0xE0, 0xFF, 0xE7, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x7F,
  0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x03,
  0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03,
  0xFF, 0xC0, 0xFD, 0xF0, 0x7F, 0xFC, 0x1F, 0xDF, 0x07, 0xDF, 0xC1, 0xFD,
  0xF0, 0xFD, 0xFC, 0x1F, 0xDF, 0x0F, 0xDF, 0x81, 0xFD, 0xF0, 0xFB, 0xF8,
  0x1F, 0xDF, 0x1F, 0xBF, 0x81, 0xFD, 0xF9, 0xF3, 0xF8, 0x3F, 0x8F, 0xBF,
  0x3F, 0x83, 0xF8, 0xFB, 0xE7, 0xF8, 0x3F, 0x8F, 0xFE, 0x7F, 0x03, 0xF8,
  0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xFC, 0x7F, 0x07, 0xF8, 0xFF, 0xC7, 0xF0,
  0x7F, 0x8F, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0xE0, 0x7C, 0x1F, 0xE0,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0xFE, 0x0F,
  0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF8,
  0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x3F,
  0x83, 0xFF, 0xC3, 0xFC, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0xFE, 0x07,
  0xF7, 0x87, 0xF0, 0x7F, 0xBE, 0x3F, 0x83, 0xFD, 0xF3, 0xFC, 0x1F, 0xCF,
  0x9F, 0xE0, 0xFE, 0x7C, 0xFE, 0x07, 0xF1, 0xF7, 0xF0, 0x3F, 0x8F, 0xBF,
  0x83, 0xFC, 0x7D, 0xFC, 0x1F, 0xC3, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x07,
  0xF0, 0x7F, 0xF0, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x1F, 0xFC, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFE, 0x03, 0xFF, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0x80, 0xFF,
  0x81, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0xFF, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7,
  0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0x81, 0xFC, 0x1F, 0xDF, 0xC1, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0x87, 0xF3, 0xF8, 0x7F,
  0xC3, 0xF9, 0xFC, 0x3F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xF8, 0xFE, 0x3F, 0x8F, 0xFC, 0x7F, 0x1F, 0xC7, 0xFE, 0x7F, 0x0F, 0xE7,
  0xFF, 0x3F, 0x87, 0xF3, 0xFF, 0x9F, 0xC3, 0xF9, 0xFF, 0xDF, 0xC1, 0xFD,
  0xFF, 0xEF, 0xE0, 0xFE, 0xFF, 0xF7, 0xF0, 0x7F, 0x7F, 0xFB, 0xF0, 0x3F,
  0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFC, 0x07,
  0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xE1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFD,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F,
  0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFE, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xCF, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0x7F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xDF, 0xC0, 0xF9, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFB, 0xFF, 0x0F, 0xEF, 0xF8, 0x3F, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0x87, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF1, 0xFC,
  0x07, 0xF9, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0x9F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0x87, 0xF3, 0xF8, 0x3F, 0x7F,
  0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0x07, 0xF0, 0x70, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x07, 0xFC, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x02, 0x01, 0xFC, 0x06, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF9, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xC0,
  0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE1, 0xFF, 0x0F, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xE7,
  0xFC, 0x1F, 0xCF, 0xF8, 0x1F, 0xCF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE7, 0xC0, 0xF8, 0x07, 0xFF,
  0xF9, 0xFF, 0x03, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x87, 0xF1,
  0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE,
  0x7F, 0x07, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xF3, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC7, 0xC0, 0x7E, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFD, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0x7E,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x83, 0xF9, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xBF, 0xE0, 0x3F, 0x8F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0xFC, 0x1F, 0xE7, 0xF0, 0xFF, 0xDF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xEF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x0F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xF1,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xFE, 0x07, 0xF7, 0xF8,
  0x3F, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF,
  0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x07, 0xEF, 0xC3, 0xF0, 0xFE,
  0xFC, 0x3F, 0x0F, 0xEF, 0xC3, 0xF0, 0xFC, 0xFC, 0x7F, 0x1F, 0xCF, 0xC7,
  0xF1, 0xFC, 0xFC, 0x7F, 0x1F, 0x8F, 0xCF, 0xF1, 0xF8, 0xFC, 0xFF, 0x3F,
  0x8F, 0xDF, 0xF3, 0xF0, 0xFD, 0xFF, 0x3F, 0x0F, 0xDF, 0xF7, 0xF0, 0xFF,
  0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x03, 0xF9, 0xFC,
  0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x01, 0xFB, 0xF8, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xEF, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0,
  0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xFC, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x20, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xDF, 0xFC, 0x3F, 0x7F,
  0xF8, 0xFB, 0xFF, 0xFF, 0xEF, 0xC7, 0xFF, 0xBE, 0x1F, 0xFC, 0xF8, 0x3F,
  0xF3, 0xE0, 0x7F, 0x80, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 34, 12, 1, -34 },
  { 57, 15, 13, 15, 2, -36 },
  { 82, 24, 34, 24, 1, -34 },
  { 184, 22, 44, 24, 1, -39 },
  { 305, 23, 34, 30, 4, -34 },
  { 403, 24, 34, 27, 1, -34 },
  { 505, 7, 13, 7, 3, -36 },
  { 517, 15, 49, 15, 2, -38 },
  { 609, 15, 49, 15, -2, -38 },
  { 701, 21, 21, 21, 2, -34 },
  { 757, 20, 24, 22, 1, -28 },
  { 817, 11, 15, 12, -3, -6 },
  { 838, 12, 6, 18, 3, -18 },
  { 847, 8, 8, 14, 1, -8 },
  { 855, 21, 37, 15, -3, -34 },
  { 953, 21, 34, 24, 2, -34 },
  { 1043, 15, 34, 24, 5, -34 },
  { 1107, 23, 34, 24, 0, -34 },
  { 1205, 23, 34, 24, 0, -34 },
  { 1303, 22, 34, 24, 1, -34 },
  { 1397, 23, 34, 24, 1, -34 },
  { 1495, 20, 34, 24, 2, -34 },
  { 1580, 23, 34, 24, 2, -34 },
  { 1678, 22, 34, 24, 1, -34 },
  { 1772, 20, 34, 24, 3, -34 },
  { 1857, 11, 27, 13, 1, -27 },
  { 1895, 14, 36, 13, -2, -27 },
  { 1958, 19, 23, 21, 1, -26 },
  { 2013, 20, 16, 24, 2, -23 },
  { 2053, 19, 23, 21, 1, -26 },
  { 2108, 19, 34, 21, 3, -34 },
  { 2189, 33, 44, 36, 1, -33 },
  { 2371, 27, 34, 28, -2, -34 },
  { 2486, 26, 34, 26, 0, -34 },
  { 2597, 25, 34, 27, 2, -34 },
  { 2704, 26, 34, 26, 0, -34 },
  { 2815, 25, 34, 23, 0, -34 },
  { 2922, 25, 34, 22, 0, -34 },
  { 3029, 25, 34, 27, 2, -34 },
  { 3136, 30, 34, 28, 0, -34 },
  { 3264, 14, 34, 13, 0, -34 },
  { 3324, 24, 34, 23, 0, -34 },
  { 3426, 30, 34, 26, 0, -34 },
  { 3554, 20, 34, 22, 0, -34 },
  { 3639, 36, 34, 35, 0, -34 },
  { 3792, 29, 34, 28, 0, -34 },
  { 3916, 25, 34, 28, 2, -34 },
  { 4023, 27, 34, 27, 0, -34 },
  { 4138, 25, 40, 28, 2, -34 },
  { 4263, 26, 34, 26, 0, -34 },
  { 4374, 25, 34, 25, 1, -34 },
  { 4481, 24, 34, 26, 4, -34 },
  { 4583, 27, 34, 27, 1, -34 },
  { 4698, 26, 34, 27, 4, -34 },
  { 4809, 33, 34, 35, 4, -34 },
  { 4950, 31, 34, 26, -2, -34 },
  { 5082, 25, 34, 26, 4, -34 },
  { 5189, 28, 34, 25, -1, -34 },
  { 5308, 17, 48, 12, -1, -40 },
  { 5410, 12, 37, 18, 4, -34 },
  { 5466, 17, 48, 12, -3, -40 },
  { 5568, 17, 17, 18, 1, -34 },
  { 5605, 19, 6, 19, -3, 0 },
  { 5620, 11, 7, 16, 5, -36 },
  { 5630, 20, 26, 22, 0, -26 },
  { 5695, 22, 36, 23, 0, -36 },
  { 5794, 20, 26, 21, 1, -26 },
  { 5859, 24, 36, 23, 1, -36 },
  { 5967, 20, 26, 22, 1, -26 },
  { 6032, 18, 36, 15, 1, -36 },
  { 6113, 23, 36, 24, 0, -26 },
  { 6217, 21, 36, 23, 0, -36 },
  { 6312, 13, 36, 12, 0, -36 },
  { 6371, 18, 46, 12, -5, -36 },
  { 6475, 24, 36, 23, 0, -36 },
  { 6583, 13, 36, 12, 0, -36 },
  { 6642, 33, 26, 34, 0, -26 },
  { 6750, 21, 26, 23, 0, -26 },
  { 6819, 21, 26, 23, 1, -26 },
  { 6888, 24, 36, 23, -2, -26 },
  { 6996, 22, 36, 23, 1, -26 },
  { 7095, 17, 26, 16, 0, -26 },
  { 7151, 20, 26, 21, 0, -26 },
  { 7216, 13, 32, 14, 2, -32 },
  { 7268, 22, 26, 23, 1, -26 },
  { 7340, 21, 26, 21, 2, -26 },
  { 7409, 28, 26, 29, 3, -26 },
  { 7500, 24, 26, 21, -2, -26 },
  { 7578, 24, 36, 21, -1, -26 },
  { 7686, 22, 26, 21, -1, -26 },
  { 7758, 15, 45, 14, 1, -37 },
  { 7843, 10, 40, 12, 1, -34 },
  { 7893, 15, 46, 14, -2, -37 },
  { 7980, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC48PT7B_H_
