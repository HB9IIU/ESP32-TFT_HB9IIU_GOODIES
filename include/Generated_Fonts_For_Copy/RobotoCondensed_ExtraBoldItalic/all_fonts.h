#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_ExtraBoldItalic
// Headers: 67

#include "RobotoCondensed_ExtraBoldItalic6pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic7pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic8pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic9pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic10pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic11pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic12pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic13pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic14pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic15pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic16pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic17pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic18pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic19pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic20pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic21pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic22pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic23pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic24pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic25pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic26pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic27pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic28pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic29pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic30pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic31pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic32pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic33pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic34pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic35pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic36pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic37pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic38pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic39pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic40pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic41pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic42pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic43pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic44pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic45pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic46pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic47pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic48pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic49pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic50pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic51pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic52pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic53pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic54pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic55pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic56pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic57pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic58pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic59pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic60pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic61pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic62pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic63pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic64pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic65pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic66pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic67pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic68pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic69pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic70pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic71pt7b.h"
#include "RobotoCondensed_ExtraBoldItalic72pt7b.h"
