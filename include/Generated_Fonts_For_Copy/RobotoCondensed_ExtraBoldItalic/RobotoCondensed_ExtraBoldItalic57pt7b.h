#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC57PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x9F, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0xFC, 0x04, 0x1F, 0x0F,
  0x81, 0xE7, 0xE1, 0xF0, 0x7E, 0xFC, 0x3E, 0x0F, 0x9F, 0x87, 0xC3, 0xE3,
  0xE0, 0xF8, 0xFC, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xE7, 0xC1, 0xF8, 0xFD,
  0xF8, 0x3F, 0x3F, 0x7E, 0x03, 0xFF, 0xEF, 0x80, 0x7F, 0xFB, 0xF0, 0x07,
  0xFE, 0xFC, 0x00, 0x7F, 0x9F, 0x00, 0x01, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0xFF, 0x00, 0x1F, 0xBF, 0xF0, 0x07, 0xEF, 0xFF, 0x00, 0xFB, 0xFF,
  0xE0, 0x3E, 0x7E, 0xFC, 0x0F, 0xDF, 0x8F, 0xC1, 0xF3, 0xF1, 0xF8, 0x7C,
  0x7C, 0x3F, 0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0xF8, 0x3E, 0x1F,
  0xBF, 0x07, 0xC3, 0xE7, 0xC0, 0xF8, 0xFC, 0x70, 0x1F, 0xBF, 0x82, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F,
  0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x0F, 0xE3, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xFF,
  0xFF, 0x3F, 0x9F, 0xF7, 0xF9, 0xFC, 0xFF, 0x3F, 0xFF, 0xEF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xC7, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0x9F, 0xE0, 0xFF, 0xF8,
  0xFF, 0x03, 0xFF, 0xC7, 0xF8, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xE0, 0x3F, 0xF0, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8, 0x00, 0x01,
  0x00, 0x03, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x1E, 0x00, 0x38, 0x1E,
  0x07, 0x7E, 0x3E, 0x3F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xEF, 0x80, 0x1F, 0xCF, 0x80, 0x3F, 0x8F,
  0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01,
  0x80, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0x00, 0x04, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F,
  0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xE0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF9, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xE3, 0xFC, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF3,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8,
  0x3F, 0xE3, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xF7, 0xFC, 0x01, 0xFD, 0xFE, 0x00,
  0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFE,
  0x07, 0xF8, 0xFF, 0x81, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE7,
  0xE0, 0x3F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x87, 0xFC, 0x7F, 0xCF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF,
  0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7,
  0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF,
  0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x83, 0xF9, 0xFE,
  0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xF0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07,
  0xF8, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0xFF,
  0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0xF0, 0x3E, 0x0F, 0xC0,
  0xFF, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x3E, 0x1F, 0x81, 0xFF, 0xFC,
  0x1E, 0x1F, 0x83, 0xF8, 0xFC, 0x1E, 0x3F, 0x07, 0xF0, 0xFC, 0x1E, 0x3F,
  0x07, 0xE0, 0xF8, 0x1E, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x7E, 0x1F, 0xC1, 0xF8, 0x3E, 0x7E, 0x1F, 0x81, 0xF0, 0x3E,
  0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0xFC, 0x3F, 0x83, 0xF0, 0x3E, 0xFC, 0x3F,
  0x83, 0xF0, 0x3C, 0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0xFC, 0x3F, 0x03, 0xE0,
  0x7C, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x1F,
  0xC1, 0xF0, 0xF8, 0x3F, 0xFF, 0xE3, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x1F, 0xFB, 0xFF, 0xC0, 0xF8, 0x1F, 0xF3, 0xFF, 0x80, 0xFC, 0x0F,
  0xE1, 0xFE, 0x00, 0xFC, 0x01, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02,
  0x00, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F,
  0xE3, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x07,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0xE7, 0xFC, 0x1F, 0xFF, 0x9F, 0xE0,
  0x7F, 0xFE, 0x7F, 0x81, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0xCF, 0xF8, 0x3F,
  0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8,
  0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x0F, 0xF3, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFC,
  0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF,
  0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x7F, 0xFF, 0x01, 0xFE, 0xFC, 0x0F,
  0xDF, 0xE0, 0x3F, 0xDF, 0x83, 0xFB, 0xFC, 0x07, 0xFB, 0xF0, 0x7F, 0x7F,
  0x80, 0xFF, 0x7E, 0x1F, 0xDF, 0xF0, 0x3F, 0xEF, 0xE3, 0xFB, 0xFC, 0x07,
  0xF9, 0xFC, 0x7E, 0x7F, 0x80, 0xFF, 0x1F, 0x9F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xF3, 0xF1, 0xFE, 0x03, 0xFC, 0x7E, 0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xDF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFB, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xFE, 0x3F,
  0xC0, 0x7F, 0xC7, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0xF1, 0xFF, 0x01,
  0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x80,
  0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xF8,
  0x0F, 0xF0, 0x1F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xC0,
  0x7F, 0xFF, 0x07, 0xF8, 0x0F, 0xFB, 0xE0, 0xFF, 0x01, 0xFF, 0x7E, 0x3F,
  0xE0, 0x3F, 0xEF, 0xC7, 0xFC, 0x07, 0xF9, 0xF8, 0xFF, 0x80, 0xFF, 0x1F,
  0x1F, 0xE0, 0x3F, 0xE3, 0xF3, 0xFC, 0x07, 0xFC, 0x7E, 0x7F, 0x80, 0xFF,
  0x8F, 0xDF, 0xF0, 0x1F, 0xE0, 0xFB, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xFE, 0x03, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x01, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F,
  0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x1F, 0xF0,
  0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x07,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x1F,
  0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x80,
  0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x0F,
  0xF7, 0xF8, 0x1F, 0xF0, 0x3F, 0xEF, 0xF0, 0x3F, 0xE0, 0x7F, 0xDF, 0xE0,
  0x7F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFF, 0x83, 0xFE, 0x7F, 0x83, 0xFF, 0x07,
  0xFC, 0xFF, 0x07, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xFC, 0x1F, 0xE3, 0xFC,
  0x3F, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1,
  0xFE, 0x1F, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x7F,
  0x8F, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0xF9, 0xFE, 0x07, 0xFB, 0xFF, 0xF3, 0xFC, 0x0F,
  0xF7, 0xFF, 0xEF, 0xF0, 0x1F, 0xEF, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0x9F,
  0xBF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0xFF, 0xE3,
  0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00,
  0x7F, 0xC7, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x03, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3,
  0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7,
  0xE0, 0xFC, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF1, 0xF8, 0x3F, 0x7F, 0x07,
  0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x83,
  0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xE3, 0xFC, 0x01, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF,
  0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0x80,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0xFF,
  0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xF3, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xF8, 0x3F, 0xCF, 0xFC, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFE,
  0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xF1, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x20, 0x7F, 0x80, 0x60, 0x7F, 0xF3, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFA, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xF9, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xCF, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0x83, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x04, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x38, 0x0F, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F,
  0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x1F, 0xFC, 0x1F, 0xE1, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC0, 0x7F, 0x8F, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7,
  0xFC, 0x00, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xF0,
  0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x1F,
  0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFC, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFC,
  0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0xFF,
  0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7,
  0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFD,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x7F,
  0xBF, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F,
  0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF3, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFC, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xDF,
  0xFE, 0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x08, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x3F, 0xF3,
  0xFC, 0x1F, 0xFE, 0xFF, 0x0F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE7,
  0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFE, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F,
  0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x04, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x40, 0x7F, 0xBF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0x00, 0x0F,
  0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFF,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x81,
  0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xF1,
  0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC3, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x03,
  0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0x9F,
  0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0xBF,
  0xC0, 0x7F, 0xBF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x3F, 0xDF, 0xE1,
  0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x0F, 0xF7, 0xF8, 0xFF, 0x87, 0xF3, 0xFC,
  0x7F, 0xC7, 0xF9, 0xFE, 0x3F, 0xE3, 0xFC, 0xFF, 0x3F, 0xF1, 0xFC, 0x7F,
  0x9F, 0xF9, 0xFE, 0x3F, 0xCF, 0xFC, 0xFE, 0x1F, 0xEF, 0xFE, 0x7F, 0x07,
  0xF7, 0xFF, 0x7F, 0x83, 0xFF, 0xEF, 0xBF, 0x81, 0xFF, 0xF7, 0xDF, 0xC0,
  0xFD, 0xFB, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0,
  0x1F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0,
  0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF,
  0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFB, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xF1, 0xFF, 0xC0, 0xFC,
  0xFF, 0xF8, 0x3F, 0x3F, 0xFE, 0x0F, 0xDF, 0xFF, 0xC7, 0xF7, 0xFF, 0xFF,
  0xF9, 0xF8, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0,
  0x7F, 0xE3, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 42, 15, 1, -41 },
  { 80, 17, 16, 18, 3, -43 },
  { 114, 28, 41, 29, 1, -41 },
  { 258, 26, 54, 28, 2, -48 },
  { 434, 27, 43, 35, 5, -42 },
  { 580, 29, 43, 32, 1, -42 },
  { 736, 9, 16, 9, 3, -43 },
  { 754, 17, 58, 18, 3, -45 },
  { 878, 18, 58, 18, -2, -45 },
  { 1009, 24, 25, 25, 3, -41 },
  { 1084, 24, 30, 26, 1, -34 },
  { 1174, 12, 18, 14, -3, -7 },
  { 1201, 15, 7, 22, 3, -21 },
  { 1215, 10, 10, 16, 1, -9 },
  { 1228, 25, 44, 18, -4, -41 },
  { 1366, 25, 43, 28, 2, -42 },
  { 1501, 18, 41, 28, 6, -41 },
  { 1594, 27, 42, 28, 0, -42 },
  { 1736, 26, 43, 28, 1, -42 },
  { 1876, 26, 41, 28, 1, -41 },
  { 2010, 27, 42, 28, 1, -41 },
  { 2152, 24, 42, 28, 2, -41 },
  { 2278, 28, 41, 28, 2, -41 },
  { 2422, 26, 43, 28, 1, -42 },
  { 2562, 23, 42, 28, 4, -42 },
  { 2683, 14, 33, 16, 1, -32 },
  { 2741, 17, 43, 15, -3, -32 },
  { 2833, 23, 27, 25, 1, -31 },
  { 2911, 24, 19, 28, 2, -27 },
  { 2968, 23, 28, 25, 1, -31 },
  { 3049, 22, 43, 25, 4, -42 },
  { 3168, 40, 52, 42, 1, -39 },
  { 3428, 33, 41, 33, -3, -41 },
  { 3598, 31, 41, 31, 0, -41 },
  { 3757, 30, 43, 32, 2, -42 },
  { 3919, 30, 41, 31, 0, -41 },
  { 4073, 30, 41, 27, 0, -41 },
  { 4227, 29, 41, 26, 0, -41 },
  { 4376, 30, 43, 33, 2, -42 },
  { 4538, 35, 41, 34, 0, -41 },
  { 4718, 16, 41, 15, 0, -41 },
  { 4800, 28, 42, 27, 0, -41 },
  { 4947, 35, 41, 31, 0, -41 },
  { 5127, 23, 41, 26, 0, -41 },
  { 5245, 43, 41, 42, 0, -41 },
  { 5466, 35, 41, 34, 0, -41 },
  { 5646, 31, 43, 33, 2, -42 },
  { 5813, 32, 41, 32, 0, -41 },
  { 5977, 31, 49, 33, 2, -42 },
  { 6167, 31, 41, 31, 0, -41 },
  { 6326, 29, 43, 30, 1, -42 },
  { 6482, 29, 41, 30, 4, -41 },
  { 6631, 31, 42, 32, 2, -41 },
  { 6794, 32, 41, 32, 4, -41 },
  { 6958, 39, 41, 41, 5, -41 },
  { 7158, 36, 41, 31, -2, -41 },
  { 7343, 29, 41, 30, 5, -41 },
  { 7492, 33, 41, 29, -1, -41 },
  { 7662, 19, 57, 15, -1, -47 },
  { 7798, 15, 44, 21, 4, -41 },
  { 7881, 20, 57, 15, -3, -47 },
  { 8024, 19, 20, 22, 2, -41 },
  { 8072, 23, 7, 22, -4, 0 },
  { 8093, 12, 9, 19, 6, -43 },
  { 8107, 24, 32, 26, 0, -31 },
  { 8203, 26, 44, 27, 0, -43 },
  { 8346, 24, 32, 25, 1, -31 },
  { 8442, 28, 44, 27, 1, -43 },
  { 8596, 24, 32, 27, 1, -31 },
  { 8692, 21, 44, 18, 1, -44 },
  { 8808, 29, 43, 28, -1, -31 },
  { 8964, 26, 43, 27, -1, -43 },
  { 9104, 15, 42, 14, 0, -42 },
  { 9183, 21, 54, 14, -6, -42 },
  { 9325, 29, 43, 27, 0, -43 },
  { 9481, 16, 43, 14, 0, -43 },
  { 9567, 39, 31, 41, 0, -31 },
  { 9719, 26, 31, 27, -1, -31 },
  { 9820, 25, 32, 27, 1, -31 },
  { 9920, 28, 43, 27, -2, -31 },
  { 10071, 26, 43, 27, 1, -31 },
  { 10211, 20, 31, 19, 0, -31 },
  { 10289, 24, 32, 25, 0, -31 },
  { 10385, 16, 39, 17, 2, -38 },
  { 10463, 26, 31, 27, 1, -30 },
  { 10564, 24, 30, 25, 3, -30 },
  { 10654, 33, 30, 35, 3, -30 },
  { 10778, 29, 30, 25, -2, -30 },
  { 10887, 28, 42, 25, -1, -30 },
  { 11034, 26, 30, 25, -1, -30 },
  { 11132, 17, 55, 16, 1, -45 },
  { 11249, 12, 49, 14, 1, -41 },
  { 11323, 17, 54, 16, -2, -44 },
  { 11438, 26, 13, 30, 2, -23 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC57PT7B_H_
