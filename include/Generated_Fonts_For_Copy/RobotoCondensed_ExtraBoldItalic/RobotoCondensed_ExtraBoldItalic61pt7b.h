#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC61PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x08, 0x00, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF8, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x41, 0xFC, 0x7C,
  0x07, 0x0F, 0xC3, 0xF0, 0x7E, 0x7E, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x3F,
  0x3F, 0x07, 0xE3, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x9F, 0x81, 0xF0, 0xFD, 0xF8, 0x0F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFE,
  0xFC, 0x01, 0xFF, 0xEF, 0xC0, 0x07, 0xFE, 0x7C, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x10, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x1F,
  0xBF, 0xF8, 0x01, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFD, 0xFF,
  0xFC, 0x0F, 0xDF, 0xC7, 0xE0, 0x7C, 0xFC, 0x3F, 0x07, 0xE7, 0xE1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xF3, 0xF0,
  0x7C, 0x1F, 0xBF, 0x03, 0xF0, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0x80, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x3F, 0xFF, 0xC3,
  0xF8, 0xFF, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0xDF, 0xE7, 0xFC, 0xFF, 0xBF,
  0xCF, 0xF9, 0xFF, 0xFF, 0x3F, 0xE1, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFC,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0x87,
  0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E,
  0x3F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x3E,
  0x02, 0x3C, 0x1F, 0x07, 0x9F, 0xC7, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xF0, 0xFC, 0x07, 0xF8,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x03,
  0xE0, 0x06, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8,
  0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF9,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F,
  0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF3, 0xFC, 0xE0, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0x8F, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xFE, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xE7, 0xFE,
  0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xE0,
  0x7F, 0xE7, 0xF8, 0x1F, 0xF1, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0,
  0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x0F, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xBF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0x80, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x04, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFF, 0xC0, 0x7C, 0x1F, 0x80,
  0xFF, 0xF8, 0x1F, 0x0F, 0xC0, 0x7F, 0xFF, 0x87, 0xC3, 0xF0, 0x3F, 0xFF,
  0xC1, 0xF1, 0xF8, 0x1F, 0xF3, 0xF0, 0x7C, 0x7E, 0x07, 0xF0, 0xFC, 0x1F,
  0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xCF, 0xC0, 0xFC, 0x1F, 0x81, 0xF3, 0xF0,
  0x7F, 0x07, 0xE0, 0x7C, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x7E, 0x0F, 0xE0,
  0x7E, 0x07, 0xDF, 0x83, 0xF8, 0x3F, 0x81, 0xF7, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFD, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xBF,
  0x07, 0xF0, 0x3F, 0x03, 0xEF, 0xC1, 0xF8, 0x1F, 0x80, 0xFB, 0xF0, 0x7E,
  0x07, 0xE0, 0x7C, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x3F, 0x07, 0xE0, 0xFE,
  0x07, 0xCF, 0xC1, 0xF8, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x1F, 0xC0, 0xF8,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFC,
  0xFF, 0xE0, 0x3F, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x3F,
  0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFC, 0x7F,
  0xC1, 0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0x8F,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF, 0x00, 0xFF, 0xFF, 0x01,
  0xFE, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F,
  0xEF, 0xE0, 0x7F, 0x7F, 0x80, 0xFF, 0xBF, 0x83, 0xFF, 0xFE, 0x03, 0xFE,
  0xFE, 0x0F, 0xEF, 0xF8, 0x0F, 0xFB, 0xF8, 0x7F, 0xBF, 0xE0, 0x3F, 0xEF,
  0xE1, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x87, 0xF7, 0xFC, 0x07, 0xFC, 0xFE,
  0x3F, 0x9F, 0xF0, 0x1F, 0xF1, 0xF8, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xE7,
  0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0x9F, 0xC7, 0xFC, 0x07, 0xFC, 0x7E, 0x7F,
  0x3F, 0xE0, 0x1F, 0xF1, 0xFB, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xEF, 0xE3,
  0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x87, 0xFC,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xE0,
  0x7F, 0xEF, 0xC3, 0xFE, 0x03, 0xFF, 0x7E, 0x1F, 0xF0, 0x1F, 0xF3, 0xF0,
  0xFF, 0x80, 0xFF, 0x9F, 0xC7, 0xFC, 0x07, 0xFC, 0x7E, 0x7F, 0xE0, 0x3F,
  0xE3, 0xF3, 0xFF, 0x03, 0xFF, 0x1F, 0x9F, 0xF0, 0x1F, 0xF8, 0xFE, 0xFF,
  0x80, 0xFF, 0x83, 0xF7, 0xFC, 0x07, 0xFC, 0x1F, 0xBF, 0xE0, 0x3F, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x7F,
  0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE,
  0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xCF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0xFF,
  0x83, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0x3F, 0xE7,
  0xFF, 0xE3, 0xFC, 0x0F, 0xF9, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xFE,
  0x7F, 0xC0, 0xFF, 0xBF, 0xFF, 0x9F, 0xE0, 0x3F, 0xEF, 0xFF, 0xEF, 0xF8,
  0x0F, 0xFB, 0xFB, 0xFB, 0xFE, 0x03, 0xFF, 0xFE, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x07, 0xFF, 0xF3,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x03, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07,
  0xE7, 0xF0, 0x3F, 0xFF, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC7, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xF1, 0xFF, 0x87, 0xFC,
  0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x7F, 0xEF, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF3, 0xFF, 0xE0, 0xFF, 0x3F, 0xFC, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F,
  0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x83,
  0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x00, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF3,
  0xFE, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x18,
  0x1F, 0xF8, 0x1E, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0xCF, 0xF0, 0x07, 0xFF,
  0xDF, 0xE0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x61, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0x80, 0x3F, 0xF0, 0x03, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x00, 0x7C,
  0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFE,
  0x0F, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x7F,
  0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x20, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07,
  0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F,
  0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8, 0x1F, 0xE3, 0xFE,
  0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFD,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0,
  0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8,
  0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xF0,
  0x0F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00,
  0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x03,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x03, 0xFF, 0x8F, 0xF0, 0x7F, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF3, 0xFC, 0x00, 0x08, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF9, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0x80, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF,
  0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0xBF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xF8, 0x1F, 0xF7, 0xF8, 0x3F, 0x81,
  0xFE, 0x7F, 0x83, 0xF8, 0x3F, 0xE7, 0xF8, 0x7F, 0x83, 0xFE, 0x7F, 0x87,
  0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x8F, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0x9F, 0xF8, 0x7F, 0x87, 0xF1, 0xFF, 0xCF,
  0xF0, 0x7F, 0x1F, 0xFC, 0xFF, 0x07, 0xF3, 0xFF, 0xCF, 0xF0, 0x7F, 0x3F,
  0xFD, 0xFE, 0x07, 0xF3, 0xFF, 0xDF, 0xE0, 0x7F, 0x7F, 0xFD, 0xFE, 0x07,
  0xF7, 0xEF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0x01, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFE,
  0x1F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE3, 0xFF, 0x00, 0x7F, 0x8F,
  0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xBF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0x0F, 0xFE, 0x03,
  0xF1, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x07, 0xF3, 0xFF, 0xF8, 0x7F, 0x7F,
  0xFF, 0xCF, 0xE7, 0xFB, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xE7, 0xE0, 0xFF,
  0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xF8, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 44, 16, 1, -43 },
  { 89, 19, 17, 19, 3, -46 },
  { 130, 30, 43, 31, 1, -43 },
  { 292, 28, 57, 30, 2, -50 },
  { 492, 29, 45, 38, 5, -44 },
  { 656, 31, 45, 35, 1, -44 },
  { 831, 9, 17, 9, 3, -46 },
  { 851, 19, 61, 19, 3, -48 },
  { 996, 20, 62, 19, -3, -48 },
  { 1151, 26, 27, 27, 3, -43 },
  { 1239, 26, 31, 28, 1, -35 },
  { 1340, 13, 19, 15, -3, -7 },
  { 1371, 16, 7, 23, 4, -22 },
  { 1385, 10, 10, 18, 1, -9 },
  { 1398, 27, 47, 19, -4, -43 },
  { 1557, 27, 45, 30, 2, -44 },
  { 1709, 18, 43, 30, 7, -43 },
  { 1806, 29, 44, 30, 0, -44 },
  { 1966, 28, 45, 30, 1, -44 },
  { 2124, 28, 43, 30, 1, -43 },
  { 2275, 29, 44, 30, 1, -43 },
  { 2435, 26, 44, 30, 2, -43 },
  { 2578, 30, 43, 30, 2, -43 },
  { 2740, 28, 45, 30, 1, -44 },
  { 2898, 25, 44, 30, 4, -44 },
  { 3036, 15, 34, 17, 1, -33 },
  { 3100, 18, 45, 16, -3, -33 },
  { 3202, 25, 29, 26, 1, -33 },
  { 3293, 26, 20, 30, 2, -29 },
  { 3358, 25, 29, 27, 1, -33 },
  { 3449, 23, 45, 27, 4, -44 },
  { 3579, 42, 56, 45, 1, -42 },
  { 3873, 35, 43, 36, -3, -43 },
  { 4062, 33, 43, 33, 0, -43 },
  { 4240, 32, 45, 34, 2, -44 },
  { 4420, 32, 43, 33, 0, -43 },
  { 4592, 32, 43, 29, 0, -43 },
  { 4764, 31, 43, 28, 0, -43 },
  { 4931, 32, 45, 35, 2, -44 },
  { 5111, 38, 43, 36, 0, -43 },
  { 5316, 17, 43, 16, 0, -43 },
  { 5408, 30, 44, 29, 0, -43 },
  { 5573, 38, 43, 33, 0, -43 },
  { 5778, 25, 43, 28, 0, -43 },
  { 5913, 46, 43, 45, 0, -43 },
  { 6161, 37, 43, 36, 0, -43 },
  { 6360, 33, 45, 36, 2, -44 },
  { 6546, 34, 43, 34, 0, -43 },
  { 6729, 33, 52, 36, 2, -44 },
  { 6944, 33, 43, 33, 0, -43 },
  { 7122, 32, 45, 32, 1, -44 },
  { 7302, 31, 43, 33, 4, -43 },
  { 7469, 33, 44, 34, 2, -43 },
  { 7651, 33, 43, 34, 5, -43 },
  { 7829, 42, 43, 44, 5, -43 },
  { 8055, 38, 43, 33, -2, -43 },
  { 8260, 32, 43, 32, 5, -43 },
  { 8432, 35, 43, 31, -1, -43 },
  { 8621, 21, 61, 16, -1, -51 },
  { 8782, 15, 47, 23, 5, -43 },
  { 8871, 21, 61, 16, -3, -51 },
  { 9032, 21, 22, 23, 2, -43 },
  { 9090, 24, 7, 24, -4, 0 },
  { 9111, 14, 9, 20, 6, -45 },
  { 9127, 26, 34, 28, 0, -33 },
  { 9238, 28, 47, 29, 0, -46 },
  { 9403, 25, 34, 27, 1, -33 },
  { 9510, 30, 47, 29, 1, -46 },
  { 9687, 26, 34, 28, 1, -33 },
  { 9798, 23, 47, 20, 1, -47 },
  { 9934, 31, 45, 30, -1, -33 },
  { 10109, 28, 46, 29, -1, -46 },
  { 10270, 16, 45, 15, 0, -45 },
  { 10360, 23, 57, 15, -7, -45 },
  { 10524, 31, 46, 29, 0, -46 },
  { 10703, 17, 46, 15, 0, -46 },
  { 10801, 41, 33, 44, 0, -33 },
  { 10971, 28, 33, 29, -1, -33 },
  { 11087, 27, 34, 29, 1, -33 },
  { 11202, 30, 45, 29, -2, -33 },
  { 11371, 28, 45, 29, 1, -33 },
  { 11529, 21, 33, 20, 0, -33 },
  { 11616, 26, 34, 27, 0, -33 },
  { 11727, 18, 41, 18, 2, -40 },
  { 11820, 28, 33, 29, 1, -32 },
  { 11936, 26, 32, 27, 3, -32 },
  { 12040, 36, 32, 37, 3, -32 },
  { 12184, 31, 32, 27, -2, -32 },
  { 12308, 30, 44, 27, -1, -32 },
  { 12473, 28, 32, 27, -1, -32 },
  { 12585, 19, 59, 18, 1, -48 },
  { 12726, 13, 51, 15, 1, -43 },
  { 12809, 19, 59, 18, -2, -48 },
  { 12950, 28, 14, 33, 2, -25 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC61PT7B_H_
