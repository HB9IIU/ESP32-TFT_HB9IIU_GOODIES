#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC22PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x8E, 0x31, 0xC0, 0x00, 0x63, 0xCF,
  0x18, 0x6E, 0xDD, 0xB7, 0x6C, 0xD9, 0x80, 0x06, 0x60, 0xD8, 0x1B, 0x03,
  0x60, 0xD8, 0x7F, 0xCF, 0xF8, 0xD8, 0x1B, 0x03, 0x61, 0xFF, 0x7F, 0xC3,
  0x60, 0x4C, 0x1B, 0x03, 0x60, 0x02, 0x00, 0x80, 0xF0, 0xFE, 0x3F, 0x9E,
  0xF7, 0x3D, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1C, 0x07, 0xB9, 0xEE, 0x73,
  0xFC, 0x7E, 0x0F, 0x01, 0x00, 0xC0, 0x78, 0x1F, 0x0C, 0xCF, 0x36, 0xDF,
  0xBE, 0xC7, 0x60, 0x38, 0x0C, 0x06, 0xE3, 0x7C, 0xDB, 0x6C, 0xF3, 0x30,
  0x7C, 0x1E, 0x07, 0x01, 0xF0, 0x7F, 0x0C, 0xE1, 0x9C, 0x37, 0x07, 0xC0,
  0xF0, 0x3E, 0x6F, 0xFD, 0xDF, 0xFB, 0xFF, 0x3C, 0xFF, 0x9F, 0xF1, 0xEF,
  0x66, 0x66, 0xEC, 0x04, 0x1C, 0x70, 0xC3, 0x86, 0x1C, 0x38, 0x61, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0x04, 0x00, 0x10,
  0x30, 0x30, 0x60, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x18, 0x70, 0xC3, 0x8E, 0x10, 0x00, 0x06, 0x03, 0x00, 0xC1, 0xB6,
  0xFF, 0x87, 0x83, 0xC1, 0xD8, 0xE7, 0x00, 0x80, 0x0E, 0x0E, 0x07, 0x03,
  0x8F, 0xFF, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x31, 0x9C, 0xE6,
  0x73, 0x00, 0x7D, 0xFF, 0xC0, 0x07, 0xF7, 0x00, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x00, 0x0F, 0x1F, 0xCF, 0xEE, 0x77, 0x3B, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xEE, 0x77, 0xF9, 0xF8, 0x78, 0x02,
  0x3D, 0xFB, 0xFD, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E,
  0x3C, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xE7, 0x9C, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xFF, 0x3F, 0xE7, 0xFC, 0x0F,
  0x03, 0xF8, 0xFF, 0x1C, 0xE0, 0x1C, 0x03, 0x83, 0xF0, 0x7C, 0x0F, 0x80,
  0x70, 0x0F, 0x71, 0xEF, 0x38, 0xFF, 0x1F, 0xC1, 0xF0, 0x01, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xDC, 0x3B, 0x8E, 0x71, 0xFF,
  0x7F, 0xEF, 0xFC, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0xE3, 0xFC, 0x7F, 0x1C,
  0x03, 0x80, 0x7E, 0x0F, 0xE3, 0xDC, 0x03, 0xC0, 0x38, 0x07, 0x39, 0xE7,
  0x38, 0xFF, 0x0F, 0xC0, 0xF0, 0x07, 0x07, 0x87, 0xC7, 0x87, 0x83, 0xFB,
  0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x77, 0xF9, 0xF8, 0x78, 0x7F,
  0xDF, 0xF7, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0x0F, 0x0F, 0xE3, 0xF9, 0xEF,
  0x73, 0x9C, 0xE3, 0xF8, 0xFC, 0x7F, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F,
  0xCF, 0xE0, 0xF0, 0x0E, 0x1F, 0x8F, 0xEE, 0x77, 0x3B, 0x9F, 0xCE, 0xE7,
  0x7F, 0xBF, 0xCF, 0xC0, 0xE0, 0xE3, 0xF1, 0xF0, 0xE0, 0x00, 0xE3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0x70, 0x00, 0x71, 0xC7, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x8E, 0x31, 0xC7, 0x38, 0x40, 0x00, 0x81, 0xC3, 0xE7,
  0xF7, 0xC3, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0x80, 0x40, 0x7F, 0xBF, 0xDF,
  0xE0, 0x00, 0x07, 0xFB, 0xFD, 0xFE, 0x20, 0x1C, 0x0F, 0x07, 0xE0, 0xF8,
  0x1C, 0x7E, 0xFE, 0x78, 0x30, 0x20, 0x00, 0x1E, 0x3F, 0x9F, 0xFE, 0x70,
  0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x06, 0x31,
  0xE3, 0x33, 0xF3, 0x67, 0x33, 0x66, 0x73, 0x66, 0x66, 0xEE, 0x66, 0xCE,
  0xE6, 0xCE, 0xEC, 0xCF, 0xFC, 0xC7, 0x78, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x1E, 0x70, 0xE3, 0x87, 0xFC, 0x7F,
  0xE3, 0xFF, 0x3C, 0x39, 0xC1, 0xDE, 0x0E, 0x1F, 0xC3, 0xFE, 0x3F, 0xF3,
  0x8F, 0x38, 0xF3, 0x8F, 0x39, 0xE7, 0xFC, 0x7F, 0xC7, 0x1E, 0x70, 0xE7,
  0x1E, 0x71, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x0E, 0xE1, 0xFC, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xEE,
  0x3D, 0xFF, 0x1F, 0xE1, 0xF0, 0x1F, 0x83, 0xFC, 0x3F, 0xE3, 0x8E, 0x38,
  0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71,
  0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0x80, 0x38,
  0x03, 0x80, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x1F, 0xE7, 0xFC, 0xFF, 0x9C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xFE, 0x7F, 0x8F, 0xF1, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0E, 0xE0, 0x3C,
  0x07, 0x80, 0xE7, 0xFC, 0xFF, 0x87, 0x70, 0xEF, 0x1D, 0xFF, 0x9F, 0xE1,
  0xF8, 0x1C, 0x38, 0xF0, 0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xE3,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xC1, 0xC7, 0x0F, 0x1C, 0x3C, 0x70, 0xE3,
  0xC3, 0x8F, 0x0E, 0x38, 0x38, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x79,
  0xE7, 0x1C, 0x71, 0xCF, 0x3C, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x71, 0xCE, 0x79, 0xFE,
  0x1F, 0xC1, 0xE0, 0x1C, 0x78, 0xF3, 0xE3, 0xCF, 0x0E, 0x78, 0x3B, 0xC0,
  0xEE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xB8, 0x1C, 0xE0,
  0x73, 0xC3, 0xCF, 0x0F, 0x1C, 0x38, 0x78, 0x1C, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1,
  0xF1, 0xF8, 0xF8, 0xFC, 0xFC, 0xFC, 0x77, 0x6E, 0x3B, 0xF7, 0x1D, 0xFB,
  0x8E, 0xFB, 0xC7, 0x3D, 0xE7, 0x9C, 0xE3, 0xCE, 0x71, 0xC6, 0x38, 0x1C,
  0x38, 0xF0, 0xE3, 0xE3, 0x8F, 0x8E, 0x3E, 0x78, 0xF9, 0xE3, 0xF7, 0x1E,
  0xDC, 0x7B, 0x71, 0xCD, 0xC7, 0x3F, 0x1C, 0xFC, 0x71, 0xE3, 0xC7, 0x8F,
  0x1E, 0x38, 0x78, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xE7, 0x0E,
  0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCF, 0xF8,
  0x7F, 0x83, 0xE0, 0x1F, 0xC3, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87,
  0x38, 0xF7, 0xFE, 0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xE7, 0x0E,
  0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCF, 0xF8,
  0x7F, 0x83, 0xF0, 0x07, 0x80, 0x38, 0x01, 0x00, 0x1F, 0xC3, 0xFE, 0x3F,
  0xF3, 0x8F, 0x38, 0xF3, 0x8F, 0x38, 0xE7, 0xFE, 0x7F, 0xC7, 0xF8, 0x73,
  0x87, 0x38, 0x73, 0xCF, 0x3C, 0xF1, 0xCE, 0x1C, 0x07, 0xC1, 0xFE, 0x1F,
  0xE3, 0xCF, 0x38, 0xF3, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x01,
  0xCF, 0x1C, 0x71, 0xC7, 0xFC, 0x3F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x38, 0xF7, 0x8F, 0x78, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x71, 0xEF, 0x1E, 0xF1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE3, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0xE0, 0xFE, 0x1E, 0xE1, 0xEE, 0x1C,
  0xE3, 0xCF, 0x38, 0xF3, 0x8F, 0x78, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xE3, 0x8F, 0xCF, 0x3F, 0x9E, 0x77,
  0x3C, 0xEE, 0xFB, 0xDD, 0xF7, 0x3B, 0xEE, 0x77, 0xFC, 0xFF, 0xF1, 0xFF,
  0xE3, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1E, 0x7C, 0x3C, 0xF0, 0x78, 0xE0,
  0x1E, 0x3C, 0x79, 0xE0, 0xE7, 0x83, 0xBC, 0x0E, 0xE0, 0x3F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE0, 0xE7,
  0x87, 0x8E, 0x3C, 0x38, 0xE1, 0xFC, 0x3B, 0xCF, 0x39, 0xC7, 0x78, 0xEE,
  0x1F, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0xFC, 0xFF,
  0xCF, 0xFC, 0x0F, 0x0F, 0x0F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x78, 0x78, 0x78,
  0xE7, 0x39, 0xCE, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x9C, 0xE7, 0x38, 0x1E,
  0x3C, 0x78, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E,
  0x1C, 0x38, 0xF1, 0xC7, 0x8F, 0x1E, 0x00, 0x1C, 0x38, 0xF1, 0xF7, 0x6C,
  0xF9, 0xE3, 0xFF, 0xFF, 0xFF, 0x73, 0x8E, 0x1F, 0x1F, 0xDE, 0xEE, 0x70,
  0x39, 0xFD, 0xFF, 0xEF, 0xE7, 0xFF, 0xBF, 0xCF, 0xE0, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x0F, 0xE3, 0xF9, 0xFF, 0x79, 0xDC, 0x77, 0x1D, 0xC7,
  0x73, 0xFC, 0xEF, 0xFB, 0xFC, 0xEE, 0x00, 0x1F, 0x1F, 0xCF, 0xEE, 0x77,
  0x3B, 0x83, 0xC1, 0xE0, 0xF3, 0xBF, 0x9F, 0xC7, 0xC0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x3B, 0x8F, 0xF3, 0xFE, 0x71, 0xCE, 0x79, 0xCF,
  0x79, 0xCF, 0x39, 0xE7, 0x1F, 0xE3, 0xFC, 0x3B, 0x80, 0x0F, 0x0F, 0xE3,
  0xF9, 0xC7, 0x71, 0xDF, 0xF7, 0xFD, 0xC0, 0x71, 0x1F, 0xC7, 0xF8, 0x78,
  0x0E, 0x3C, 0xF9, 0xC3, 0x9F, 0xBF, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C,
  0x38, 0x70, 0xE0, 0x1E, 0xE7, 0xF9, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0xBC,
  0xF7, 0x9C, 0xF3, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0x70, 0xFE, 0x3F, 0x83,
  0xE0, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xE3, 0xF9, 0xFF, 0x71,
  0xDC, 0xF7, 0x3D, 0xCE, 0x73, 0xBC, 0xEE, 0x3B, 0x8E, 0xE7, 0x80, 0x1C,
  0xF1, 0x80, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0x73, 0xCE, 0x38, 0x07,
  0x0F, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x73, 0xCE, 0xF3, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF1, 0xEE, 0x39, 0xC7, 0x3C, 0xE3, 0x80, 0x1C, 0x73, 0xCE, 0x38, 0xE3,
  0x8E, 0x79, 0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xE0, 0x3F, 0xBC, 0x7F, 0xFC,
  0xFF, 0xFB, 0xDE, 0x77, 0x3C, 0xEE, 0x73, 0xDC, 0xE7, 0xB9, 0xCE, 0xF3,
  0x9D, 0xE7, 0x3B, 0x9E, 0x77, 0x38, 0xE0, 0x3F, 0x8F, 0xE7, 0xFD, 0xC7,
  0x73, 0xDC, 0xF7, 0x39, 0xCE, 0xF3, 0xB8, 0xEE, 0x3B, 0x9E, 0x0F, 0x0F,
  0xE3, 0xFD, 0xC7, 0x71, 0xDC, 0x7F, 0x1F, 0xCF, 0x73, 0x9F, 0xE7, 0xF0,
  0xF8, 0x1F, 0xC3, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF,
  0x79, 0xCF, 0xF9, 0xFE, 0x3B, 0x87, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x1D,
  0xCF, 0xF7, 0xFD, 0xC7, 0x73, 0xDC, 0xFF, 0x3B, 0xCE, 0xF3, 0x9F, 0xE7,
  0xF8, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0x3F, 0x7E, 0x78, 0x70,
  0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0x1F, 0x1F, 0xDE, 0xEE, 0x77,
  0x81, 0xF0, 0x7C, 0x1E, 0xE7, 0x73, 0x9F, 0xC7, 0x80, 0x38, 0xE7, 0xBF,
  0xFD, 0xC7, 0x1C, 0xF3, 0x8E, 0x38, 0xF3, 0xC7, 0x00, 0x39, 0xC7, 0x39,
  0xE7, 0x38, 0xE7, 0x1C, 0xE7, 0x9C, 0xE3, 0x9C, 0x73, 0x8F, 0xF1, 0xFE,
  0x1D, 0xC0, 0xE3, 0xF3, 0xF9, 0xDC, 0xE6, 0xE3, 0x71, 0xF8, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0F, 0x00, 0xE7, 0x3F, 0x3B, 0xBB, 0xDD, 0xDE, 0xEE, 0xF6,
  0x7F, 0xF3, 0xEF, 0x9F, 0x78, 0xFB, 0xC7, 0x9E, 0x3C, 0xE1, 0xC7, 0x00,
  0x3C, 0xE3, 0xB8, 0x77, 0x0F, 0xC1, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x3B,
  0x87, 0x71, 0xCE, 0x39, 0xC0, 0x71, 0xCE, 0x79, 0xCE, 0x39, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x81, 0xE0,
  0x3C, 0x07, 0x00, 0x3F, 0xCF, 0xE7, 0xF8, 0x1C, 0x0F, 0x07, 0x81, 0xC0,
  0xE0, 0x78, 0x3F, 0xCF, 0xF3, 0xFC, 0x02, 0x1C, 0x30, 0xE1, 0xC3, 0x86,
  0x1C, 0x38, 0xF1, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x81,
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x62,
  0x30, 0x18, 0x38, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0xF1,
  0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC7, 0x04, 0x00, 0x38, 0xDE, 0x7F, 0xFB,
  0x3E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 7, 1, -17 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 20, 11, 1, -18 },
  { 66, 10, 16, 14, 2, -16 },
  { 86, 11, 16, 13, 0, -16 },
  { 108, 4, 6, 3, 1, -17 },
  { 111, 7, 22, 7, 1, -17 },
  { 131, 7, 22, 7, -1, -17 },
  { 151, 10, 10, 10, 1, -16 },
  { 164, 9, 11, 10, 1, -13 },
  { 177, 5, 7, 5, -1, -3 },
  { 182, 6, 3, 8, 1, -8 },
  { 185, 4, 4, 6, 0, -4 },
  { 187, 10, 17, 7, -2, -16 },
  { 209, 9, 16, 11, 1, -16 },
  { 227, 7, 16, 11, 2, -16 },
  { 241, 11, 16, 11, 0, -16 },
  { 263, 11, 16, 11, 0, -16 },
  { 285, 11, 16, 11, 0, -16 },
  { 307, 11, 16, 11, 0, -16 },
  { 329, 9, 16, 11, 1, -16 },
  { 347, 10, 16, 11, 1, -16 },
  { 367, 10, 16, 11, 1, -16 },
  { 387, 9, 16, 11, 1, -16 },
  { 405, 6, 13, 6, 0, -13 },
  { 415, 6, 17, 6, -1, -13 },
  { 428, 9, 11, 10, 0, -12 },
  { 441, 9, 8, 11, 1, -11 },
  { 450, 9, 11, 10, 0, -12 },
  { 463, 9, 16, 10, 1, -16 },
  { 481, 16, 20, 16, 0, -15 },
  { 521, 13, 16, 13, -1, -16 },
  { 547, 12, 16, 12, 0, -16 },
  { 571, 11, 16, 12, 1, -16 },
  { 593, 12, 16, 12, 0, -16 },
  { 617, 12, 16, 10, 0, -16 },
  { 641, 11, 16, 10, 0, -16 },
  { 663, 11, 16, 13, 1, -16 },
  { 685, 14, 16, 13, 0, -16 },
  { 713, 6, 16, 6, 0, -16 },
  { 725, 11, 16, 11, 0, -16 },
  { 747, 14, 16, 12, 0, -16 },
  { 775, 9, 16, 10, 0, -16 },
  { 793, 17, 16, 16, 0, -16 },
  { 827, 14, 16, 13, 0, -16 },
  { 855, 12, 16, 13, 1, -16 },
  { 879, 12, 16, 12, 0, -16 },
  { 903, 12, 19, 13, 1, -16 },
  { 932, 12, 16, 12, 0, -16 },
  { 956, 12, 16, 12, 0, -16 },
  { 980, 11, 16, 12, 2, -16 },
  { 1002, 12, 16, 12, 1, -16 },
  { 1026, 12, 16, 12, 2, -16 },
  { 1050, 15, 16, 16, 2, -16 },
  { 1080, 14, 16, 12, -1, -16 },
  { 1108, 11, 16, 12, 2, -16 },
  { 1130, 12, 16, 11, 0, -16 },
  { 1154, 8, 22, 6, -1, -18 },
  { 1176, 5, 17, 8, 2, -16 },
  { 1187, 7, 22, 6, -1, -18 },
  { 1207, 7, 8, 8, 1, -16 },
  { 1214, 8, 3, 8, -1, 0 },
  { 1217, 5, 3, 7, 2, -16 },
  { 1219, 9, 12, 10, 0, -12 },
  { 1233, 10, 17, 11, 0, -17 },
  { 1255, 9, 12, 10, 0, -12 },
  { 1269, 11, 17, 11, 0, -17 },
  { 1293, 10, 12, 10, 0, -12 },
  { 1308, 7, 17, 7, 1, -17 },
  { 1323, 11, 16, 11, 0, -12 },
  { 1345, 10, 17, 11, 0, -17 },
  { 1367, 6, 16, 5, 0, -16 },
  { 1379, 8, 20, 5, -2, -16 },
  { 1399, 11, 17, 10, 0, -17 },
  { 1423, 6, 17, 5, 0, -17 },
  { 1436, 15, 12, 16, 0, -12 },
  { 1459, 10, 12, 11, 0, -12 },
  { 1474, 10, 12, 11, 0, -12 },
  { 1489, 11, 16, 11, -1, -12 },
  { 1511, 10, 16, 11, 0, -12 },
  { 1531, 8, 12, 7, 0, -12 },
  { 1543, 9, 12, 10, 0, -12 },
  { 1557, 6, 15, 7, 1, -15 },
  { 1569, 11, 12, 11, 0, -12 },
  { 1586, 9, 12, 10, 1, -12 },
  { 1600, 13, 12, 13, 1, -12 },
  { 1620, 11, 12, 10, -1, -12 },
  { 1637, 11, 16, 10, 0, -12 },
  { 1659, 10, 12, 10, 0, -12 },
  { 1674, 7, 21, 6, 0, -17 },
  { 1693, 5, 19, 5, 0, -16 },
  { 1705, 7, 21, 6, -1, -17 },
  { 1724, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC22PT7B_H_
