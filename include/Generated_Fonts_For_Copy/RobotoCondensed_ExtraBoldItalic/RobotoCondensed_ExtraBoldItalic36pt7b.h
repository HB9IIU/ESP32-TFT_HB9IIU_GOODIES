#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC36PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x00, 0x79, 0xEF,
  0x3D, 0xE7, 0x38, 0xE7, 0x3D, 0xE7, 0xBC, 0xE7, 0x1C, 0xE3, 0x9C, 0x70,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x79, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x0E, 0x70, 0x07, 0xBC, 0x01, 0xCE, 0x00, 0x73, 0x81, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0xE7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07,
  0x38, 0x03, 0xDE, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC7, 0xC3, 0xF3, 0xE1, 0xF9,
  0xF0, 0xFC, 0xFC, 0x7C, 0x3E, 0x7E, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x78, 0x4F, 0x3C, 0x77, 0x9E, 0x7B, 0xCF,
  0x79, 0xE7, 0xB8, 0xF3, 0xBC, 0x3F, 0xFC, 0x1F, 0xDC, 0x07, 0xDC, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0x7B,
  0xC7, 0xB8, 0xE7, 0x9C, 0x73, 0x9E, 0x3B, 0xCF, 0x3D, 0xC3, 0x9E, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9E, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0xC7, 0xC7, 0xFC, 0xF1, 0xFF, 0x9E, 0x7D, 0xFF, 0xCF, 0x9F,
  0xF9, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC3, 0xF0, 0xFC, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xF9, 0xF8, 0x7B, 0xDE, 0xF7, 0xBB,
  0xDE, 0xF7, 0x00, 0x00, 0x40, 0x18, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x60, 0x04, 0x00, 0x02, 0x00, 0x30, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x04, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x04, 0x1C, 0x2E, 0x33, 0xFF, 0xFF,
  0xBF, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xEF, 0x07, 0xCE, 0x1F,
  0x1E, 0x0C, 0x1C, 0x00, 0x20, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C,
  0x7C, 0x78, 0xF0, 0x20, 0x7F, 0x9F, 0xEF, 0xFB, 0xFE, 0x33, 0xEF, 0xFF,
  0xF9, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0x60, 0x3C, 0x3F, 0xBF, 0xE7, 0xFD, 0xFF, 0xBF, 0xF6, 0x3E, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF0, 0xF9, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xDF,
  0x87, 0xEF, 0xC3, 0xE3, 0xF7, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0xFC, 0xF8, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC1, 0xE3,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x1F, 0x9F,
  0x0F, 0x8F, 0x87, 0xC7, 0xE7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x7F,
  0x81, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7D, 0xE1, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFB, 0xE1, 0xF7, 0xC7, 0xEF, 0xDF, 0x9F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F,
  0xBF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3F, 0x1F, 0x1F, 0x3F, 0x1F,
  0x3E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0x7C, 0x7C,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xF7, 0xCF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xC7, 0xEF, 0x8F, 0x9F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x00, 0x0C, 0x1F, 0x3F, 0x3F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF8,
  0xFC, 0xFC, 0xF8, 0x70, 0x01, 0x80, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x7C, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x7F, 0x07, 0xF8, 0x7F, 0xE7, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x60,
  0x00, 0x80, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0x20, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xF1, 0xFF, 0x9F, 0xFC, 0xFF, 0x83, 0xF8,
  0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFF, 0x7E, 0xFF, 0xF1, 0xFF, 0xC7, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xE0, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xC0,
  0x78, 0x00, 0x38, 0x3C, 0x1F, 0x0E, 0x0E, 0x1F, 0xE3, 0x87, 0x8F, 0xFC,
  0xE1, 0xC7, 0xCF, 0x38, 0xF1, 0xE3, 0x8F, 0x3C, 0xF0, 0xE3, 0xCE, 0x3C,
  0x78, 0xE7, 0x8F, 0x1E, 0x39, 0xE7, 0x87, 0x0E, 0x71, 0xE1, 0xC3, 0x9C,
  0x78, 0xF0, 0xE7, 0x1E, 0x3C, 0x73, 0xC7, 0x8E, 0x1C, 0xF1, 0xE7, 0x87,
  0x3C, 0x79, 0xE3, 0x87, 0x1F, 0xFF, 0xC1, 0xC3, 0xF7, 0xF0, 0x70, 0x70,
  0xF0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC1, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x07, 0xE3, 0xE0,
  0xFC, 0x7C, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xC7, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF3, 0xF0, 0x3E,
  0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF9, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0xFE, 0x3F, 0x0F, 0xCF, 0xC0,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC3, 0xFC, 0xF8, 0x7F, 0x9F, 0x1F, 0xF3, 0xE3, 0xFE, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xE0, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C,
  0x07, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7E,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0,
  0xF8, 0x3F, 0x03, 0xE1, 0xFC, 0x0F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF9,
  0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3,
  0xEF, 0x1E, 0xF8, 0x7D, 0xE3, 0xDF, 0x0F, 0x9C, 0xF3, 0xE1, 0xF3, 0x9E,
  0xFC, 0x3E, 0x7F, 0x9F, 0x0F, 0xCF, 0xF3, 0xE1, 0xF9, 0xFE, 0x7C, 0x3F,
  0x3F, 0x9F, 0x87, 0xC7, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x8F,
  0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0x3C, 0x3E, 0x1F, 0x87, 0x8F, 0xC0, 0x0F,
  0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0,
  0xF8, 0x7F, 0x83, 0xE1, 0xFE, 0x0F, 0x87, 0xFC, 0x7E, 0x1F, 0xF1, 0xF8,
  0x7F, 0xC7, 0xC1, 0xF7, 0x1F, 0x0F, 0xDE, 0x7C, 0x3F, 0x79, 0xF0, 0xFD,
  0xEF, 0xC3, 0xE3, 0xBF, 0x0F, 0x8E, 0xF8, 0x3E, 0x3F, 0xE1, 0xF8, 0xFF,
  0x87, 0xE1, 0xFE, 0x1F, 0x87, 0xF8, 0x7C, 0x1F, 0xE1, 0xF0, 0x7F, 0x07,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E,
  0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xC7, 0xC0,
  0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F,
  0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E,
  0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x03,
  0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C,
  0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x1F, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE7, 0xE0,
  0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xC7, 0xC3, 0xF3, 0xF0, 0x7C,
  0xFC, 0x1F, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xFC, 0x3F, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x07, 0xE3,
  0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0,
  0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x3D, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0xF8, 0x3E, 0x1F, 0xFC, 0x1F, 0x0F, 0xBE, 0x1F,
  0x87, 0xDF, 0x0F, 0xC7, 0xEF, 0x87, 0xE3, 0xE7, 0xC7, 0xF1, 0xF3, 0xE3,
  0xF9, 0xF9, 0xF1, 0xFC, 0xF8, 0xF9, 0xFE, 0x7C, 0x7C, 0xFF, 0x3E, 0x3E,
  0x7F, 0xBE, 0x1F, 0x7F, 0xDF, 0x0F, 0xBD, 0xEF, 0x87, 0xDE, 0xFF, 0xC3,
  0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0x07, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xF7,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E,
  0x3E, 0x0F, 0xC7, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0x81, 0xF3, 0xE0,
  0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x1E, 0xE1, 0xEF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF0,
  0x70, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1E, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0xC7,
  0xC0, 0x0F, 0x83, 0xFF, 0x1F, 0xFE, 0x7F, 0xFD, 0xF9, 0xF7, 0xE3, 0xEF,
  0xC7, 0xDF, 0x0F, 0xBF, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x79,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xBF, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E,
  0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0xBF, 0x0F, 0x7C, 0x1E, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x9F, 0x1F, 0x3E, 0x7E, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0x9F, 0x07, 0xF7, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7E, 0x7E,
  0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xDF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xEF, 0x80, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE7, 0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x02, 0x3F, 0x9C,
  0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0xC1,
  0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF9, 0xFF, 0xC3, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF3, 0xF3, 0xF9, 0xF0, 0xFD, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF9, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xDF, 0x00, 0x0F, 0x80, 0x0F,
  0xC3, 0x8F, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF,
  0x3F, 0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F, 0x7E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x7E, 0xFC, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F,
  0x81, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x82, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x1F,
  0xC7, 0xC7, 0xE1, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xBF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x8F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x80, 0x1F, 0x7C, 0x3C, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0x3F, 0x9F, 0x3E, 0x1F, 0x1F, 0x3E, 0x1F, 0x1F,
  0x3E, 0x3F, 0x1F, 0x3E, 0x3E, 0x1F, 0x7E, 0x3E, 0x1F, 0x7E, 0x3E, 0x1F,
  0x7C, 0x3E, 0x3F, 0x7C, 0x3E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7C, 0x3E,
  0xFC, 0x7C, 0x3E, 0xFC, 0x7C, 0x7E, 0xF8, 0x7C, 0x7E, 0xF8, 0x7C, 0x7C,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xE7, 0xEF,
  0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xDF, 0x0F, 0xBF, 0x3F, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x00, 0x0F, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xF9,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF9, 0xF0, 0xF8, 0xFC, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3E, 0xFE, 0x1F, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x9F,
  0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x78, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xC0,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xDF, 0x0F, 0xBE,
  0x3F, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0xFF, 0x9F, 0xF7, 0xFE, 0xFF, 0xC7, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F,
  0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E,
  0xFC, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFD, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0xF8, 0x7F, 0xF0, 0xFB,
  0xE3, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3E, 0x7C, 0x3C, 0xF8, 0x7B,
  0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFF, 0xC7,
  0x8F, 0xBE, 0x3C, 0x7D, 0xF3, 0xE3, 0xEF, 0x9F, 0x3E, 0x7D, 0xF9, 0xF3,
  0xEF, 0xEF, 0x9F, 0x7F, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xDF,
  0xE1, 0xFE, 0xFF, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x00, 0x1F, 0x8F,
  0xC3, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7C,
  0x1F, 0x1F, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC7, 0xC3, 0xF1, 0xF1, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x3D, 0xF8, 0x0F,
  0x7C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x40, 0x38,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x01, 0x00, 0x0E, 0x1C, 0x38, 0x70,
  0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71,
  0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x04, 0x00, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0x03, 0xE0,
  0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x18, 0x00, 0x0F,
  0x00, 0x1F, 0xC3, 0xDF, 0xF1, 0xEF, 0xFD, 0xF7, 0xFF, 0xF7, 0x8F, 0xFB,
  0xC3, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 10, 11, 2, -27 },
  { 48, 18, 26, 18, 0, -26 },
  { 107, 17, 33, 18, 1, -30 },
  { 178, 17, 26, 22, 3, -26 },
  { 234, 19, 26, 21, 0, -26 },
  { 296, 5, 10, 6, 2, -27 },
  { 303, 11, 36, 11, 2, -28 },
  { 353, 12, 36, 11, -2, -28 },
  { 407, 15, 16, 16, 2, -26 },
  { 437, 15, 19, 16, 1, -22 },
  { 473, 8, 11, 9, -2, -4 },
  { 484, 10, 4, 14, 2, -13 },
  { 489, 6, 6, 10, 1, -6 },
  { 494, 15, 28, 11, -2, -26 },
  { 547, 16, 26, 18, 1, -26 },
  { 599, 11, 26, 18, 4, -26 },
  { 635, 17, 26, 18, 0, -26 },
  { 691, 17, 26, 18, 0, -26 },
  { 747, 16, 26, 18, 1, -26 },
  { 799, 17, 26, 18, 1, -26 },
  { 855, 15, 26, 18, 1, -26 },
  { 904, 18, 26, 18, 1, -26 },
  { 963, 16, 26, 18, 1, -26 },
  { 1015, 15, 26, 18, 2, -26 },
  { 1064, 8, 20, 10, 1, -20 },
  { 1084, 11, 27, 9, -2, -20 },
  { 1122, 14, 18, 16, 1, -20 },
  { 1154, 16, 11, 18, 1, -17 },
  { 1176, 14, 17, 16, 1, -19 },
  { 1206, 14, 26, 16, 2, -26 },
  { 1252, 26, 33, 27, 0, -25 },
  { 1360, 21, 26, 21, -2, -26 },
  { 1429, 19, 26, 20, 0, -26 },
  { 1491, 19, 26, 20, 1, -26 },
  { 1553, 19, 26, 20, 0, -26 },
  { 1615, 19, 26, 17, 0, -26 },
  { 1677, 18, 26, 17, 0, -26 },
  { 1736, 19, 26, 21, 1, -26 },
  { 1798, 22, 26, 21, 0, -26 },
  { 1870, 10, 26, 10, 0, -26 },
  { 1903, 18, 26, 17, 0, -26 },
  { 1962, 22, 26, 19, 0, -26 },
  { 2034, 15, 26, 17, 0, -26 },
  { 2083, 27, 26, 26, 0, -26 },
  { 2171, 22, 26, 21, 0, -26 },
  { 2243, 20, 26, 21, 1, -26 },
  { 2308, 20, 26, 20, 0, -26 },
  { 2373, 20, 31, 21, 1, -26 },
  { 2451, 20, 26, 20, 0, -26 },
  { 2516, 18, 26, 19, 1, -26 },
  { 2575, 18, 26, 19, 3, -26 },
  { 2634, 20, 26, 20, 1, -26 },
  { 2699, 20, 26, 20, 3, -26 },
  { 2764, 25, 26, 26, 3, -26 },
  { 2846, 23, 26, 20, -1, -26 },
  { 2921, 19, 26, 19, 3, -26 },
  { 2983, 21, 26, 19, -1, -26 },
  { 3052, 13, 36, 9, -1, -30 },
  { 3111, 9, 28, 13, 3, -26 },
  { 3143, 12, 36, 9, -2, -30 },
  { 3197, 12, 13, 14, 1, -26 },
  { 3217, 14, 4, 14, -2, 0 },
  { 3224, 8, 5, 12, 4, -27 },
  { 3229, 15, 19, 16, 0, -19 },
  { 3265, 16, 27, 17, 0, -27 },
  { 3319, 15, 19, 16, 1, -19 },
  { 3355, 18, 27, 17, 1, -27 },
  { 3416, 15, 19, 17, 1, -19 },
  { 3452, 13, 27, 12, 1, -27 },
  { 3496, 17, 26, 18, 0, -19 },
  { 3552, 16, 27, 17, 0, -27 },
  { 3606, 10, 27, 9, 0, -27 },
  { 3640, 14, 34, 9, -4, -27 },
  { 3700, 18, 27, 17, 0, -27 },
  { 3761, 10, 27, 9, 0, -27 },
  { 3795, 24, 19, 26, 0, -19 },
  { 3852, 16, 19, 17, 0, -19 },
  { 3890, 15, 19, 17, 1, -19 },
  { 3926, 17, 26, 17, -1, -19 },
  { 3982, 16, 26, 17, 1, -19 },
  { 4034, 13, 19, 12, 0, -19 },
  { 4065, 15, 19, 16, 0, -19 },
  { 4101, 11, 24, 11, 1, -24 },
  { 4134, 16, 19, 17, 1, -19 },
  { 4172, 15, 19, 16, 2, -19 },
  { 4208, 21, 19, 22, 2, -19 },
  { 4258, 18, 19, 16, -1, -19 },
  { 4301, 18, 26, 16, -1, -19 },
  { 4360, 17, 19, 16, -1, -19 },
  { 4401, 11, 34, 10, 1, -28 },
  { 4448, 7, 31, 9, 1, -26 },
  { 4476, 11, 34, 10, -1, -28 },
  { 4523, 17, 8, 19, 1, -15 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC36PT7B_H_
