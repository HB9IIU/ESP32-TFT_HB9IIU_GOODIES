#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC70PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC,
  0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x60, 0xFE, 0x1F, 0xC0, 0x78, 0x7F, 0x0F, 0xE0, 0x7F,
  0x7F, 0x07, 0xF0, 0x3F, 0x3F, 0x83, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x3F, 0x1F,
  0xC1, 0xFC, 0x3F, 0x9F, 0xC0, 0xFE, 0x1F, 0xCF, 0xC0, 0x3F, 0xFF, 0xCF,
  0xE0, 0x1F, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xE7,
  0xF0, 0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0xF0, 0x00, 0x7E, 0x7F, 0xFC, 0x00,
  0x7F, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xC0,
  0x3F, 0xBF, 0xC7, 0xF0, 0x3F, 0x9F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F,
  0x8F, 0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x07,
  0xE7, 0xE0, 0x3F, 0x87, 0xF0, 0xF0, 0x0F, 0xE7, 0xF8, 0x30, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xFC, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xFF,
  0x8F, 0xF9, 0xFF, 0xBF, 0xF9, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xCF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xCF,
  0xFE, 0x0F, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x03, 0xF0,
  0x1C, 0xFC, 0x0F, 0x81, 0xF3, 0xFC, 0x3E, 0x3F, 0xDF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x01, 0x80,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F, 0x83, 0xFE, 0x7F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFD, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F,
  0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0xFF, 0xC7,
  0x83, 0xFF, 0x10, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x3F, 0xF8, 0x03,
  0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0x78,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xE0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xBF, 0xFC, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB,
  0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xE3, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x3F, 0xE7, 0xFF, 0x03, 0xFE,
  0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x0F,
  0xFE, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFE, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xFF, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x03,
  0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x03, 0xFE, 0x3F, 0x81, 0xF8,
  0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFC, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7E,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x1F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0x9F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xCF, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF3, 0xF8, 0x3F, 0xC0, 0x7F, 0x01, 0xF9, 0xFC, 0x1F, 0xE0, 0x3F, 0x80,
  0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x83, 0xFC, 0x07, 0xF0,
  0x1F, 0x9F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xCF, 0xE0, 0xFF, 0x03, 0xF8,
  0x0F, 0xC7, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0xC0, 0xFE,
  0x03, 0xF1, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xC1, 0xF8, 0x3F, 0x81, 0xFF, 0xFF,
  0xE1, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFD,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFE,
  0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x38,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF,
  0x83, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00,
  0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF3,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xE7,
  0xFE, 0x03, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0xE0,
  0x7F, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xFE,
  0x00, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFD, 0xFE, 0x03,
  0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x1F, 0xEF, 0xF8, 0x03, 0xFF, 0x7F,
  0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFC, 0x0F, 0xF7, 0xFE, 0x00, 0xFF,
  0xDF, 0xE0, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0x80,
  0x7F, 0xE7, 0xF8, 0x3F, 0xDF, 0xFC, 0x03, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFE, 0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0xC7, 0xF1, 0xFE,
  0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0x8F, 0xF1, 0xFF, 0x80, 0x7F, 0xF1, 0xFC,
  0x7F, 0x9F, 0xFC, 0x03, 0xFF, 0x8F, 0xE7, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8,
  0x7F, 0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFB, 0xFC, 0x3F, 0xF0, 0x07,
  0xFE, 0x1F, 0xDF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC,
  0x03, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xBF, 0x83, 0xFF, 0x80, 0x7F, 0xF7,
  0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x9F, 0xC3,
  0xFF, 0x80, 0x3F, 0xF1, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0x8F, 0xFE,
  0x01, 0xFF, 0xC7, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0x0F, 0xE7, 0xFE, 0x00, 0xFF, 0xC1, 0xFD, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xBF, 0xF8, 0x07, 0xFF, 0x07, 0xF7, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFE,
  0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF9,
  0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0x00,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xC0,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0x80,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0x80,
  0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0x00,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xEF, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01,
  0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF9, 0xFF,
  0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xFD, 0xFC, 0x03, 0xF8, 0xFC,
  0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF,
  0x83, 0xFF, 0x8F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x0F, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF,
  0xC0, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x3F,
  0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xEF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F,
  0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0x01, 0xFF, 0xC0, 0x7C,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xF9,
  0xFF, 0x80, 0x3F, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xF7, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07,
  0x8F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0x00, 0x0F, 0xFE, 0x00, 0x38, 0x03, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x87, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x07, 0xFE,
  0x3F, 0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0x80, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFE, 0xFF, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xBF, 0xF8, 0x03,
  0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xE1, 0xFF,
  0x01, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xFB, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x03,
  0xFE, 0x7F, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xFC, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF,
  0x80, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0,
  0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0xFF,
  0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0x81, 0xFF,
  0xBF, 0xE0, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFF, 0x0F, 0xFC,
  0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0xC7, 0xFE, 0x1F, 0xF1,
  0xFF, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0xF9,
  0xFF, 0x83, 0xFE, 0x7F, 0xFC, 0xFF, 0x81, 0xFF, 0x7F, 0xFE, 0x7F, 0xC0,
  0xFF, 0xBF, 0xBF, 0x3F, 0xE0, 0x7F, 0xDF, 0xDF, 0xBF, 0xE0, 0x3F, 0xFF,
  0xEF, 0xDF, 0xF0, 0x1F, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFF,
  0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF8, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xEF, 0xFF, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF,
  0x0F, 0xE0, 0x3F, 0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0x87, 0xF8, 0x03, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 51, 18, 1, -50 },
  { 123, 22, 19, 22, 3, -53 },
  { 176, 35, 50, 35, 1, -50 },
  { 395, 32, 66, 35, 2, -58 },
  { 659, 33, 52, 44, 6, -51 },
  { 874, 35, 52, 40, 1, -51 },
  { 1102, 10, 19, 11, 4, -53 },
  { 1126, 22, 70, 22, 3, -55 },
  { 1319, 22, 71, 22, -3, -55 },
  { 1515, 30, 30, 31, 3, -50 },
  { 1628, 29, 36, 32, 2, -41 },
  { 1759, 15, 22, 17, -4, -9 },
  { 1801, 18, 8, 27, 4, -25 },
  { 1819, 12, 11, 20, 1, -10 },
  { 1836, 31, 54, 22, -5, -50 },
  { 2046, 30, 52, 35, 3, -51 },
  { 2241, 22, 50, 35, 7, -50 },
  { 2379, 34, 51, 35, 0, -51 },
  { 2596, 33, 52, 35, 1, -51 },
  { 2811, 32, 50, 35, 1, -50 },
  { 3011, 33, 51, 35, 2, -50 },
  { 3222, 29, 51, 35, 3, -50 },
  { 3407, 33, 50, 35, 3, -50 },
  { 3614, 32, 52, 35, 2, -51 },
  { 3822, 28, 51, 35, 5, -51 },
  { 4001, 17, 39, 20, 1, -38 },
  { 4084, 20, 51, 18, -3, -38 },
  { 4212, 28, 33, 30, 1, -38 },
  { 4328, 30, 23, 35, 2, -33 },
  { 4415, 28, 33, 31, 1, -37 },
  { 4531, 27, 52, 31, 4, -51 },
  { 4707, 49, 63, 52, 1, -48 },
  { 5093, 40, 50, 41, -3, -50 },
  { 5343, 38, 50, 38, 0, -50 },
  { 5581, 37, 52, 39, 2, -51 },
  { 5822, 37, 50, 38, 0, -50 },
  { 6054, 37, 50, 33, 0, -50 },
  { 6286, 36, 50, 32, 0, -50 },
  { 6511, 36, 52, 40, 3, -51 },
  { 6745, 43, 50, 42, 0, -50 },
  { 7014, 20, 50, 19, 0, -50 },
  { 7139, 35, 51, 33, 0, -50 },
  { 7363, 43, 50, 38, 0, -50 },
  { 7632, 29, 50, 33, 0, -50 },
  { 7814, 53, 50, 52, 0, -50 },
  { 8146, 43, 50, 41, 0, -50 },
  { 8415, 38, 52, 41, 2, -51 },
  { 8662, 39, 50, 39, 0, -50 },
  { 8906, 37, 60, 41, 3, -51 },
  { 9184, 38, 50, 38, 0, -50 },
  { 9422, 36, 52, 37, 1, -51 },
  { 9656, 36, 50, 37, 5, -50 },
  { 9881, 39, 51, 39, 2, -50 },
  { 10130, 39, 50, 39, 5, -50 },
  { 10374, 48, 50, 51, 6, -50 },
  { 10674, 45, 50, 38, -3, -50 },
  { 10956, 36, 50, 37, 6, -50 },
  { 11181, 40, 50, 36, -1, -50 },
  { 11431, 25, 70, 18, -2, -58 },
  { 11650, 18, 54, 26, 5, -50 },
  { 11772, 24, 70, 18, -4, -58 },
  { 11982, 24, 25, 27, 2, -50 },
  { 12057, 27, 8, 27, -4, 0 },
  { 12084, 16, 11, 23, 7, -53 },
  { 12106, 30, 39, 32, 0, -38 },
  { 12253, 32, 54, 34, 0, -53 },
  { 12469, 29, 39, 31, 1, -38 },
  { 12611, 35, 54, 34, 1, -53 },
  { 12848, 30, 39, 33, 1, -38 },
  { 12995, 25, 54, 22, 2, -54 },
  { 13164, 35, 52, 34, -1, -38 },
  { 13392, 32, 53, 34, -1, -53 },
  { 13604, 19, 52, 17, 0, -52 },
  { 13728, 27, 66, 17, -8, -52 },
  { 13951, 36, 53, 33, 0, -53 },
  { 14190, 19, 53, 17, 0, -53 },
  { 14316, 48, 38, 50, 0, -38 },
  { 14544, 32, 38, 34, -1, -38 },
  { 14696, 31, 39, 34, 1, -38 },
  { 14848, 35, 52, 34, -3, -38 },
  { 15076, 32, 52, 34, 1, -38 },
  { 15284, 24, 38, 23, 0, -38 },
  { 15398, 30, 39, 31, 0, -38 },
  { 15545, 20, 47, 21, 2, -46 },
  { 15663, 31, 38, 34, 2, -37 },
  { 15811, 30, 37, 31, 3, -37 },
  { 15950, 41, 37, 43, 4, -37 },
  { 16140, 36, 37, 31, -3, -37 },
  { 16307, 35, 51, 31, -2, -37 },
  { 16531, 32, 37, 31, -1, -37 },
  { 16679, 22, 67, 20, 1, -55 },
  { 16864, 15, 59, 17, 1, -50 },
  { 16975, 21, 67, 20, -2, -55 },
  { 17151, 33, 16, 37, 2, -29 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC70PT7B_H_
