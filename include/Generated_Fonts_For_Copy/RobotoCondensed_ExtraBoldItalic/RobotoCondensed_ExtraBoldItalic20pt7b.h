#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC20PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x18, 0xE1, 0x80,
  0x6D, 0xBC, 0xF6, 0xD8, 0x06, 0xC1, 0x60, 0xD8, 0x36, 0x3F, 0xCF, 0xF1,
  0xB0, 0x68, 0xFF, 0xBF, 0xE3, 0x41, 0xB0, 0x6C, 0x1A, 0x00, 0x06, 0x02,
  0x07, 0x87, 0xE7, 0xF3, 0x9D, 0xCE, 0xE0, 0x3C, 0x0F, 0x03, 0x98, 0xEE,
  0x77, 0x73, 0xF8, 0xF8, 0x30, 0x18, 0x00, 0x70, 0x7C, 0x36, 0x7B, 0x6D,
  0xE7, 0xF1, 0xF0, 0x3E, 0x3F, 0x9E, 0xDB, 0x79, 0xB0, 0xF8, 0x38, 0x0F,
  0x07, 0xE1, 0xB8, 0xEE, 0x3B, 0x87, 0xC1, 0xE0, 0xF3, 0x7E, 0xF9, 0xFE,
  0x7B, 0xDE, 0x7F, 0x8F, 0x70, 0x6D, 0xED, 0x80, 0x04, 0x31, 0x8E, 0x31,
  0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x86, 0x08, 0x10,
  0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x8E, 0x31,
  0xCE, 0x20, 0x0C, 0x06, 0x02, 0x1D, 0xE7, 0xF1, 0xC1, 0xF1, 0xCC, 0x44,
  0x00, 0x0E, 0x07, 0x03, 0x81, 0x87, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0C,
  0x06, 0x00, 0x33, 0x76, 0xEC, 0xFF, 0xC0, 0x6F, 0x60, 0x03, 0x03, 0x06,
  0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0,
  0x1E, 0x1F, 0x9D, 0xCE, 0x66, 0x3F, 0x1B, 0x9D, 0xCE, 0xE7, 0x73, 0xB9,
  0x9D, 0xCF, 0xC3, 0xC0, 0x04, 0xFF, 0xFF, 0x1C, 0x63, 0x8E, 0x38, 0xE3,
  0x9C, 0x71, 0xC0, 0x0F, 0x07, 0xE3, 0xB8, 0xC7, 0x73, 0x80, 0xE0, 0x70,
  0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0x3F, 0xC0, 0x0F, 0x0F, 0xE3,
  0xB8, 0xE7, 0x03, 0x80, 0xE0, 0xF0, 0x7C, 0x03, 0x80, 0xEE, 0x3B, 0xDC,
  0x7F, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x3E, 0x0F, 0x86, 0xE3, 0xF1,
  0xDC, 0x67, 0x3F, 0xEF, 0xF8, 0x1C, 0x0E, 0x03, 0x80, 0x1F, 0xC7, 0xF3,
  0x80, 0xE0, 0x38, 0x0F, 0xC7, 0xF0, 0xCE, 0x03, 0x80, 0xEE, 0x39, 0xDC,
  0x7F, 0x0F, 0x00, 0x07, 0x1F, 0x3E, 0x78, 0x70, 0xEE, 0xFF, 0xF7, 0xE7,
  0xE7, 0xE7, 0xEE, 0x7E, 0x38, 0x7F, 0xBF, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x0F, 0x07, 0xE3,
  0xB8, 0xE7, 0x39, 0x8E, 0xE1, 0xF0, 0xFC, 0x73, 0x1C, 0xE6, 0x39, 0xDC,
  0x7F, 0x0F, 0x00, 0x1E, 0x3F, 0x77, 0x73, 0xE3, 0xE7, 0xF7, 0x7F, 0x3F,
  0x06, 0x0E, 0x7C, 0x78, 0x70, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x67, 0x98,
  0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x71, 0x84, 0x00,
  0x01, 0x07, 0x1F, 0x7E, 0x78, 0xF0, 0x7C, 0x3E, 0x0E, 0x02, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x20, 0x38, 0x3C, 0x1F, 0x07, 0x0F, 0x3F, 0x78,
  0x60, 0x80, 0x3C, 0x7F, 0x77, 0xE7, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x00,
  0x00, 0x70, 0x70, 0x70, 0x03, 0xE0, 0x1F, 0xE0, 0xC1, 0x86, 0x03, 0x31,
  0xCC, 0xCF, 0xB6, 0x66, 0xDB, 0x93, 0x6C, 0xCF, 0x33, 0x3C, 0xCC, 0xF3,
  0x76, 0xCF, 0xFB, 0x1B, 0xC6, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x01, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x1D, 0x83, 0xB0, 0xE7, 0x1F,
  0xE7, 0xFC, 0xFF, 0xB8, 0x77, 0x0F, 0xE1, 0xC0, 0x3F, 0x87, 0xF8, 0xFF,
  0x9C, 0x73, 0x8E, 0x73, 0x9F, 0xE3, 0xFC, 0x71, 0xCE, 0x39, 0xC7, 0x73,
  0xCF, 0xF9, 0xFC, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0x61, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xEE, 0x3B, 0xFC, 0x7F, 0x0F, 0x00, 0x3F, 0x07,
  0xF0, 0xFF, 0x1C, 0xE3, 0x8E, 0x71, 0xDC, 0x73, 0x8E, 0x71, 0xCE, 0x39,
  0xCE, 0x77, 0xCF, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0xFF, 0x1C, 0x03,
  0x80, 0x70, 0x1F, 0xE3, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x7F, 0x8F, 0xF1,
  0xFE, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xE0, 0x38, 0x0F, 0xE7, 0xF9, 0xFC,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0x0F, 0xE7, 0xFD,
  0xC7, 0x71, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0xEE, 0x3B, 0xFE, 0x7F,
  0x8F, 0x80, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0xF3, 0xFE, 0x7F,
  0xE7, 0xFE, 0x70, 0xE7, 0x0E, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0x1C,
  0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x80, 0x01, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xCE, 0x73,
  0xFC, 0x7E, 0x0F, 0x00, 0x38, 0xF3, 0x8E, 0x39, 0xC3, 0xBC, 0x3F, 0x83,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x8E, 0x38, 0xE3, 0x8E,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70,
  0xFF, 0xFF, 0xFF, 0x3C, 0x1E, 0x78, 0x3C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7,
  0xC6, 0xCF, 0x9D, 0xBF, 0x3B, 0x6E, 0x76, 0xDC, 0xEF, 0x71, 0xDE, 0xE7,
  0x3D, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x3C, 0x73, 0xC7, 0x3C, 0x73, 0xC7,
  0x3E, 0xE3, 0xEE, 0x76, 0xE7, 0x6E, 0x73, 0xE7, 0x3E, 0x73, 0xCE, 0x3C,
  0xE3, 0xCE, 0x1C, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0x71, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0x7F, 0x0F, 0x00, 0x3F, 0x87, 0xF8,
  0xFF, 0x9C, 0x73, 0x8E, 0x71, 0xDF, 0xF3, 0xFE, 0x7F, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0x71, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0x7F, 0x0F, 0x80, 0x70,
  0x0C, 0x02, 0x00, 0x3F, 0x87, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0x73, 0x9C,
  0xF3, 0xFC, 0x7F, 0x0E, 0xE1, 0xDE, 0x71, 0xCE, 0x39, 0xC7, 0x00, 0x0F,
  0x83, 0xF8, 0xF7, 0x1C, 0x73, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0x9C,
  0x31, 0xCE, 0x3F, 0xC7, 0xF8, 0x3C, 0x00, 0x7F, 0xEF, 0xFB, 0xFF, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x00, 0x70, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8,
  0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0x7F, 0x8F, 0xF0, 0x78, 0x00, 0x70,
  0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x37,
  0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xE7, 0x3F, 0x39, 0xFB,
  0xCF, 0xDE, 0xEE, 0xF7, 0x7F, 0xBB, 0xFF, 0x9F, 0x7C, 0xFB, 0xE7, 0xDE,
  0x3C, 0xF1, 0xE7, 0x8E, 0x38, 0x71, 0xC0, 0x1C, 0x78, 0xE3, 0x87, 0xB8,
  0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F,
  0x70, 0x73, 0x87, 0x9C, 0x38, 0xF0, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0x6E,
  0x1F, 0x87, 0xC1, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x7F, 0xCF, 0xF9, 0xFF, 0x00, 0x1C, 0xF3, 0x8E, 0x38,
  0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8F, 0x38, 0x61,
  0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x80, 0x1E,
  0x3C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x38, 0x70, 0xE3, 0xC7, 0x80, 0x18, 0xF3, 0xDF, 0x6F, 0xBC, 0xC0, 0xFE,
  0xFE, 0xE7, 0x30, 0x1E, 0x1F, 0x9D, 0xC0, 0x63, 0xF3, 0xFB, 0x9D, 0xCE,
  0xEF, 0x7F, 0x9D, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF1, 0xFD, 0xEE,
  0xE7, 0x73, 0xB9, 0xDC, 0xEC, 0x7F, 0x77, 0xFB, 0xB8, 0x1E, 0x1F, 0x9C,
  0xCE, 0x77, 0x07, 0x03, 0x81, 0xCE, 0x77, 0x3F, 0x0F, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x1D, 0x8F, 0xE7, 0x39, 0xCE, 0x63, 0xB8, 0xEE, 0x33,
  0x9C, 0xF7, 0x1F, 0xC3, 0xF0, 0x1E, 0x1F, 0x9E, 0xEE, 0x77, 0xFB, 0xFF,
  0x80, 0xC0, 0x76, 0x3F, 0x8F, 0x80, 0x0F, 0x1F, 0x1C, 0x38, 0x7E, 0x7E,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x1D, 0xCF, 0xE7,
  0xB9, 0xCE, 0x73, 0x98, 0xEE, 0x3B, 0x8C, 0x77, 0x1F, 0xC3, 0xF0, 0x1C,
  0x4E, 0x3F, 0x87, 0x80, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF3, 0xFD, 0xCE,
  0xE7, 0x73, 0xB9, 0xDC, 0xDC, 0xEE, 0x77, 0x3B, 0x9C, 0x19, 0xC6, 0x03,
  0x9D, 0xCE, 0x73, 0x9C, 0xEE, 0x73, 0x80, 0x06, 0x1C, 0x18, 0x00, 0xE1,
  0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x79, 0xE3, 0x80,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCD, 0xE7, 0x71, 0xF8, 0x7C, 0x1F,
  0x87, 0xE3, 0xF8, 0xE7, 0x39, 0xCE, 0x70, 0x18, 0xE3, 0x8E, 0x38, 0xE7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x00, 0x37, 0x79, 0xFF, 0xE7, 0xBB,
  0xDC, 0xE7, 0x73, 0x99, 0xCE, 0xE7, 0x73, 0xB9, 0xCE, 0xE7, 0x3B, 0x9C,
  0xEE, 0x73, 0x00, 0x37, 0x3F, 0xDE, 0xEE, 0x77, 0x3B, 0x9D, 0x8D, 0xCE,
  0xE7, 0x73, 0xB9, 0xC0, 0x1E, 0x1F, 0x9E, 0xEE, 0x77, 0x3B, 0x1F, 0x8F,
  0xC7, 0x77, 0x3F, 0x0F, 0x00, 0x1B, 0x8F, 0xF3, 0xDC, 0xE7, 0x39, 0xCE,
  0x73, 0x9D, 0xC7, 0x7B, 0x9F, 0xE7, 0x71, 0xC0, 0x70, 0x38, 0x0E, 0x00,
  0x1D, 0x8F, 0xE7, 0x39, 0xCE, 0x63, 0xB8, 0xEE, 0x73, 0x9C, 0xF7, 0x1F,
  0xC3, 0xF0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x36, 0xFD, 0xFB, 0x87, 0x0E,
  0x1C, 0x70, 0xE1, 0xC3, 0x80, 0x1E, 0x3F, 0x73, 0x70, 0x78, 0x3E, 0x1E,
  0x07, 0xE7, 0x7E, 0x3C, 0x33, 0xBF, 0xF7, 0x3B, 0x9C, 0xE7, 0x39, 0xE7,
  0x00, 0x31, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x33, 0x9C, 0x77,
  0x1F, 0xC7, 0xF0, 0xE7, 0xE7, 0xEE, 0xEE, 0xEE, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0x70, 0xE6, 0x7E, 0xEE, 0xEE, 0xEE, 0xEE, 0xFE, 0xCF, 0xFC, 0xFF,
  0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x00, 0x39, 0xC6, 0xF1, 0xF8, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x1D, 0xC7, 0x38, 0x73, 0x9C, 0xE7,
  0x71, 0xDC, 0x77, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x00, 0x3F, 0xBF, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0x7F, 0x3F, 0x80, 0x04, 0x31, 0xC6, 0x18, 0xE3, 0x8E, 0x31,
  0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x83, 0x04, 0x18, 0x84, 0x63, 0x18,
  0xC4, 0x23, 0x18, 0xC6, 0x31, 0x08, 0xC0, 0x10, 0x61, 0xC7, 0x1C, 0x71,
  0xC6, 0x1C, 0x31, 0xCE, 0x38, 0xE3, 0x0C, 0x31, 0xCE, 0x10, 0x71, 0xBC,
  0xFF, 0xF9, 0xEC, 0x60,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 5, 6, 1, -15 },
  { 16, 10, 14, 10, 0, -14 },
  { 34, 9, 18, 10, 1, -16 },
  { 55, 9, 14, 12, 2, -14 },
  { 71, 10, 14, 11, 0, -14 },
  { 89, 3, 6, 3, 1, -15 },
  { 92, 6, 20, 6, 1, -16 },
  { 107, 6, 20, 6, -1, -16 },
  { 122, 9, 9, 9, 1, -14 },
  { 133, 9, 11, 9, 0, -12 },
  { 146, 4, 6, 5, -1, -2 },
  { 149, 5, 2, 8, 1, -7 },
  { 151, 4, 3, 6, 0, -3 },
  { 153, 8, 15, 6, -1, -14 },
  { 168, 9, 14, 10, 1, -14 },
  { 184, 6, 14, 10, 2, -14 },
  { 195, 10, 14, 10, 0, -14 },
  { 213, 10, 14, 10, 0, -14 },
  { 231, 10, 14, 10, 0, -14 },
  { 249, 10, 14, 10, 0, -14 },
  { 267, 8, 14, 10, 1, -14 },
  { 281, 9, 14, 10, 1, -14 },
  { 297, 10, 14, 10, 0, -14 },
  { 315, 8, 14, 10, 1, -14 },
  { 329, 5, 11, 6, 0, -11 },
  { 336, 6, 15, 5, -1, -11 },
  { 348, 8, 10, 9, 0, -11 },
  { 358, 8, 6, 10, 1, -9 },
  { 364, 8, 10, 9, 0, -11 },
  { 374, 8, 14, 9, 1, -14 },
  { 388, 14, 18, 15, 0, -14 },
  { 420, 11, 14, 12, -1, -14 },
  { 440, 11, 14, 11, 0, -14 },
  { 460, 10, 14, 11, 1, -14 },
  { 478, 11, 14, 11, 0, -14 },
  { 498, 11, 14, 10, 0, -14 },
  { 518, 10, 14, 9, 0, -14 },
  { 536, 10, 14, 11, 1, -14 },
  { 554, 12, 14, 12, 0, -14 },
  { 575, 6, 14, 5, 0, -14 },
  { 586, 10, 14, 10, 0, -14 },
  { 604, 12, 14, 11, 0, -14 },
  { 625, 8, 14, 9, 0, -14 },
  { 639, 15, 14, 15, 0, -14 },
  { 666, 12, 14, 12, 0, -14 },
  { 687, 10, 14, 12, 1, -14 },
  { 705, 11, 14, 11, 0, -14 },
  { 725, 10, 17, 12, 1, -14 },
  { 747, 11, 14, 11, 0, -14 },
  { 767, 11, 14, 11, 0, -14 },
  { 787, 11, 14, 11, 1, -14 },
  { 807, 11, 14, 11, 1, -14 },
  { 827, 12, 14, 11, 1, -14 },
  { 848, 13, 14, 14, 2, -14 },
  { 871, 13, 14, 11, -1, -14 },
  { 894, 10, 14, 11, 2, -14 },
  { 912, 11, 14, 10, 0, -14 },
  { 932, 6, 20, 5, 0, -17 },
  { 947, 6, 15, 7, 1, -14 },
  { 959, 7, 20, 5, -1, -17 },
  { 977, 6, 7, 8, 1, -14 },
  { 983, 8, 2, 8, -1, 0 },
  { 985, 4, 3, 7, 2, -15 },
  { 987, 9, 11, 9, 0, -11 },
  { 1000, 9, 15, 10, 0, -15 },
  { 1017, 9, 11, 9, 0, -11 },
  { 1030, 10, 15, 10, 0, -15 },
  { 1049, 9, 11, 9, 0, -11 },
  { 1062, 8, 15, 6, 0, -15 },
  { 1077, 10, 15, 10, 0, -11 },
  { 1096, 9, 15, 10, 0, -15 },
  { 1113, 5, 15, 5, 0, -15 },
  { 1123, 7, 19, 5, -2, -15 },
  { 1140, 10, 15, 9, 0, -15 },
  { 1159, 6, 15, 5, 0, -15 },
  { 1171, 14, 11, 14, 0, -11 },
  { 1191, 9, 11, 10, 0, -11 },
  { 1204, 9, 11, 10, 0, -11 },
  { 1217, 10, 15, 10, -1, -11 },
  { 1236, 10, 15, 10, 0, -11 },
  { 1255, 7, 11, 7, 0, -11 },
  { 1265, 8, 11, 9, 0, -11 },
  { 1276, 5, 13, 6, 1, -13 },
  { 1285, 10, 11, 10, 0, -11 },
  { 1299, 8, 11, 9, 1, -11 },
  { 1310, 12, 11, 12, 1, -11 },
  { 1327, 10, 11, 9, -1, -11 },
  { 1341, 10, 15, 9, 0, -11 },
  { 1360, 9, 11, 9, 0, -11 },
  { 1373, 6, 20, 6, 0, -16 },
  { 1388, 5, 17, 5, 0, -14 },
  { 1399, 6, 20, 6, -1, -16 },
  { 1414, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC20PT7B_H_
