#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC60PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x08, 0x00, 0x3F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x81, 0xF8, 0xFC,
  0x0F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7C, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0x7E,
  0x3F, 0x07, 0xC3, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF3, 0xF0, 0x7E,
  0x1F, 0x9F, 0x03, 0xF1, 0xF9, 0xF8, 0x0F, 0xFF, 0xDF, 0x80, 0x7F, 0xFE,
  0xF8, 0x01, 0xFF, 0xEF, 0xC0, 0x07, 0xFE, 0xFC, 0x00, 0x1F, 0xE7, 0xC0,
  0x00, 0x10, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0x1F,
  0xBF, 0xF0, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0x00, 0xFD, 0xFF,
  0xF8, 0x0F, 0xDF, 0x87, 0xC0, 0xFC, 0xFC, 0x3E, 0x07, 0xE7, 0xE1, 0xF0,
  0x7E, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x83, 0xE3, 0xF0,
  0xFC, 0x3F, 0x3F, 0x07, 0xE1, 0xF8, 0xF0, 0x1F, 0x0F, 0xC3, 0x80, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF,
  0x3F, 0xDF, 0xF7, 0xFC, 0xFE, 0x7F, 0xCF, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF,
  0xEF, 0xF8, 0x7F, 0xFF, 0xBF, 0xE1, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0xF3,
  0xFE, 0x0F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFE, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD,
  0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x8F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF1, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x7C, 0x06, 0x3E, 0x1F, 0x0F,
  0x9F, 0xE7, 0xDF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x78, 0x07,
  0xC0, 0x0C, 0x01, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01,
  0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF,
  0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x3F, 0xC7, 0x0F, 0xF9, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xEF, 0xF8,
  0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0x8F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x1F, 0xF0, 0x0F, 0xE1, 0xFF,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFE, 0x00, 0x18,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xCF, 0xC0, 0x3F, 0xDF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xFD,
  0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F,
  0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xE1, 0xFE, 0x3F, 0xE1, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x10, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xC7, 0xFD,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x81, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x7E, 0x03,
  0xFF, 0xE0, 0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x3E, 0x0F, 0xC0, 0xFF, 0xFF,
  0x0F, 0x87, 0xE0, 0x7F, 0x8F, 0xC3, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF8, 0x1F, 0x83, 0xF3, 0xE0, 0xFE, 0x0F, 0xC0, 0xF9, 0xF8, 0x3F, 0x03,
  0xF0, 0x3E, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x9F, 0x87, 0xF0, 0x3F, 0x03,
  0xE7, 0xC1, 0xFC, 0x0F, 0xC0, 0xFB, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x3F, 0x0F, 0xE0, 0x7E, 0x07, 0xCF, 0xC3, 0xF8,
  0x1F, 0x81, 0xF3, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0xFC, 0x3F, 0x83, 0xF0,
  0x3E, 0x3E, 0x0F, 0xE0, 0xFC, 0x0F, 0x8F, 0x83, 0xF8, 0x7F, 0x07, 0xC3,
  0xE0, 0x7E, 0x3F, 0xC3, 0xF0, 0xF8, 0x1F, 0xFF, 0xF9, 0xF8, 0x3F, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xDF, 0xFE, 0x03, 0xF0, 0x3F, 0xE3,
  0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0x00, 0x20, 0x03, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F,
  0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC7, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0,
  0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFE, 0x7F, 0xC0,
  0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFC, 0x7F, 0xC1,
  0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0x81, 0xFD, 0xFE, 0x03, 0xFE, 0xFC,
  0x0F, 0xEF, 0xF0, 0x1F, 0xF7, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x07,
  0xF7, 0xFC, 0x07, 0xF9, 0xF8, 0x3F, 0xBF, 0xE0, 0x3F, 0xCF, 0xE3, 0xF9,
  0xFF, 0x03, 0xFE, 0x7F, 0x1F, 0xCF, 0xF0, 0x1F, 0xF3, 0xF9, 0xFC, 0xFF,
  0x80, 0xFF, 0x9F, 0xCF, 0xE7, 0xFC, 0x07, 0xFC, 0xFE, 0x7E, 0x3F, 0xE0,
  0x3F, 0xE3, 0xF7, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0xBF, 0x8F, 0xF8, 0x1F,
  0xF0, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0xC7, 0xFC, 0x07, 0xFC,
  0x3F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x0F,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F,
  0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xC0, 0x7F, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x7E, 0x1F, 0xF0, 0x1F, 0xF3,
  0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0x8F, 0xF8, 0x07, 0xFC, 0xFC, 0x7F, 0xC0,
  0x3F, 0xE3, 0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0x9F, 0xF0, 0x1F, 0xF0, 0xFC,
  0xFF, 0x80, 0xFF, 0x87, 0xEF, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x03,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF7, 0xFC, 0x0F, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0x0F, 0xF9,
  0xFF, 0x07, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0x7F, 0xC1,
  0xFF, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0,
  0xFF, 0x8F, 0xF8, 0x7F, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xFC, 0x7F, 0xC3,
  0xFE, 0x3F, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xFF, 0x1F, 0xE0, 0xFF, 0x9F,
  0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xFF, 0xCF, 0xF8, 0x3F, 0xE7, 0xFF, 0xE7,
  0xF8, 0x1F, 0xF7, 0xFF, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF, 0xFB, 0xFE, 0x07,
  0xFD, 0xFD, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0xFE, 0xFF, 0x01, 0xFF, 0xFE,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7,
  0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0xF1, 0xFF, 0x87, 0xFC, 0x7F, 0xC1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF,
  0xF8, 0x0F, 0xF3, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x07, 0xFC,
  0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07,
  0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0xF0, 0x7F, 0x9F, 0xFC,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0x7F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x0F,
  0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0xFF,
  0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x08, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x3F, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x1F, 0xF0, 0x1E,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x18, 0x03, 0xFF, 0x00, 0x78, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x9F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x0F,
  0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xF8, 0x7F, 0xF0, 0x1F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0,
  0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xEF, 0xF0, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0xFF, 0xE3,
  0xFF, 0x80, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x1F, 0xF1,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xF8, 0x1F,
  0xF1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x7F,
  0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFF,
  0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE,
  0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFE,
  0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xF0, 0xFE, 0x03, 0xFF, 0x9F, 0xE0, 0x7F, 0xFD, 0xFE, 0x0F, 0xFF, 0xDF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF7, 0xFC, 0x00, 0x08, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x3F, 0xCF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x83,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF9,
  0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x01, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFE,
  0x07, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFF, 0x7F, 0x83, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x87,
  0xFC, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F,
  0xC7, 0xFC, 0x7F, 0x1F, 0xF8, 0xFF, 0x0F, 0xE3, 0xFF, 0x1F, 0xE1, 0xFC,
  0xFF, 0xE7, 0xF8, 0x3F, 0x9F, 0xFC, 0xFF, 0x07, 0xF3, 0xFF, 0x9F, 0xE0,
  0xFE, 0xFF, 0xF3, 0xF8, 0x1F, 0xDF, 0xFE, 0xFF, 0x03, 0xFB, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFE, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xF3,
  0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xE7, 0xF8,
  0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01,
  0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x87,
  0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE,
  0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFF, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFE, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x40,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0x0F, 0xFC, 0x03, 0xF1, 0xFF, 0xE0, 0x7F, 0x3F,
  0xFF, 0x07, 0xE3, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xCF, 0xE7, 0xF3, 0xFF,
  0xFE, 0x7E, 0x1F, 0xFF, 0xCF, 0xE0, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0x8F,
  0xC0, 0x3F, 0xF0, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 44, 15, 1, -43 },
  { 89, 18, 16, 19, 3, -45 },
  { 125, 30, 43, 30, 1, -43 },
  { 287, 27, 57, 30, 2, -50 },
  { 480, 29, 45, 37, 5, -44 },
  { 644, 30, 45, 34, 1, -44 },
  { 813, 9, 17, 9, 3, -45 },
  { 833, 18, 60, 19, 3, -47 },
  { 968, 19, 60, 19, -3, -47 },
  { 1111, 26, 26, 27, 3, -43 },
  { 1196, 26, 31, 27, 1, -35 },
  { 1297, 13, 18, 15, -3, -7 },
  { 1327, 15, 7, 23, 4, -22 },
  { 1341, 10, 10, 17, 1, -9 },
  { 1354, 26, 47, 19, -4, -43 },
  { 1507, 27, 45, 30, 2, -44 },
  { 1659, 19, 43, 30, 6, -43 },
  { 1762, 29, 44, 30, 0, -44 },
  { 1922, 28, 45, 30, 1, -44 },
  { 2080, 28, 43, 30, 1, -43 },
  { 2231, 29, 44, 30, 1, -43 },
  { 2391, 25, 44, 30, 2, -43 },
  { 2529, 29, 43, 30, 2, -43 },
  { 2685, 28, 45, 30, 1, -44 },
  { 2843, 24, 44, 30, 4, -44 },
  { 2975, 14, 34, 17, 1, -33 },
  { 3035, 18, 44, 16, -3, -33 },
  { 3134, 24, 29, 26, 1, -33 },
  { 3221, 26, 20, 30, 2, -29 },
  { 3286, 24, 28, 26, 1, -32 },
  { 3370, 23, 45, 26, 4, -44 },
  { 3500, 42, 54, 45, 1, -41 },
  { 3784, 34, 43, 35, -3, -43 },
  { 3967, 32, 43, 33, 0, -43 },
  { 4139, 32, 45, 33, 2, -44 },
  { 4319, 32, 43, 33, 0, -43 },
  { 4491, 32, 43, 29, 0, -43 },
  { 4663, 31, 43, 28, 0, -43 },
  { 4830, 32, 45, 34, 2, -44 },
  { 5010, 37, 43, 36, 0, -43 },
  { 5209, 17, 43, 16, 0, -43 },
  { 5301, 30, 44, 29, 0, -43 },
  { 5466, 37, 43, 32, 0, -43 },
  { 5665, 25, 43, 28, 0, -43 },
  { 5800, 45, 43, 44, 0, -43 },
  { 6042, 37, 43, 36, 0, -43 },
  { 6241, 32, 45, 35, 2, -44 },
  { 6421, 33, 43, 33, 0, -43 },
  { 6599, 32, 52, 35, 2, -44 },
  { 6807, 33, 43, 33, 0, -43 },
  { 6985, 31, 45, 32, 1, -44 },
  { 7160, 31, 43, 32, 4, -43 },
  { 7327, 33, 44, 33, 2, -43 },
  { 7509, 34, 43, 34, 4, -43 },
  { 7692, 41, 43, 43, 5, -43 },
  { 7913, 38, 43, 33, -2, -43 },
  { 8118, 31, 43, 32, 5, -43 },
  { 8285, 35, 43, 31, -1, -43 },
  { 8474, 20, 60, 15, -1, -50 },
  { 8624, 16, 47, 22, 4, -43 },
  { 8718, 20, 60, 15, -3, -50 },
  { 8868, 20, 21, 23, 2, -43 },
  { 8921, 24, 7, 23, -4, 0 },
  { 8942, 13, 9, 20, 6, -45 },
  { 8957, 26, 34, 27, 0, -33 },
  { 9068, 27, 46, 29, 0, -45 },
  { 9224, 25, 34, 27, 1, -33 },
  { 9331, 30, 46, 29, 1, -45 },
  { 9504, 26, 34, 28, 1, -33 },
  { 9615, 22, 46, 19, 1, -46 },
  { 9742, 30, 45, 29, -1, -33 },
  { 9911, 28, 45, 29, -1, -45 },
  { 10069, 16, 45, 15, 0, -45 },
  { 10159, 23, 57, 15, -7, -45 },
  { 10323, 31, 45, 28, 0, -45 },
  { 10498, 17, 45, 15, 0, -45 },
  { 10594, 41, 33, 43, 0, -33 },
  { 10764, 28, 33, 29, -1, -33 },
  { 10880, 26, 34, 29, 1, -33 },
  { 10991, 29, 45, 29, -2, -33 },
  { 11155, 28, 45, 29, 1, -33 },
  { 11313, 21, 33, 20, 0, -33 },
  { 11400, 25, 34, 26, 0, -33 },
  { 11507, 17, 41, 18, 2, -40 },
  { 11595, 28, 33, 29, 1, -32 },
  { 11711, 25, 32, 26, 3, -32 },
  { 11811, 35, 32, 37, 3, -32 },
  { 11951, 30, 32, 26, -2, -32 },
  { 12071, 30, 44, 26, -1, -32 },
  { 12236, 28, 32, 26, -1, -32 },
  { 12348, 18, 58, 17, 1, -47 },
  { 12479, 13, 51, 15, 1, -43 },
  { 12562, 18, 58, 17, -2, -47 },
  { 12693, 28, 14, 32, 2, -25 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC60PT7B_H_
