#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC40PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xC0,
  0x3C, 0xF7, 0xCF, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0xF1, 0xCF, 0x1C, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x03, 0x9E, 0x00, 0x79,
  0xE0, 0x07, 0x9C, 0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0E,
  0x38, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x1C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xE0, 0x03, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9C, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x0E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCE, 0x00, 0x38, 0xE0,
  0x03, 0x9E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xF0, 0x47, 0x9E, 0x1C,
  0xF3, 0xC7, 0x9C, 0x79, 0xE3, 0x8F, 0x3C, 0x71, 0xEF, 0x0F, 0x7F, 0xC1,
  0xFF, 0x70, 0x1F, 0xDE, 0x01, 0xF7, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x7C, 0x03, 0xDF, 0xC0, 0x77, 0xFC, 0x1F, 0xF7, 0x87, 0xBC, 0x71,
  0xE7, 0x8E, 0x38, 0xE3, 0xCF, 0x1C, 0x7B, 0xC3, 0x8F, 0x30, 0x7B, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE3, 0xE3, 0xFF,
  0x1F, 0x3F, 0xFD, 0xF3, 0xF7, 0xEF, 0x9F, 0x9F, 0xFC, 0xFC, 0xFF, 0xC7,
  0xE3, 0xFE, 0x3F, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0x3C, 0xF7, 0xDF,
  0x79, 0xE7, 0x9E, 0x73, 0xCF, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xC0, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x0B,
  0xCF, 0x3D, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFE, 0x01, 0xE7, 0x01, 0xE3, 0xC1, 0xE1, 0xF0, 0x70, 0x70, 0x10,
  0x20, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0xF8, 0xF0, 0x20, 0x7F,
  0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xFC, 0xF8, 0x7E, 0xFC, 0x3F,
  0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7D, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF,
  0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xF1, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x07, 0x81, 0xFC,
  0x3F, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0x7C, 0xC3, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCF,
  0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xF7, 0xC0, 0x7F, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF,
  0x07, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0xFE, 0x01, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xBE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFC,
  0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xF7,
  0xC1, 0xFB, 0xE1, 0xF9, 0xF8, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF9, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E, 0x00,
  0x78, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC3, 0xC0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x3F,
  0xFC, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x08, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x81, 0xE0,
  0x00, 0x70, 0x7C, 0x00, 0x0F, 0x0F, 0x07, 0xC1, 0xE3, 0xC1, 0xFE, 0x1C,
  0x78, 0x7F, 0xE3, 0x9E, 0x1F, 0xFC, 0x73, 0xC7, 0xC7, 0x8E, 0xF0, 0xF1,
  0xE1, 0xDE, 0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x87, 0xF1, 0xF0, 0xF0, 0xFE,
  0x3E, 0x3C, 0x3F, 0xC7, 0x87, 0x87, 0xF8, 0xF0, 0xF0, 0xFF, 0x1E, 0x1E,
  0x1D, 0xC3, 0xC7, 0xC3, 0xB8, 0x78, 0xF0, 0xE7, 0x0F, 0x1E, 0x1C, 0xE1,
  0xFF, 0xEF, 0x1C, 0x3F, 0xFF, 0xE3, 0x83, 0xF7, 0xF8, 0x78, 0x3C, 0x7C,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x01, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0,
  0x01, 0xF7, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00,
  0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xE0,
  0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xFD, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x1F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F,
  0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xF9, 0xF8, 0x7F,
  0xE7, 0xE1, 0xFF, 0x1F, 0x87, 0xFC, 0x7E, 0x3F, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xF0,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x8F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F, 0xC0,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x1F, 0x7C, 0x1F, 0x7C, 0x7F, 0xF0, 0x7D, 0xF1, 0xEF,
  0xC3, 0xF7, 0xCF, 0xBF, 0x0F, 0xDF, 0x3C, 0xFC, 0x3F, 0x3D, 0xF7, 0xE0,
  0xFC, 0xF7, 0xDF, 0x83, 0xF3, 0xDE, 0x7E, 0x0F, 0x8F, 0xF9, 0xF8, 0x7E,
  0x3F, 0xC7, 0xE1, 0xF8, 0xFF, 0x3F, 0x07, 0xE3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0,
  0xFC, 0x3F, 0x07, 0x87, 0xE0, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83,
  0xF8, 0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x7F, 0x81, 0xF8,
  0x3F, 0xC1, 0xF8, 0x1F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3F,
  0x07, 0xFE, 0x1F, 0x83, 0xF7, 0x9F, 0xC1, 0xFB, 0xCF, 0xC0, 0xFD, 0xE7,
  0xE0, 0xFC, 0xF3, 0xF0, 0x7E, 0x3D, 0xF8, 0x3F, 0x1E, 0xFC, 0x1F, 0x8F,
  0xFC, 0x0F, 0xC7, 0xFE, 0x07, 0xE1, 0xFF, 0x07, 0xE0, 0xFF, 0x83, 0xF0,
  0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0x8F, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x7F, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xF0, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x83, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x02, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F,
  0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F,
  0x87, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8,
  0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFE, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07,
  0xE3, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x80, 0xF8, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x7E, 0xFC, 0x1F, 0x87, 0xEF,
  0xC3, 0xF8, 0x7E, 0xFC, 0x3F, 0x8F, 0xCF, 0xC3, 0xF8, 0xFC, 0xFC, 0x7F,
  0x8F, 0xCF, 0xC7, 0xF8, 0xF8, 0xFC, 0x7F, 0x9F, 0x87, 0xCF, 0xF9, 0xF8,
  0x7C, 0xFF, 0x9F, 0x07, 0xCF, 0xFB, 0xF0, 0x7D, 0xFF, 0xBF, 0x07, 0xDF,
  0xFB, 0xE0, 0x7D, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC,
  0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x9F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0xFE, 0x03,
  0xFB, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xF7, 0x83, 0xDE, 0x1E, 0x78, 0xF9,
  0xE3, 0xC7, 0x9F, 0x1F, 0x7C, 0x3F, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0x00, 0x3F, 0x03, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xF7, 0xE7, 0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xF3, 0xE0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xEF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xF8, 0xFD, 0xFC, 0x3E, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFF, 0x7E, 0x3F, 0x7E, 0x1F, 0x7C, 0x1F, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x7E, 0xF8, 0x7E,
  0xFC, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C,
  0xFC, 0x1F, 0xEF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0,
  0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xF7, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF3, 0xF0, 0xF9, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x30, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC1, 0xFF, 0xE7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0xFF, 0x7C, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFB, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x81,
  0x03, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xEF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7C, 0x1F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x7F, 0x1F, 0x8F, 0xE1, 0xF9, 0xFC, 0x1F, 0xBF,
  0x81, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x9E, 0x0F, 0x83, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF1,
  0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x0F, 0x87, 0xE7, 0xE3, 0xF0, 0xFC, 0xF8,
  0x7E, 0x1F, 0xBF, 0x0F, 0xC3, 0xE7, 0xE1, 0xF8, 0xFC, 0xFC, 0x3F, 0x1F,
  0x9F, 0x87, 0xC3, 0xF3, 0xF1, 0xF8, 0x7E, 0x7C, 0x3F, 0x0F, 0xDF, 0x87,
  0xE1, 0xF3, 0xF0, 0xFC, 0x7E, 0x7E, 0x1F, 0x0F, 0xCF, 0xC7, 0xE1, 0xF8,
  0x1F, 0xBE, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF0, 0x7C,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x00,
  0x03, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0,
  0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xF7, 0xF0, 0x3F,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC7,
  0xC7, 0xFB, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xE7,
  0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xF1, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xBC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xF8, 0xFF, 0xE3, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF3, 0xE0,
  0xF9, 0xF8, 0x7C, 0xFC, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xFF, 0x7F,
  0xF7, 0xFE, 0xFF, 0xE1, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0x81, 0xF0, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x87, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0x7E, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF,
  0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8,
  0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x7C, 0x3F, 0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE7,
  0xE3, 0xEF, 0xCF, 0xCF, 0xDF, 0x9F, 0x9F, 0x3F, 0x7F, 0x3E, 0x7C, 0xFE,
  0xFC, 0xFB, 0xFD, 0xF1, 0xF7, 0xFB, 0xE3, 0xEF, 0xF7, 0xC3, 0xFD, 0xFF,
  0x07, 0xFB, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0,
  0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xC0, 0xF9, 0xFC, 0x0F,
  0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x20, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x7E,
  0x0F, 0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x40, 0x07, 0x07, 0x0F, 0x0F,
  0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF0,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x3C, 0xFF, 0x8F, 0xBF, 0xF1, 0xF7,
  0xFF, 0xFC, 0xF1, 0xFF, 0x9E, 0x1F, 0xE7, 0xC1, 0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 28, 10, 1, -28 },
  { 36, 12, 11, 12, 2, -30 },
  { 53, 20, 28, 20, 0, -28 },
  { 123, 18, 36, 20, 1, -32 },
  { 204, 19, 28, 25, 3, -28 },
  { 271, 21, 28, 23, 0, -28 },
  { 345, 6, 11, 6, 2, -30 },
  { 354, 12, 41, 13, 2, -32 },
  { 416, 13, 40, 13, -2, -31 },
  { 481, 17, 17, 18, 2, -28 },
  { 518, 17, 21, 18, 1, -24 },
  { 563, 8, 12, 10, -2, -5 },
  { 575, 11, 5, 15, 2, -15 },
  { 582, 6, 6, 12, 1, -6 },
  { 587, 18, 30, 12, -3, -28 },
  { 655, 17, 28, 20, 2, -28 },
  { 715, 13, 28, 20, 4, -28 },
  { 761, 19, 28, 20, 0, -28 },
  { 828, 19, 28, 20, 0, -28 },
  { 895, 18, 28, 20, 1, -28 },
  { 958, 19, 28, 20, 1, -28 },
  { 1025, 17, 28, 20, 1, -28 },
  { 1085, 20, 28, 20, 1, -28 },
  { 1155, 18, 28, 20, 1, -28 },
  { 1218, 16, 28, 20, 3, -28 },
  { 1274, 9, 22, 11, 1, -22 },
  { 1299, 12, 29, 11, -2, -22 },
  { 1343, 16, 19, 17, 1, -22 },
  { 1381, 18, 13, 20, 1, -19 },
  { 1411, 16, 19, 18, 1, -21 },
  { 1449, 15, 28, 18, 3, -28 },
  { 1502, 27, 37, 30, 1, -28 },
  { 1627, 23, 28, 23, -2, -28 },
  { 1708, 21, 28, 22, 0, -28 },
  { 1782, 21, 28, 22, 1, -28 },
  { 1856, 21, 28, 22, 0, -28 },
  { 1930, 21, 28, 19, 0, -28 },
  { 2004, 20, 28, 18, 0, -28 },
  { 2074, 22, 28, 23, 1, -28 },
  { 2151, 25, 28, 24, 0, -28 },
  { 2239, 11, 28, 11, 0, -28 },
  { 2278, 20, 28, 19, 0, -28 },
  { 2348, 25, 28, 22, 0, -28 },
  { 2436, 16, 28, 19, 0, -28 },
  { 2492, 30, 28, 29, 0, -28 },
  { 2597, 25, 28, 24, 0, -28 },
  { 2685, 22, 28, 23, 1, -28 },
  { 2762, 22, 28, 22, 0, -28 },
  { 2839, 22, 33, 23, 1, -28 },
  { 2930, 22, 28, 22, 0, -28 },
  { 3007, 20, 28, 21, 1, -28 },
  { 3077, 20, 28, 21, 3, -28 },
  { 3147, 22, 28, 22, 1, -28 },
  { 3224, 22, 28, 23, 3, -28 },
  { 3301, 28, 28, 29, 3, -28 },
  { 3399, 26, 28, 22, -2, -28 },
  { 3490, 21, 28, 21, 3, -28 },
  { 3564, 23, 28, 21, -1, -28 },
  { 3645, 14, 40, 10, -1, -33 },
  { 3715, 10, 30, 15, 3, -28 },
  { 3753, 14, 40, 10, -2, -33 },
  { 3823, 14, 14, 15, 1, -28 },
  { 3848, 15, 5, 15, -2, 0 },
  { 3858, 9, 6, 13, 4, -30 },
  { 3865, 17, 21, 18, 0, -21 },
  { 3910, 18, 30, 19, 0, -30 },
  { 3978, 16, 21, 18, 1, -21 },
  { 4020, 20, 30, 19, 1, -30 },
  { 4095, 17, 21, 19, 1, -21 },
  { 4140, 14, 30, 13, 1, -30 },
  { 4193, 19, 29, 20, 0, -21 },
  { 4262, 18, 30, 19, 0, -30 },
  { 4330, 11, 29, 10, 0, -29 },
  { 4370, 16, 37, 10, -5, -29 },
  { 4444, 20, 30, 19, 0, -30 },
  { 4519, 11, 30, 10, 0, -30 },
  { 4561, 27, 21, 29, 0, -21 },
  { 4632, 18, 21, 19, 0, -21 },
  { 4680, 17, 21, 19, 1, -21 },
  { 4725, 20, 29, 19, -2, -21 },
  { 4798, 18, 29, 19, 1, -21 },
  { 4864, 14, 21, 13, 0, -21 },
  { 4901, 17, 21, 18, 0, -21 },
  { 4946, 12, 26, 12, 1, -26 },
  { 4985, 18, 21, 19, 1, -21 },
  { 5033, 17, 21, 18, 2, -21 },
  { 5078, 23, 21, 24, 2, -21 },
  { 5139, 20, 21, 18, -1, -21 },
  { 5192, 20, 29, 18, -1, -21 },
  { 5265, 19, 21, 18, -1, -21 },
  { 5315, 12, 38, 11, 1, -31 },
  { 5372, 8, 33, 10, 1, -28 },
  { 5405, 12, 38, 11, -1, -31 },
  { 5462, 19, 9, 21, 1, -16 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC40PT7B_H_
