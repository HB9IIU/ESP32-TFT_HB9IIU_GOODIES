#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC9PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x30, 0x74, 0x31, 0x9E, 0xCF, 0x32, 0x80, 0x13, 0x54,
  0x61, 0xD6, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x32, 0x9C, 0xCF, 0xD9, 0xC0,
  0x50, 0x2D, 0x2D, 0x22, 0x40, 0x55, 0x56, 0x80, 0x27, 0x65, 0x22, 0xF6,
  0x40, 0x54, 0xC0, 0xC0, 0x11, 0x22, 0x24, 0x44, 0x35, 0x5D, 0xDF, 0x60,
  0x7D, 0x24, 0xB0, 0x75, 0x13, 0x64, 0xF0, 0x75, 0x12, 0x1B, 0x60, 0x13,
  0x57, 0xF2, 0x20, 0x74, 0x71, 0x1F, 0x60, 0x36, 0x7D, 0xDD, 0x60, 0x78,
  0x8C, 0x42, 0x21, 0x00, 0x75, 0x56, 0xDF, 0x60, 0x76, 0xDE, 0xB0, 0x40,
  0xC0, 0x40, 0xA8, 0x1E, 0xE2, 0x70, 0xF0, 0x47, 0x78, 0xF5, 0xA8, 0x20,
  0x3D, 0x15, 0xEB, 0xB6, 0xB8, 0x1C, 0x31, 0x8C, 0xA5, 0x7E, 0x60, 0x72,
  0xD6, 0xED, 0x6B, 0xC0, 0x3A, 0x51, 0x8C, 0x69, 0xC0, 0x72, 0xD6, 0xBD,
  0x6B, 0x80, 0x7A, 0x10, 0xEC, 0x63, 0xC0, 0x7A, 0x10, 0xEC, 0x62, 0x00,
  0x3A, 0x51, 0xBD, 0xED, 0xC0, 0x49, 0x24, 0x9E, 0xDB, 0x69, 0x80, 0x49,
  0x2D, 0xB0, 0x10, 0x84, 0x23, 0x5B, 0x80, 0x49, 0x67, 0x18, 0xF3, 0x49,
  0x00, 0x44, 0x44, 0xCC, 0xF0, 0x66, 0xDD, 0xB3, 0x6F, 0x5E, 0xAF, 0x00,
  0x69, 0xA6, 0x9A, 0xDB, 0x69, 0x00, 0x32, 0x53, 0x9D, 0xE9, 0xC0, 0x72,
  0x52, 0xBF, 0x62, 0x00, 0x32, 0x53, 0x9D, 0xE9, 0xC2, 0x72, 0xD6, 0xEF,
  0x6A, 0x40, 0x32, 0xD0, 0xE1, 0x69, 0xC0, 0xF4, 0x44, 0x4C, 0xC0, 0x4A,
  0x56, 0xBD, 0xE9, 0xC0, 0x94, 0xAD, 0x4A, 0x63, 0x00, 0xAE, 0xBE, 0xBA,
  0xFB, 0xCB, 0x00, 0x4B, 0xDC, 0x47, 0x6B, 0x40, 0x9B, 0xAE, 0x4C, 0xC0,
  0x78, 0x8C, 0x44, 0x63, 0xC0, 0x69, 0x2D, 0xA4, 0xC0, 0xAA, 0xFD, 0x32,
  0x22, 0x26, 0x64, 0x40, 0x2D, 0x80, 0x70, 0x90, 0x77, 0x7A, 0xE0, 0x44,
  0x75, 0xDD, 0xE0, 0x6D, 0xCB, 0x60, 0x18, 0x9D, 0xAD, 0x5B, 0xC0, 0x7D,
  0xFC, 0x60, 0x2B, 0xA5, 0xB0, 0x7D, 0xDD, 0xF2, 0xE0, 0x44, 0x7D, 0xDB,
  0xB0, 0x45, 0xF8, 0x20, 0x96, 0xD2, 0xC0, 0x42, 0x14, 0xCE, 0x72, 0xC0,
  0x55, 0xF8, 0x7D, 0x5D, 0x7D, 0xBC, 0x75, 0xDB, 0xB0, 0x7D, 0xD9, 0x60,
  0x75, 0xDD, 0xE8, 0x80, 0x7D, 0xDB, 0xF2, 0x20, 0x6B, 0x68, 0x6D, 0x6A,
  0xE0, 0x5D, 0x2C, 0x80, 0x55, 0xDF, 0xF0, 0xD7, 0x66, 0x40, 0xFF, 0xBD,
  0x6A, 0x00, 0x56, 0x66, 0xA0, 0xD7, 0x66, 0x44, 0x80, 0x72, 0x6C, 0xE0,
  0x29, 0x28, 0xB6, 0x40, 0x55, 0x6A, 0x55, 0x5E, 0x80, 0x7B,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 2, 3, 0, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 4, 9, 4, 0, -8 },
  { 15, 4, 7, 6, 1, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 2, 2, 1, 0, -7 },
  { 25, 3, 9, 3, 0, -7 },
  { 29, 2, 9, 3, 0, -7 },
  { 32, 4, 4, 4, 0, -7 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 2, 3, 2, -1, -1 },
  { 38, 2, 1, 3, 1, -3 },
  { 39, 2, 1, 3, 0, -1 },
  { 40, 4, 8, 3, -1, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 3, 7, 4, 1, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 5, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 3, 7, 4, 1, -7 },
  { 83, 2, 5, 3, 0, -5 },
  { 85, 2, 7, 2, 0, -5 },
  { 87, 4, 4, 4, 0, -5 },
  { 89, 4, 3, 4, 0, -4 },
  { 91, 4, 4, 4, 0, -5 },
  { 93, 3, 7, 4, 1, -7 },
  { 96, 6, 8, 7, 0, -6 },
  { 102, 5, 7, 5, 0, -7 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 5, 7, 5, 0, -7 },
  { 117, 5, 7, 5, 0, -7 },
  { 122, 5, 7, 4, 0, -7 },
  { 127, 5, 7, 4, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 6, 7, 5, 0, -7 },
  { 143, 3, 7, 2, 0, -7 },
  { 146, 5, 7, 4, 0, -7 },
  { 151, 6, 7, 5, 0, -7 },
  { 157, 4, 7, 4, 0, -7 },
  { 161, 7, 7, 7, 0, -7 },
  { 168, 6, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 5, 8, 5, 0, -7 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 5, 7, 5, 0, -7 },
  { 199, 4, 7, 5, 1, -7 },
  { 203, 5, 7, 5, 0, -7 },
  { 208, 5, 7, 5, 1, -7 },
  { 213, 6, 7, 7, 1, -7 },
  { 219, 5, 7, 5, 0, -7 },
  { 224, 4, 7, 5, 1, -7 },
  { 228, 5, 7, 5, 0, -7 },
  { 233, 3, 9, 2, 0, -7 },
  { 237, 2, 8, 3, 1, -7 },
  { 239, 4, 9, 2, -1, -7 },
  { 244, 3, 3, 3, 0, -7 },
  { 246, 4, 1, 3, -1, 0 },
  { 247, 2, 2, 3, 1, -7 },
  { 248, 4, 5, 4, 0, -5 },
  { 251, 4, 7, 4, 0, -7 },
  { 255, 4, 5, 4, 0, -5 },
  { 258, 5, 7, 4, 0, -7 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 3, 7, 3, 0, -7 },
  { 269, 4, 7, 4, 0, -5 },
  { 273, 4, 7, 4, 0, -7 },
  { 277, 2, 7, 2, 0, -7 },
  { 279, 3, 9, 2, -1, -7 },
  { 283, 5, 7, 4, 0, -7 },
  { 288, 2, 7, 2, 0, -7 },
  { 290, 6, 5, 6, 0, -5 },
  { 294, 4, 5, 4, 0, -5 },
  { 297, 4, 5, 4, 0, -5 },
  { 300, 4, 7, 4, 0, -5 },
  { 304, 4, 7, 4, 0, -5 },
  { 308, 3, 5, 3, 0, -5 },
  { 310, 4, 5, 4, 0, -5 },
  { 313, 3, 6, 3, 0, -6 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 4, 5, 4, 0, -5 },
  { 322, 5, 5, 5, 1, -5 },
  { 326, 4, 5, 4, 0, -5 },
  { 329, 4, 7, 4, 0, -5 },
  { 333, 4, 5, 4, 0, -5 },
  { 336, 3, 9, 3, 0, -7 },
  { 340, 2, 8, 2, 0, -7 },
  { 342, 2, 9, 3, 0, -7 },
  { 345, 4, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC9PT7B_H_
