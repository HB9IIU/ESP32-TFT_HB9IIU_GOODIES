#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC27PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x73, 0xB9, 0x9D, 0xCE,
  0xE6, 0x73, 0x33, 0x98, 0x01, 0x98, 0x0E, 0xE0, 0x3B, 0x00, 0xCC, 0x07,
  0x70, 0x1D, 0x83, 0xFF, 0xCF, 0xFE, 0x0E, 0xC0, 0x33, 0x00, 0xDC, 0x1F,
  0xFC, 0xFF, 0xF0, 0x6E, 0x03, 0xB8, 0x0C, 0xC0, 0x33, 0x01, 0xDC, 0x07,
  0x60, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x7C, 0x1F, 0xE1, 0xFE, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x08,
  0x01, 0x80, 0x18, 0x00, 0x3C, 0x03, 0xF0, 0x1D, 0x8C, 0xCE, 0x6E, 0x77,
  0x73, 0x73, 0xBB, 0x0F, 0xF8, 0x3F, 0x80, 0x38, 0x01, 0xBC, 0x1F, 0xE1,
  0xFB, 0x8D, 0xCC, 0xCC, 0xEE, 0x67, 0x63, 0xB8, 0x1F, 0x80, 0x78, 0x03,
  0xC0, 0x1F, 0x80, 0xFF, 0x07, 0xBC, 0x1E, 0x70, 0x73, 0xC1, 0xEE, 0x07,
  0xF8, 0x0F, 0x80, 0x7C, 0x73, 0xFB, 0xDF, 0xEF, 0x7B, 0xFB, 0xCF, 0xEF,
  0x1F, 0x3E, 0x7C, 0x7F, 0xF1, 0xFF, 0xE1, 0xF7, 0x80, 0x33, 0x9C, 0xE7,
  0x31, 0x80, 0x01, 0x01, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x04, 0x00, 0x08, 0x0C, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0xF0, 0xE0, 0x80,
  0x03, 0x00, 0x30, 0x03, 0x04, 0x73, 0x7E, 0xF7, 0xFF, 0x0F, 0x81, 0xF0,
  0x3B, 0x07, 0xB8, 0x71, 0xC2, 0x10, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x78, 0x00, 0x1C, 0x71, 0xCF, 0x39, 0xE7, 0x18, 0xFF, 0xFB, 0xF0, 0x7B,
  0xDE, 0xE0, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x81,
  0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xFF,
  0x0E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0x7F, 0x87,
  0xF0, 0x3E, 0x00, 0x03, 0x0F, 0x7F, 0xFF, 0xFF, 0xDE, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x7D, 0xF3, 0xC7, 0x9E, 0x3C, 0x01, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x7D, 0xF3,
  0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x01,
  0xC0, 0x0F, 0x78, 0x7B, 0xC3, 0xCF, 0x3C, 0x7F, 0xE1, 0xFE, 0x07, 0xC0,
  0x00, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC1,
  0xDE, 0x1D, 0xE1, 0xEF, 0x0E, 0x78, 0xF3, 0xC7, 0xFF, 0x3F, 0xFB, 0xFF,
  0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3,
  0xC0, 0x38, 0x03, 0x80, 0x7F, 0x87, 0xFC, 0x7F, 0xC3, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x1E, 0x00,
  0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x78, 0x1E, 0xE3, 0xFE, 0x7F,
  0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xDE, 0x7F, 0xC7,
  0xF0, 0x78, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC1,
  0xFE, 0x1F, 0xE3, 0xCF, 0x3C, 0xF3, 0x8F, 0x38, 0xF3, 0xDE, 0x1F, 0xC3,
  0xF8, 0x7F, 0xCF, 0x1C, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xFF, 0xC7,
  0xF8, 0x3E, 0x00, 0x0F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x7B, 0xFF, 0x3F, 0xE3, 0xFC, 0x0F, 0x03, 0xE1,
  0xF8, 0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xF3, 0xCE, 0x00, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70,
  0xE0, 0x40, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFC, 0xFC, 0x1E, 0x03,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x01, 0xC0, 0x08, 0x7F, 0xEF, 0xFD, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0x10, 0x07, 0x80,
  0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xC1, 0xF8, 0xFF, 0x7F, 0x8F, 0x81, 0xC0,
  0x60, 0x00, 0x1F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xC0, 0xF0, 0x7C, 0x1E,
  0x1F, 0x07, 0x83, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x1E,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x0E, 0x03, 0x80, 0xE0,
  0xE0, 0x0C, 0x38, 0x01, 0xC7, 0x1E, 0x19, 0xC7, 0xF3, 0x39, 0xEE, 0x6E,
  0x39, 0x8D, 0xCE, 0x31, 0xB9, 0xCE, 0x36, 0x71, 0xCF, 0xCE, 0x31, 0xB9,
  0xCE, 0x37, 0x39, 0xCE, 0xE7, 0xF9, 0x9C, 0x7B, 0xE1, 0x8E, 0x38, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x9C, 0x00, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0xF1,
  0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xBE, 0x0F, 0x78, 0x1F, 0xF0, 0x3F,
  0xC0, 0x78, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF3, 0xE1, 0xE3, 0xC7,
  0x87, 0x8F, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xC3, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0,
  0xF7, 0x83, 0xDE, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x7B, 0xC1, 0xEF, 0x0F, 0x3E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xBF, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0x78, 0x79, 0xE1,
  0xE7, 0x8F, 0x9E, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0x87, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0,
  0xFF, 0x87, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x9F, 0x3C, 0x3D, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE7, 0xFF,
  0x1F, 0xBC, 0x7E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x9F, 0x7E, 0x7F, 0xF0,
  0xFF, 0x81, 0xF8, 0x00, 0x1E, 0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x3E, 0x3C, 0x1E, 0x00, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x78, 0xF3, 0xC7, 0x9F, 0x78, 0x7F, 0xC3, 0xFC, 0x07, 0xC0, 0x1E,
  0x1F, 0x0F, 0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x81, 0xEF, 0x81, 0xE7, 0x80,
  0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xDE, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78,
  0x7C, 0x3C, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x81, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xDE, 0x7B, 0x9D, 0xE7, 0xBB,
  0xBC, 0x79, 0xBB, 0xC7, 0x9F, 0x3C, 0x79, 0xF3, 0xC7, 0x9F, 0x3C, 0xF9,
  0xE7, 0xCF, 0x1E, 0x78, 0xF1, 0xC7, 0x80, 0x1E, 0x0F, 0x0F, 0x87, 0x87,
  0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF1, 0xFC, 0x78, 0xFE, 0x78, 0x7F, 0x3C,
  0x3D, 0x9E, 0x1E, 0xEF, 0x1F, 0x77, 0x8F, 0x3F, 0xC7, 0x8F, 0xC3, 0xC7,
  0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x00,
  0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1,
  0xEF, 0x0F, 0x9F, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x1F, 0x3C, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x9F, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xE0, 0x01,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF3, 0xE1, 0xE3, 0xC7, 0x87,
  0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x7C, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xF3, 0xC3,
  0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xC7, 0xDF, 0x1E, 0x3C, 0xF0, 0xF1,
  0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x79,
  0xE1, 0xE7, 0x8F, 0x9F, 0x7C, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C,
  0x3C, 0x7C, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xF0, 0x3F, 0xF0,
  0x7B, 0xE1, 0xF7, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8,
  0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0xE1, 0xFE,
  0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF1, 0xEF, 0x3E, 0x79, 0xE7, 0xCF, 0x3C,
  0xF9, 0xE7, 0xBF, 0x78, 0xF7, 0xEF, 0x1E, 0xFD, 0xE3, 0xFF, 0xB8, 0x7F,
  0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0x7C,
  0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x87, 0x87, 0x83,
  0xC7, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x3E, 0x3E, 0x3E, 0x1F, 0x00,
  0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0x79, 0xF1, 0xE7, 0x83, 0xBC,
  0x0E, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xC3,
  0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x0F, 0xC0, 0xF1, 0xE3, 0xC7, 0x87,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x78, 0xF1, 0xE0, 0x07, 0xC3, 0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0x0F, 0x07, 0x87, 0xC3, 0xE3, 0xB1, 0xD9, 0xCE, 0xE7, 0x73, 0xF1,
  0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x00, 0xF1, 0xE3, 0x8E, 0x0F, 0x81, 0xFE,
  0x3F, 0xE3, 0xDE, 0x79, 0xE0, 0x1E, 0x1F, 0xE3, 0xFE, 0x79, 0xEF, 0x1E,
  0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xFC, 0x3B, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3D, 0xC3, 0xFE, 0x3F, 0xF3, 0xCF, 0x3C,
  0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x9E, 0xFF,
  0xEF, 0xFC, 0xF7, 0x80, 0x07, 0x81, 0xFC, 0x3F, 0xE3, 0xDE, 0x78, 0xF7,
  0x8F, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x71, 0xE7, 0xBC, 0x7F, 0xC3,
  0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0xF7, 0x87, 0xDE, 0x3F, 0xF1, 0xF7, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xCF, 0x0E, 0x3C, 0x78, 0xF1, 0xE1, 0xE7, 0x87, 0xFE,
  0x1F, 0xF8, 0x3D, 0xC0, 0x0F, 0x07, 0xF9, 0xFF, 0x3C, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0xCF, 0xF8, 0xFF, 0x0F,
  0xC0, 0x07, 0x87, 0xC7, 0xE3, 0xC3, 0xC1, 0xE3, 0xFD, 0xFE, 0xFF, 0x1E,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x00, 0x0F, 0x78, 0xFF, 0xCF, 0xFE, 0x79, 0xF7, 0x8F, 0x3C, 0x79, 0xE3,
  0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x9C, 0x78, 0xF3, 0xC7, 0xFE, 0x3F, 0xF0,
  0x77, 0x80, 0x78, 0x43, 0xC7, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3D, 0xC3, 0xFE, 0x3F, 0xF3,
  0xDF, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xC0, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x0F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE3, 0xF0, 0xF8, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x3E,
  0x3D, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xE0, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x00, 0x3D, 0xE7, 0x8F, 0xFB, 0xF3, 0xFF,
  0xFC, 0xF7, 0xEF, 0x3C, 0xF3, 0xDE, 0x3C, 0xF7, 0x8F, 0x3D, 0xE3, 0xCF,
  0x79, 0xE3, 0xDE, 0x78, 0xF7, 0x9E, 0x3B, 0xC7, 0x9E, 0xF1, 0xE7, 0xBC,
  0x79, 0xEF, 0x3C, 0x78, 0x3D, 0xE3, 0xFE, 0x3F, 0xF3, 0xDF, 0x78, 0xF7,
  0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0xCF, 0x78, 0xF7, 0x8F,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xE7, 0x9E, 0x7F, 0xC3, 0xFC,
  0x1F, 0x00, 0x1E, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0xF9, 0xE7, 0xFF, 0x3F,
  0xF1, 0xEF, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F,
  0x78, 0xFF, 0xCF, 0xFC, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E,
  0x71, 0xE7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x3D, 0x9F, 0xCF, 0xE7,
  0xF3, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF7, 0x8E, 0xF8, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7B, 0xC7, 0x79, 0xEF, 0xFC, 0xFF, 0x0F, 0x80, 0x3C, 0x3C,
  0x3C, 0xFF, 0xFE, 0xFE, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xF0, 0xFC, 0x7C, 0x38, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x9E, 0x71, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x7C, 0xFF, 0xCF,
  0xFC, 0x7B, 0xC0, 0xF1, 0xEF, 0x1E, 0x71, 0xE7, 0x3C, 0x73, 0xC7, 0x38,
  0x77, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x00, 0xE3, 0x9F, 0xCF, 0x3F, 0x9E, 0x77, 0x3D, 0xEE, 0xFB, 0xDD,
  0xF7, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xF7, 0xE3, 0xEF, 0xC7, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x79, 0xE1, 0xEF,
  0x07, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0x70, 0x7D, 0xE1, 0xE7, 0x8F, 0x9E, 0x00, 0x3C, 0x7C,
  0xF1, 0xE1, 0xC7, 0x87, 0x3C, 0x1E, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x02, 0x07, 0x0E, 0x1C,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0xE0, 0xF0, 0x70,
  0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x10, 0x0C, 0x30,
  0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x71, 0xC6,
  0x18, 0x61, 0x8E, 0x00, 0x08, 0x0C, 0x0E, 0x0E, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0x3C, 0x37, 0xE7, 0xFF, 0x7F, 0x7F,
  0xE3, 0xE0, 0x1C,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 8, 1, -20 },
  { 28, 14, 19, 14, 0, -19 },
  { 62, 12, 25, 13, 1, -22 },
  { 100, 13, 19, 17, 2, -19 },
  { 131, 14, 19, 15, 0, -19 },
  { 165, 5, 7, 4, 1, -20 },
  { 170, 9, 27, 8, 1, -21 },
  { 201, 8, 27, 8, -1, -21 },
  { 228, 12, 12, 12, 1, -19 },
  { 246, 11, 14, 12, 1, -16 },
  { 266, 6, 8, 7, -2, -3 },
  { 272, 7, 3, 10, 2, -10 },
  { 275, 5, 4, 8, 0, -4 },
  { 278, 12, 21, 8, -2, -19 },
  { 310, 12, 19, 13, 1, -19 },
  { 339, 8, 19, 13, 3, -19 },
  { 358, 13, 19, 13, 0, -19 },
  { 389, 13, 19, 13, 0, -19 },
  { 420, 13, 19, 13, 0, -19 },
  { 451, 12, 19, 13, 1, -19 },
  { 480, 11, 19, 13, 1, -19 },
  { 507, 13, 19, 13, 1, -19 },
  { 538, 12, 19, 13, 1, -19 },
  { 567, 11, 19, 13, 2, -19 },
  { 594, 6, 15, 8, 1, -15 },
  { 606, 8, 20, 7, -1, -15 },
  { 626, 11, 13, 12, 0, -15 },
  { 644, 11, 9, 13, 1, -13 },
  { 657, 11, 12, 12, 0, -14 },
  { 674, 10, 19, 12, 2, -19 },
  { 698, 19, 25, 20, 0, -19 },
  { 758, 15, 19, 16, -1, -19 },
  { 794, 15, 19, 15, 0, -19 },
  { 830, 14, 19, 15, 1, -19 },
  { 864, 14, 19, 15, 0, -19 },
  { 898, 14, 19, 13, 0, -19 },
  { 932, 14, 19, 12, 0, -19 },
  { 966, 14, 19, 15, 1, -19 },
  { 1000, 17, 19, 16, 0, -19 },
  { 1041, 8, 19, 7, 0, -19 },
  { 1060, 13, 19, 13, 0, -19 },
  { 1091, 17, 19, 15, 0, -19 },
  { 1132, 11, 19, 13, 0, -19 },
  { 1159, 20, 19, 20, 0, -19 },
  { 1207, 17, 19, 16, 0, -19 },
  { 1248, 14, 19, 16, 1, -19 },
  { 1282, 15, 19, 15, 0, -19 },
  { 1318, 14, 22, 16, 1, -19 },
  { 1357, 15, 19, 15, 0, -19 },
  { 1393, 14, 19, 14, 0, -19 },
  { 1427, 14, 19, 14, 2, -19 },
  { 1461, 15, 19, 15, 1, -19 },
  { 1497, 15, 19, 15, 2, -19 },
  { 1533, 19, 19, 20, 2, -19 },
  { 1579, 17, 19, 15, -1, -19 },
  { 1620, 14, 19, 14, 2, -19 },
  { 1654, 15, 19, 14, 0, -19 },
  { 1690, 10, 27, 7, -1, -22 },
  { 1724, 7, 21, 10, 2, -19 },
  { 1743, 10, 27, 7, -2, -22 },
  { 1777, 9, 10, 10, 1, -19 },
  { 1789, 11, 3, 10, -2, 0 },
  { 1794, 6, 4, 9, 3, -20 },
  { 1797, 12, 15, 12, 0, -15 },
  { 1820, 12, 21, 13, 0, -21 },
  { 1852, 12, 15, 12, 0, -15 },
  { 1875, 14, 21, 13, 0, -21 },
  { 1912, 11, 15, 13, 1, -15 },
  { 1933, 9, 21, 9, 1, -21 },
  { 1957, 13, 20, 13, 0, -15 },
  { 1990, 12, 21, 13, 0, -21 },
  { 2022, 7, 21, 7, 0, -21 },
  { 2041, 10, 26, 7, -3, -21 },
  { 2074, 14, 21, 13, 0, -21 },
  { 2111, 7, 21, 7, 0, -21 },
  { 2130, 18, 15, 19, 0, -15 },
  { 2164, 12, 15, 13, 0, -15 },
  { 2187, 12, 15, 13, 0, -15 },
  { 2210, 13, 20, 13, -1, -15 },
  { 2243, 13, 20, 13, 0, -15 },
  { 2276, 9, 15, 9, 0, -15 },
  { 2293, 11, 15, 12, 0, -15 },
  { 2314, 8, 18, 8, 1, -18 },
  { 2332, 12, 15, 13, 1, -15 },
  { 2355, 12, 15, 12, 1, -15 },
  { 2378, 15, 15, 16, 2, -15 },
  { 2407, 14, 15, 12, -1, -15 },
  { 2434, 14, 20, 12, -1, -15 },
  { 2469, 12, 15, 12, 0, -15 },
  { 2492, 8, 26, 8, 1, -21 },
  { 2518, 6, 23, 7, 0, -19 },
  { 2536, 8, 26, 8, -1, -21 },
  { 2562, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC27PT7B_H_
