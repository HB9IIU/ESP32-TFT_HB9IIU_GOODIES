#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x64, 0x0C, 0xC0, 0xD9, 0xBA, 0x09, 0x04, 0x86,
  0x8F, 0xF1, 0x20, 0xB0, 0x91, 0xFE, 0x2C, 0x34, 0x12, 0x00, 0x04, 0x3C,
  0xA9, 0x43, 0x83, 0x07, 0x0A, 0x95, 0xF8, 0x81, 0x00, 0x30, 0x94, 0x4D,
  0x32, 0x48, 0x94, 0xAF, 0xF6, 0xAC, 0x5B, 0x34, 0x89, 0x24, 0x30, 0x0C,
  0x0B, 0x0C, 0x86, 0xC1, 0xC1, 0xC1, 0xA7, 0x9E, 0xC6, 0x67, 0x1E, 0xC0,
  0xEA, 0x08, 0x8C, 0x46, 0x21, 0x08, 0xC6, 0x10, 0x86, 0x00, 0x10, 0x86,
  0x31, 0x8C, 0x62, 0x11, 0x88, 0xCC, 0x00, 0x18, 0xA3, 0xF9, 0x86, 0x89,
  0x00, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x2D, 0x60, 0x7F, 0xF0, 0x03,
  0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x19, 0xB4,
  0x71, 0xC6, 0x18, 0xE3, 0x8A, 0x6F, 0x00, 0x17, 0xFB, 0x22, 0x26, 0x64,
  0x40, 0x1C, 0x6C, 0x08, 0x10, 0x61, 0x86, 0x18, 0x61, 0x83, 0xF0, 0x1C,
  0x6C, 0x08, 0x10, 0x47, 0x03, 0x02, 0x05, 0x1B, 0xE0, 0x06, 0x0C, 0x38,
  0xF3, 0x44, 0x91, 0x7F, 0xFE, 0x10, 0x20, 0x1E, 0x7C, 0xC1, 0x03, 0x8F,
  0x81, 0x83, 0x05, 0x1B, 0xE0, 0x1E, 0x65, 0x82, 0x0F, 0x9D, 0xB3, 0x46,
  0x8D, 0xB3, 0xC0, 0x7F, 0xFC, 0x10, 0x61, 0x82, 0x0C, 0x10, 0x60, 0x83,
  0x00, 0x1C, 0x6C, 0x89, 0x13, 0x67, 0x1B, 0x23, 0xC7, 0x89, 0xE0, 0x1C,
  0x6D, 0x8B, 0x16, 0x6C, 0xCF, 0x82, 0x0C, 0x33, 0xC0, 0x2C, 0x00, 0x36,
  0x13, 0x00, 0x00, 0x26, 0x4C, 0x04, 0x77, 0x30, 0x60, 0x70, 0x40, 0xFC,
  0x00, 0x3F, 0x83, 0x83, 0x83, 0x1D, 0xC8, 0x00, 0x76, 0xC2, 0x11, 0x11,
  0x08, 0x06, 0x30, 0x0F, 0x0E, 0x66, 0x05, 0x3D, 0x9A, 0x64, 0x9A, 0x26,
  0x9A, 0xBB, 0xA0, 0x0C, 0x01, 0xF8, 0x06, 0x06, 0x0E, 0x0A, 0x1B, 0x13,
  0x33, 0x3F, 0x63, 0x43, 0xC3, 0x1E, 0x3F, 0x31, 0x23, 0x22, 0x3C, 0x66,
  0x62, 0x42, 0x46, 0xFC, 0x1F, 0x3E, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0xC0, 0xC4, 0x7C, 0x1C, 0x1F, 0x8C, 0x44, 0x32, 0x19, 0x0D, 0x84, 0xC6,
  0x42, 0x27, 0x3E, 0x00, 0x1F, 0x3E, 0x30, 0x20, 0x20, 0x3C, 0x60, 0x60,
  0x40, 0x40, 0xFC, 0x1F, 0x3E, 0x30, 0x20, 0x20, 0x3C, 0x7C, 0x60, 0x40,
  0x40, 0xC0, 0x0F, 0x3B, 0x60, 0x40, 0xC0, 0xCF, 0x8E, 0x82, 0xC6, 0xC6,
  0x7C, 0x10, 0x98, 0x4C, 0x64, 0x32, 0x19, 0xF9, 0x84, 0xC6, 0x43, 0x21,
  0x30, 0x80, 0x3C, 0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x8F, 0x00, 0x04,
  0x30, 0xC3, 0x08, 0x21, 0x86, 0x10, 0x43, 0x0C, 0xE3, 0x80, 0x11, 0x99,
  0x8D, 0x84, 0x82, 0xC1, 0xC1, 0xA0, 0xD8, 0x4C, 0x22, 0x31, 0x80, 0x10,
  0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0F, 0xC0, 0x18, 0x33, 0x87, 0x28,
  0x62, 0x8A, 0x28, 0xA2, 0x96, 0x69, 0x64, 0xA4, 0x4A, 0x44, 0xCC, 0xCC,
  0xC0, 0x10, 0xCE, 0x32, 0x88, 0xA2, 0x2C, 0x9B, 0x66, 0x59, 0x94, 0x47,
  0x10, 0xCC, 0x30, 0x1E, 0x3F, 0x63, 0x41, 0xC1, 0xC1, 0x83, 0x83, 0xC6,
  0xCE, 0x7C, 0x1C, 0x3F, 0x33, 0x23, 0x23, 0x26, 0x7C, 0x60, 0x40, 0x40,
  0xC0, 0x1E, 0x3F, 0x63, 0x41, 0xC1, 0xC1, 0x83, 0x83, 0xC6, 0xCE, 0x78,
  0x08, 0x0C, 0x04, 0x1C, 0x3F, 0x33, 0x23, 0x23, 0x3E, 0x7C, 0x6C, 0x44,
  0x44, 0xC6, 0x1E, 0x7C, 0x83, 0x03, 0x07, 0x03, 0x06, 0x0D, 0x1B, 0xE0,
  0x7F, 0xFC, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x00, 0x61, 0x61,
  0x63, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0x86, 0xCC, 0x78, 0xC3, 0xC2, 0xC6,
  0x44, 0x4C, 0x48, 0x58, 0x50, 0x50, 0x60, 0x60, 0xC2, 0x1C, 0x63, 0xC6,
  0x24, 0xE6, 0x4A, 0x45, 0xAC, 0x52, 0xC7, 0x28, 0x63, 0x86, 0x30, 0x43,
  0x00, 0x10, 0xC6, 0x61, 0xB0, 0x28, 0x0E, 0x03, 0x01, 0xC0, 0x50, 0x36,
  0x19, 0x8C, 0x20, 0xC2, 0x8D, 0x32, 0x47, 0x8E, 0x0C, 0x10, 0x60, 0xC1,
  0x00, 0x3F, 0x3E, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xFC,
  0x3C, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x20, 0xE0, 0xAA, 0xFD,
  0x54, 0x1C, 0xA0, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0xE0, 0x08,
  0x30, 0x71, 0x22, 0x48, 0x70, 0x80, 0xF8, 0xCC, 0x7E, 0x9B, 0x14, 0x68,
  0xD1, 0xA6, 0x74, 0x30, 0x60, 0xC1, 0x73, 0x2C, 0x58, 0xA1, 0x46, 0xDB,
  0xE0, 0x3A, 0x31, 0x08, 0x43, 0x3E, 0x02, 0x0C, 0x1B, 0xF4, 0xD8, 0xA3,
  0x46, 0x89, 0x33, 0xA0, 0x39, 0x3C, 0xFE, 0xC2, 0x08, 0xBE, 0x07, 0x0C,
  0x0C, 0x1E, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0xE0,
  0xC0, 0x3F, 0x26, 0x62, 0x46, 0x46, 0x46, 0x4C, 0x74, 0x0C, 0x0C, 0xF8,
  0x60, 0x30, 0x60, 0xC1, 0x73, 0x2C, 0x59, 0xA3, 0x46, 0x8B, 0x10, 0x31,
  0x02, 0x26, 0x64, 0x44, 0xC0, 0x0C, 0x10, 0x02, 0x08, 0x61, 0x84, 0x10,
  0x43, 0x0C, 0x23, 0x8C, 0x00, 0x30, 0x30, 0x31, 0x26, 0x2C, 0x68, 0x78,
  0x78, 0x48, 0x4C, 0xCC, 0x33, 0x32, 0x26, 0x64, 0x44, 0xC0, 0x2E, 0xE6,
  0xE5, 0x88, 0xB3, 0x34, 0x66, 0x88, 0xD1, 0x16, 0x66, 0x2E, 0x65, 0x8B,
  0x34, 0x68, 0xD1, 0x66, 0x79, 0x3C, 0x61, 0x8E, 0x39, 0xBC, 0x17, 0x19,
  0x31, 0x31, 0x21, 0x23, 0x36, 0x7C, 0x60, 0x40, 0x40, 0xC0, 0x7E, 0x9B,
  0x14, 0x68, 0xD1, 0xA6, 0x74, 0x18, 0x30, 0x40, 0x80, 0x2C, 0xC6, 0x18,
  0x41, 0x04, 0x30, 0x3D, 0x96, 0x1C, 0x18, 0x69, 0xBC, 0x26, 0xF4, 0xCC,
  0xC8, 0x8E, 0x46, 0x8B, 0x16, 0x68, 0xD1, 0x26, 0x74, 0x8E, 0x29, 0xA4,
  0xF3, 0x8E, 0x30, 0x8C, 0xE7, 0x29, 0xDA, 0xF4, 0xAF, 0x2B, 0x8C, 0xE3,
  0x30, 0x33, 0x16, 0x1C, 0x1C, 0x18, 0x3C, 0x64, 0xC6, 0x23, 0x23, 0x26,
  0x36, 0x34, 0x38, 0x18, 0x10, 0x30, 0x20, 0xE0, 0x80, 0x7C, 0x31, 0x8C,
  0x21, 0x8C, 0x3E, 0x0C, 0x71, 0x04, 0x30, 0xCE, 0x18, 0x21, 0x86, 0x10,
  0x60, 0xFF, 0xFE, 0x10, 0x60, 0x82, 0x18, 0x60, 0xC7, 0x30, 0xC2, 0x08,
  0xE0, 0xF6, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 7, 12, 7, 0, -11 },
  { 33, 10, 11, 11, 1, -11 },
  { 47, 9, 11, 9, 0, -11 },
  { 60, 2, 4, 3, 2, -11 },
  { 61, 5, 13, 4, 0, -11 },
  { 70, 5, 13, 4, -1, -11 },
  { 79, 7, 6, 7, 1, -11 },
  { 85, 6, 7, 8, 1, -9 },
  { 91, 3, 4, 4, -1, -2 },
  { 93, 4, 2, 4, 0, -5 },
  { 94, 2, 2, 4, 0, -2 },
  { 95, 8, 11, 5, -1, -11 },
  { 106, 6, 11, 7, 1, -11 },
  { 115, 4, 11, 7, 2, -11 },
  { 121, 7, 11, 7, 0, -11 },
  { 131, 7, 11, 7, 0, -11 },
  { 141, 7, 11, 7, 0, -11 },
  { 151, 7, 11, 7, 0, -11 },
  { 161, 7, 11, 7, 1, -11 },
  { 171, 7, 11, 7, 1, -11 },
  { 181, 7, 11, 7, 0, -11 },
  { 191, 7, 11, 7, 0, -11 },
  { 201, 3, 8, 4, 0, -8 },
  { 204, 4, 10, 4, -1, -8 },
  { 209, 6, 7, 8, 1, -9 },
  { 215, 6, 4, 8, 1, -7 },
  { 218, 6, 7, 8, 1, -9 },
  { 224, 5, 11, 6, 1, -11 },
  { 231, 10, 12, 11, 1, -11 },
  { 246, 8, 11, 8, -1, -11 },
  { 257, 8, 11, 8, 0, -11 },
  { 268, 8, 11, 8, 1, -11 },
  { 279, 9, 11, 9, 0, -11 },
  { 292, 8, 11, 7, 0, -11 },
  { 303, 8, 11, 7, 0, -11 },
  { 314, 8, 11, 9, 1, -11 },
  { 325, 9, 11, 9, 0, -11 },
  { 338, 6, 11, 5, 0, -11 },
  { 347, 6, 14, 4, -2, -11 },
  { 358, 9, 11, 8, 0, -11 },
  { 371, 6, 11, 7, 0, -11 },
  { 380, 12, 11, 12, 0, -11 },
  { 397, 10, 11, 10, 0, -11 },
  { 411, 8, 11, 10, 1, -11 },
  { 422, 8, 11, 8, 0, -11 },
  { 433, 8, 14, 10, 1, -11 },
  { 447, 8, 11, 8, 0, -11 },
  { 458, 7, 11, 7, 0, -11 },
  { 468, 7, 11, 7, 1, -11 },
  { 478, 8, 11, 9, 1, -11 },
  { 489, 8, 11, 8, 1, -11 },
  { 500, 12, 11, 12, 1, -11 },
  { 517, 10, 11, 7, -1, -11 },
  { 531, 7, 11, 7, 1, -11 },
  { 541, 8, 11, 7, 0, -11 },
  { 552, 6, 13, 4, 0, -11 },
  { 562, 2, 11, 6, 2, -11 },
  { 565, 6, 13, 4, -1, -11 },
  { 575, 7, 7, 8, 0, -11 },
  { 582, 5, 1, 5, -1, 1 },
  { 583, 3, 2, 4, 2, -11 },
  { 584, 7, 8, 8, 1, -8 },
  { 591, 7, 11, 8, 0, -11 },
  { 601, 5, 8, 6, 1, -8 },
  { 606, 7, 11, 8, 1, -11 },
  { 616, 6, 8, 7, 1, -8 },
  { 622, 8, 15, 5, -2, -11 },
  { 637, 8, 12, 8, 0, -8 },
  { 649, 7, 11, 8, 0, -11 },
  { 659, 4, 11, 4, 0, -11 },
  { 665, 6, 15, 4, -2, -11 },
  { 677, 8, 11, 7, 0, -11 },
  { 688, 4, 11, 4, 0, -11 },
  { 694, 11, 8, 12, 0, -8 },
  { 705, 7, 8, 8, 0, -8 },
  { 712, 6, 8, 8, 1, -8 },
  { 718, 8, 12, 8, -1, -8 },
  { 730, 7, 12, 8, 1, -8 },
  { 741, 6, 8, 5, 0, -8 },
  { 747, 6, 8, 6, 0, -8 },
  { 753, 4, 10, 5, 1, -10 },
  { 758, 7, 8, 8, 1, -8 },
  { 765, 6, 8, 7, 1, -8 },
  { 771, 10, 8, 10, 1, -8 },
  { 781, 8, 8, 7, -1, -8 },
  { 789, 8, 12, 7, -1, -8 },
  { 801, 6, 8, 6, 0, -8 },
  { 807, 6, 13, 5, 0, -11 },
  { 817, 1, 15, 7, 3, -11 },
  { 819, 6, 13, 5, -1, -11 },
  { 829, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC15PT7B_H_
