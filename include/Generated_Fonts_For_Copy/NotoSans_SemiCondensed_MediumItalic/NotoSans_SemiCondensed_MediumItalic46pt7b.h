#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x06, 0x00, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDE, 0x1E, 0x78,
  0x79, 0xE1, 0xE7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E, 0x38,
  0x38, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x01, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x38, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xCE, 0x30, 0x3E, 0x30, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1C,
  0x00, 0x3C, 0x60, 0x00, 0xF9, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xDF, 0x00, 0x07, 0x3E, 0x00, 0x18, 0xF8, 0x00, 0x63, 0xE0, 0x03, 0x8F,
  0x80, 0x0E, 0x3C, 0x30, 0x31, 0xF0, 0xF0, 0xCF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x3F, 0xC0, 0x07, 0x81, 0xFF, 0x80, 0x3C, 0x07, 0x9E, 0x00,
  0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0xE0,
  0x1E, 0x0F, 0x07, 0x80, 0x70, 0x38, 0x3C, 0x03, 0xC0, 0xE0, 0xE0, 0x0F,
  0x07, 0x87, 0x80, 0x3C, 0x1E, 0x3C, 0x00, 0xF0, 0x78, 0xE0, 0x03, 0xC3,
  0xC7, 0x8F, 0x8F, 0x0F, 0x3C, 0xFF, 0xBC, 0x78, 0xE7, 0xFE, 0xF1, 0xE7,
  0x9E, 0x79, 0xFF, 0x3C, 0xF0, 0xF7, 0xF8, 0xE3, 0xC3, 0xCF, 0xC7, 0x9E,
  0x0F, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0xF0, 0x07, 0x87, 0x03,
  0x80, 0x3C, 0x3C, 0x1E, 0x00, 0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xE0,
  0x3C, 0x0F, 0x07, 0x00, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x3C,
  0x03, 0xC7, 0x80, 0xE0, 0x07, 0xFC, 0x07, 0x80, 0x1F, 0xF0, 0x3C, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xEF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x01,
  0xF1, 0xFB, 0xE0, 0x78, 0xF8, 0xFC, 0x3E, 0x7C, 0x1F, 0x0F, 0x1F, 0x03,
  0xE7, 0xCF, 0x80, 0xFB, 0xE3, 0xE0, 0x1F, 0xF0, 0xF8, 0x07, 0xFC, 0x3E,
  0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0xC0, 0xFF, 0xF1, 0xF8, 0x1F, 0xF8,
  0x3F, 0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0xBC, 0xF3, 0xCE, 0x38, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x02, 0x07, 0x80, 0xF0, 0xE0,
  0x1F, 0x9C, 0x07, 0xFF, 0x83, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x81, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0x70, 0x07, 0xCF, 0x01, 0xF1, 0xE0,
  0x1C, 0x1E, 0x01, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF0, 0xF8, 0x78, 0x38, 0x3C, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE,
  0x7B, 0xFF, 0xFF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF3,
  0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xFC,
  0x3E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xDE, 0x7F, 0x7C, 0x7C, 0xF8, 0x61, 0xF0, 0x83, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0x07, 0xE0, 0x18, 0x07, 0xC0, 0x20, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xC0, 0xFC, 0x04, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x20, 0x01, 0xF8, 0xE0, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xC0,
  0x07, 0xCF, 0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E,
  0x1E, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x20, 0x03, 0xF0, 0xC0, 0x1F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x1E, 0x7F, 0xC1, 0xF7,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xC3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x07,
  0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0x01,
  0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0,
  0x78, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0xF8,
  0x0F, 0xC1, 0xF0, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0x7C, 0x07, 0xC1, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x7F, 0x1F, 0x07, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF3, 0xE0, 0x3F, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x1F, 0x87, 0xE3, 0xF0,
  0x7C, 0x08, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x38, 0x1F, 0x20, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x01, 0xFE, 0x0F, 0x1E,
  0x03, 0xFF, 0x0F, 0x1C, 0x0F, 0xFF, 0x07, 0x3C, 0x1F, 0x0F, 0x07, 0x38,
  0x1E, 0x0F, 0x07, 0x78, 0x3C, 0x0E, 0x07, 0x78, 0x78, 0x1E, 0x0F, 0x70,
  0x78, 0x1E, 0x0F, 0xF0, 0x70, 0x1E, 0x0F, 0xF0, 0xF0, 0x1C, 0x0E, 0xF0,
  0xF0, 0x3C, 0x0E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x78, 0x1C, 0xE0,
  0xF0, 0x78, 0x3C, 0xE0, 0xF0, 0xF8, 0x38, 0xF0, 0xF1, 0xFC, 0xF8, 0xF0,
  0xFF, 0x9F, 0xF0, 0xF0, 0x7F, 0x9F, 0xE0, 0xF0, 0x3E, 0x0F, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00,
  0xF8, 0x1E, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F, 0x03, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x0C, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xE1, 0xFF,
  0x00, 0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81,
  0xF0, 0x1F, 0xC0, 0x7C, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0x80, 0xF0, 0x3F, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xFC,
  0xF8, 0x07, 0xFE, 0x7C, 0x03, 0xFF, 0x3E, 0x01, 0xFF, 0x9F, 0x01, 0x07,
  0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xF0, 0x0F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x08, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3C, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF0,
  0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x78, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xBC,
  0x07, 0xBC, 0x00, 0xFF, 0xC0, 0x7B, 0xC0, 0x0F, 0x7C, 0x07, 0xBC, 0x01,
  0xF7, 0x80, 0x7B, 0xC0, 0x1E, 0x78, 0x0F, 0xBC, 0x03, 0xEF, 0x80, 0xFB,
  0xC0, 0x3C, 0xF8, 0x0F, 0x1E, 0x07, 0xCF, 0x80, 0xF1, 0xE0, 0x78, 0xF0,
  0x0F, 0x1E, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0xF1, 0xF0, 0x1E, 0x1E, 0x1F,
  0x1F, 0x01, 0xE1, 0xE1, 0xE1, 0xE0, 0x1E, 0x1E, 0x3E, 0x1E, 0x03, 0xE1,
  0xE3, 0xC3, 0xE0, 0x3E, 0x1E, 0x7C, 0x3E, 0x03, 0xC1, 0xE7, 0x83, 0xE0,
  0x3C, 0x1E, 0xF8, 0x3C, 0x03, 0xC1, 0xEF, 0x03, 0xC0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x78, 0x0F, 0xE0, 0x7C, 0x07, 0x80,
  0xFC, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01,
  0xE0, 0x3F, 0x80, 0x07, 0x80, 0xFE, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0xF8,
  0x0F, 0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x0F, 0x01, 0xFF, 0x00, 0x7C, 0x07,
  0xBE, 0x01, 0xF0, 0x1E, 0x78, 0x07, 0xC0, 0x79, 0xE0, 0x1E, 0x01, 0xE7,
  0xC0, 0x78, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x3C, 0x0F, 0x80, 0xF0, 0xF0,
  0x3C, 0x03, 0xC3, 0xE0, 0xF0, 0x1F, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x1F,
  0x01, 0xE0, 0x7C, 0x7C, 0x07, 0x81, 0xF1, 0xE0, 0x1E, 0x03, 0xC7, 0x80,
  0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x00, 0x7B, 0xE0, 0x3C,
  0x01, 0xEF, 0x00, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0xE1,
  0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0x83, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0xF0, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x03, 0x80,
  0xFC, 0x01, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x04, 0x00, 0x3E, 0x0E, 0x01, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C,
  0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0x78,
  0x01, 0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x80, 0x3E, 0x78, 0x03, 0xF8, 0x03,
  0xE7, 0x80, 0x3F, 0x80, 0x7C, 0x78, 0x07, 0xF8, 0x07, 0xC7, 0x80, 0x7F,
  0x80, 0x78, 0x78, 0x07, 0xF8, 0x0F, 0x87, 0x80, 0xF7, 0x80, 0xF0, 0x78,
  0x0F, 0x78, 0x1F, 0x07, 0x81, 0xE7, 0x81, 0xF0, 0x78, 0x1E, 0x78, 0x3E,
  0x07, 0x83, 0xE7, 0x83, 0xE0, 0x78, 0x3C, 0x78, 0x3C, 0x07, 0x83, 0xC7,
  0x87, 0xC0, 0x78, 0x78, 0x78, 0x78, 0x07, 0x87, 0x87, 0x8F, 0x80, 0x78,
  0xF0, 0x78, 0xF8, 0x07, 0x8F, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x79, 0xF0,
  0x07, 0x9E, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x7B, 0xE0, 0x07, 0xBC, 0x07,
  0xBC, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xE7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xF0, 0x78, 0x07, 0x87, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF9, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3, 0x80, 0x00, 0xFC, 0x3C, 0x0F, 0xF9,
  0xE0, 0x7F, 0xF7, 0x83, 0xFF, 0xDE, 0x1F, 0x83, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E,
  0x07, 0xF0, 0xF8, 0x3F, 0x83, 0xFB, 0xFE, 0x07, 0xFF, 0x78, 0x1F, 0xF9,
  0xE0, 0x1F, 0x87, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0xFC, 0x01, 0xE7,
  0xFC, 0x0F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0x83, 0xF0, 0x3E,
  0x0F, 0x80, 0x78, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0xEF, 0xE0, 0xF7, 0xFF, 0x83, 0xCF,
  0xFC, 0x0E, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0x80, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x04, 0x1F, 0xDF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x7C, 0x03,
  0xFE, 0x78, 0x07, 0xFF, 0x78, 0x0F, 0xFF, 0x78, 0x1F, 0x83, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x80, 0xFE,
  0xFF, 0x80, 0x7F, 0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x1F, 0x87, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xE1, 0xF8, 0x3E, 0x3E,
  0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xE1,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x20, 0xFE, 0x3C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0xFF, 0x9E, 0x01,
  0xFF, 0xDE, 0x03, 0xFF, 0xDE, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x03, 0xF0, 0x3E,
  0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x3F, 0xBD, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x0F, 0xE3, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x80,
  0x1F, 0x80, 0xE0, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE3, 0xF8, 0x0F, 0x3F,
  0xE0, 0xFB, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xC3, 0xE1, 0xF8, 0x1F, 0x0F,
  0xC0, 0x78, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01,
  0xF0, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x07,
  0xC1, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xC3, 0xE0, 0x0F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0x9F,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0x7C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x1E, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0x8F, 0xC0, 0x7E, 0x03, 0x8F, 0xF0, 0xFF, 0x83, 0xCF, 0xFC, 0xFF,
  0xE1, 0xEF, 0xFE, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0xF8, 0x7E, 0x07, 0xF0,
  0x3C, 0x3E, 0x03, 0xF0, 0x1E, 0x3F, 0x01, 0xF0, 0x0F, 0x1F, 0x00, 0xF8,
  0x0F, 0x8F, 0x80, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE3, 0xC0, 0x3E,
  0x01, 0xE3, 0xE0, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x00, 0xF8, 0xF8, 0x07,
  0x80, 0x7C, 0x78, 0x07, 0xC0, 0x3E, 0x7C, 0x03, 0xE0, 0x1E, 0x3E, 0x01,
  0xF0, 0x0F, 0x1F, 0x00, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0x07, 0xC7, 0x80,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x00, 0xF1, 0xF0,
  0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0x8F, 0xE0, 0x3C,
  0xFF, 0x83, 0xCF, 0xFE, 0x1E, 0xFF, 0xF0, 0xFF, 0x0F, 0x87, 0xE0, 0x7C,
  0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0x83, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x79, 0xFF, 0x00,
  0x79, 0xFF, 0x80, 0x3D, 0xFF, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0x3C, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0xF8, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFF,
  0xBF, 0x80, 0x7F, 0xFF, 0xC0, 0x3E, 0xFF, 0xC0, 0x1E, 0x3F, 0x80, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x3C, 0x0F, 0xF9, 0xE0, 0x7F, 0xF7, 0x83, 0xFF, 0xDE, 0x1F, 0x83, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F,
  0x80, 0xFC, 0x3E, 0x07, 0xF0, 0xF8, 0x3F, 0x83, 0xFB, 0xDE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFB, 0xE0, 0x1F, 0x8F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0x8F, 0x83, 0xCF, 0xC3, 0xCF, 0xE1, 0xEF, 0xF0, 0xFF, 0x88,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0x01, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x80, 0x3E, 0x3E, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xCC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x8F,
  0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0,
  0x3F, 0x0F, 0x83, 0xF8, 0x7F, 0xFB, 0xC1, 0xFF, 0xDE, 0x0F, 0xFC, 0xF0,
  0x3F, 0x87, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80,
  0x3E, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x78,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00,
  0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x3E,
  0x01, 0xFF, 0x01, 0xF8, 0x0F, 0xBC, 0x07, 0xE0, 0x3E, 0xF0, 0x3F, 0x80,
  0xF3, 0xC0, 0xFE, 0x07, 0xCF, 0x03, 0xB8, 0x1E, 0x3C, 0x1E, 0xE0, 0xF8,
  0xF0, 0x73, 0x83, 0xE3, 0xC3, 0xCE, 0x0F, 0x0F, 0x0F, 0x38, 0x7C, 0x3C,
  0x78, 0xE1, 0xE0, 0xF1, 0xE3, 0xCF, 0x83, 0xC7, 0x0F, 0x3C, 0x0F, 0x3C,
  0x3D, 0xF0, 0x3C, 0xF0, 0xE7, 0x80, 0xF7, 0x83, 0x9E, 0x03, 0xDE, 0x0E,
  0xF8, 0x0F, 0x70, 0x3B, 0xC0, 0x3F, 0xC0, 0xEF, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF1,
  0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF,
  0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x78,
  0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 34, 12, 1, -33 },
  { 52, 14, 12, 18, 5, -33 },
  { 73, 26, 33, 26, 1, -33 },
  { 181, 22, 38, 23, 1, -35 },
  { 286, 30, 33, 35, 3, -33 },
  { 410, 26, 33, 28, 1, -33 },
  { 518, 6, 12, 10, 5, -33 },
  { 527, 16, 40, 13, 1, -33 },
  { 607, 15, 40, 13, -3, -33 },
  { 682, 19, 20, 22, 4, -35 },
  { 730, 20, 22, 24, 3, -27 },
  { 785, 9, 11, 11, -2, -5 },
  { 798, 12, 4, 14, 1, -14 },
  { 804, 6, 7, 11, 1, -6 },
  { 810, 22, 33, 17, -2, -33 },
  { 901, 20, 33, 23, 2, -33 },
  { 984, 15, 33, 23, 5, -33 },
  { 1046, 23, 33, 23, -1, -33 },
  { 1141, 22, 33, 23, 0, -33 },
  { 1232, 22, 33, 23, 0, -33 },
  { 1323, 22, 33, 23, 1, -33 },
  { 1414, 21, 33, 23, 2, -33 },
  { 1501, 22, 33, 23, 2, -33 },
  { 1592, 22, 33, 23, 1, -33 },
  { 1683, 21, 33, 23, 1, -33 },
  { 1770, 10, 26, 11, 0, -25 },
  { 1803, 13, 31, 11, -2, -25 },
  { 1854, 20, 23, 24, 3, -28 },
  { 1912, 20, 13, 24, 3, -23 },
  { 1945, 20, 23, 24, 3, -28 },
  { 2003, 16, 34, 18, 3, -33 },
  { 2071, 32, 37, 35, 2, -33 },
  { 2219, 24, 33, 24, -3, -33 },
  { 2318, 24, 33, 25, 1, -33 },
  { 2417, 24, 33, 24, 3, -33 },
  { 2516, 26, 33, 28, 1, -33 },
  { 2624, 22, 33, 22, 1, -33 },
  { 2715, 22, 33, 20, 1, -33 },
  { 2806, 25, 33, 28, 3, -33 },
  { 2910, 28, 33, 28, 1, -33 },
  { 3026, 18, 33, 15, -1, -33 },
  { 3101, 20, 42, 12, -7, -33 },
  { 3206, 27, 33, 24, 1, -33 },
  { 3318, 16, 33, 20, 1, -33 },
  { 3384, 36, 33, 36, 1, -33 },
  { 3533, 30, 33, 30, 1, -33 },
  { 3657, 26, 33, 30, 3, -33 },
  { 3765, 23, 33, 24, 1, -33 },
  { 3860, 26, 41, 30, 3, -33 },
  { 3994, 23, 33, 24, 1, -33 },
  { 4089, 23, 33, 21, 0, -33 },
  { 4184, 21, 33, 21, 4, -33 },
  { 4271, 26, 33, 28, 3, -33 },
  { 4379, 24, 33, 24, 4, -33 },
  { 4478, 36, 33, 37, 4, -33 },
  { 4627, 29, 33, 23, -3, -33 },
  { 4747, 22, 33, 22, 4, -33 },
  { 4838, 25, 33, 21, -1, -33 },
  { 4942, 18, 40, 14, -1, -33 },
  { 5032, 9, 33, 17, 5, -33 },
  { 5070, 18, 40, 14, -3, -33 },
  { 5160, 21, 20, 23, 1, -33 },
  { 5213, 17, 3, 17, -4, 4 },
  { 5220, 7, 7, 13, 7, -35 },
  { 5227, 22, 25, 24, 2, -25 },
  { 5296, 22, 35, 24, 1, -35 },
  { 5393, 18, 25, 19, 2, -25 },
  { 5450, 24, 35, 24, 2, -35 },
  { 5555, 19, 25, 22, 2, -25 },
  { 5615, 24, 46, 14, -5, -35 },
  { 5753, 24, 36, 24, 0, -25 },
  { 5861, 21, 35, 24, 1, -35 },
  { 5953, 11, 34, 11, 1, -34 },
  { 6000, 18, 45, 11, -6, -34 },
  { 6102, 22, 35, 21, 1, -35 },
  { 6199, 12, 35, 11, 1, -35 },
  { 6252, 33, 25, 36, 1, -25 },
  { 6356, 21, 25, 24, 1, -25 },
  { 6422, 20, 25, 24, 2, -25 },
  { 6485, 25, 36, 24, -2, -25 },
  { 6598, 22, 36, 24, 2, -25 },
  { 6697, 17, 25, 17, 1, -25 },
  { 6751, 18, 25, 18, 0, -25 },
  { 6808, 14, 30, 15, 2, -30 },
  { 6861, 21, 25, 24, 2, -25 },
  { 6927, 20, 25, 20, 2, -25 },
  { 6990, 30, 25, 31, 3, -25 },
  { 7084, 24, 25, 21, -2, -25 },
  { 7159, 26, 36, 20, -4, -25 },
  { 7276, 20, 25, 18, -1, -25 },
  { 7339, 17, 40, 16, 1, -33 },
  { 7424, 3, 46, 22, 10, -35 },
  { 7442, 17, 40, 16, -2, -33 },
  { 7527, 20, 6, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC46PT7B_H_
