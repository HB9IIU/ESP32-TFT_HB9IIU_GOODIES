#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x40, 0x00,
  0x3E, 0x3E, 0x7C, 0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC3, 0xCF, 0x0F, 0x9E,
  0x1F, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x8E, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80,
  0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C,
  0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03,
  0xC0, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xE7, 0x3C, 0x0F, 0x8C, 0x10, 0x3E, 0x38, 0x00,
  0x7C, 0x70, 0x00, 0xF8, 0xE0, 0x01, 0xF1, 0xC0, 0x03, 0xE3, 0x00, 0x07,
  0xEE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x18,
  0xF8, 0x00, 0x71, 0xF0, 0x00, 0xE3, 0xE0, 0x01, 0xC7, 0xC0, 0x03, 0x8F,
  0x88, 0x06, 0x1F, 0x1C, 0x1C, 0x7C, 0x3F, 0xBF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x78, 0x0F, 0xFC, 0x00, 0xF0, 0x1F,
  0x3C, 0x01, 0xE0, 0x3E, 0x1E, 0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x3C,
  0x1E, 0x07, 0x80, 0x78, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x0F, 0x00, 0x78,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0xF0,
  0x3C, 0x78, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0xF1, 0xFC, 0xF0,
  0x79, 0xE3, 0xFE, 0xF0, 0xF1, 0xE7, 0xFE, 0xF9, 0xF3, 0xCF, 0x9F, 0x7F,
  0xE7, 0x8F, 0x0F, 0x7F, 0xC7, 0x9E, 0x0F, 0x3F, 0x8F, 0x1E, 0x0F, 0x00,
  0x1E, 0x3C, 0x0F, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00,
  0x78, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC0, 0x78, 0x3C, 0x07,
  0x80, 0x78, 0x78, 0x07, 0x80, 0x3C, 0xF8, 0x0F, 0x00, 0x3F, 0xF0, 0x1E,
  0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x1F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x01, 0xF1, 0xF9, 0xF0, 0x3E, 0x7E, 0x3F, 0x07, 0x8F, 0x83, 0xE1,
  0xF3, 0xE0, 0x7E, 0x7C, 0x7C, 0x07, 0xCF, 0x9F, 0x00, 0xFF, 0xE3, 0xE0,
  0x0F, 0xFC, 0x7C, 0x00, 0xFF, 0x0F, 0x80, 0x1F, 0xC1, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF7, 0xE0, 0xFF, 0xF8, 0x7C, 0x07, 0xFC, 0x0F, 0xC0, 0x3E, 0x7C, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x40, 0x78, 0x07, 0x07, 0x00, 0xFC, 0x70,
  0x0F, 0xF7, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0x1F, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x3C, 0x03, 0xE3, 0xC0, 0x7C,
  0x3E, 0x03, 0xC1, 0xE0, 0x18, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xC3, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x1F, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x9F, 0xDF, 0x7F, 0x7C, 0xFC, 0xF8, 0xE1, 0xF0, 0x83,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0x83, 0xF0, 0x07, 0x00, 0xFC, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xE0, 0x7E, 0x01, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x80, 0x03, 0xF0, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF0,
  0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x7F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x10, 0x00, 0xFC, 0x38, 0x07, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC7, 0xF0, 0x0F, 0xBF, 0xF0, 0x1E, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0x07, 0xE1, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C,
  0x1F, 0x80, 0xFC, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x7C,
  0x0F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3F, 0x07, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xEF, 0x80, 0x7F, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x20, 0x1F, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x81,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x80, 0x00, 0x38, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C,
  0x0F, 0x84, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xC3, 0xE0, 0x06, 0x00, 0xF0, 0xF0, 0x1F, 0xFC, 0x3C, 0x78, 0x0F,
  0xFF, 0x07, 0x1E, 0x07, 0xFF, 0xC1, 0xCF, 0x03, 0xE1, 0xE0, 0x73, 0xC1,
  0xF0, 0x78, 0x1D, 0xE0, 0x78, 0x1E, 0x07, 0x78, 0x3C, 0x07, 0x83, 0xDE,
  0x0F, 0x03, 0xC0, 0xF7, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x0F,
  0xF0, 0x78, 0x0F, 0x03, 0xBC, 0x1E, 0x07, 0x81, 0xEF, 0x0F, 0x01, 0xE0,
  0x7B, 0xC3, 0xC0, 0xF8, 0x3C, 0xF0, 0x78, 0x3E, 0x0F, 0x3C, 0x1E, 0x1F,
  0x87, 0x8F, 0x07, 0xFE, 0xFF, 0xC3, 0xC1, 0xFF, 0x3F, 0xE0, 0xF0, 0x3F,
  0x87, 0xF0, 0x1E, 0x01, 0x80, 0x70, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xE3, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x80, 0xF8, 0x07, 0xE0, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F,
  0xC0, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x00, 0x7F, 0x07, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0,
  0x70, 0x3F, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0xC0, 0xF8, 0x07, 0xF0, 0x1F, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3C, 0x0F, 0xF0, 0x01,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0x9F, 0x80, 0x7F, 0xF3, 0xE0, 0x0F, 0xFE, 0x7C, 0x01, 0xFF, 0x8F,
  0x80, 0x7F, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3D, 0xE0, 0x01, 0xFF, 0x80, 0xF7,
  0x80, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x3F, 0xF0, 0x0F, 0x78, 0x00, 0xF7,
  0xC0, 0x7D, 0xE0, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x07, 0x9E,
  0x00, 0xFB, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xC0, 0x3C, 0x7C,
  0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x7C, 0x7C, 0x07, 0xC3, 0xC1, 0xE1, 0xF0,
  0x1F, 0x0F, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x3C, 0x1E, 0x01, 0xE0, 0xF1,
  0xF0, 0xF8, 0x07, 0x83, 0xC7, 0x83, 0xE0, 0x3E, 0x0F, 0x3E, 0x0F, 0x80,
  0xF8, 0x3C, 0xF0, 0x3E, 0x03, 0xE0, 0xF7, 0xC1, 0xF0, 0x0F, 0x03, 0xDE,
  0x07, 0xC0, 0x7C, 0x0F, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7F, 0x01, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0xF8,
  0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0xC0, 0x07, 0x80,
  0xFF, 0x80, 0x1F, 0x01, 0xEF, 0x00, 0x3E, 0x03, 0xDF, 0x00, 0x7C, 0x0F,
  0xBE, 0x00, 0xF0, 0x1F, 0x7C, 0x01, 0xE0, 0x3E, 0x78, 0x07, 0xC0, 0x78,
  0xF8, 0x0F, 0x80, 0xF1, 0xF0, 0x1F, 0x03, 0xE1, 0xE0, 0x3C, 0x07, 0xC3,
  0xE0, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x3C, 0x0F,
  0x07, 0xC0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0x3E, 0x3E, 0x03, 0xE0, 0x3C,
  0x7C, 0x07, 0x80, 0x7C, 0xF8, 0x0F, 0x00, 0xF9, 0xF0, 0x3E, 0x01, 0xF3,
  0xC0, 0x7C, 0x01, 0xF7, 0x80, 0xF8, 0x03, 0xFF, 0x01, 0xE0, 0x07, 0xFE,
  0x07, 0xC0, 0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x0F, 0xF0, 0x1F, 0x01,
  0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0x0F, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x01, 0xFC, 0x0F, 0x87, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x04, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xC0, 0x07, 0xE0, 0xF0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x07,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xDE, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0xC0,
  0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0x00,
  0x7E, 0xF8, 0x01, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xE0, 0x07, 0xCF, 0x80,
  0x3F, 0x80, 0x3E, 0x3E, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x07, 0xF8, 0x07,
  0xC3, 0xE0, 0x3F, 0xE0, 0x1F, 0x0F, 0x80, 0xF7, 0x80, 0x7C, 0x3E, 0x03,
  0xDE, 0x03, 0xE0, 0xF8, 0x1E, 0x78, 0x0F, 0x83, 0xE0, 0x79, 0xE0, 0x7C,
  0x0F, 0x83, 0xE7, 0x81, 0xF0, 0x3E, 0x0F, 0x1E, 0x07, 0x80, 0xF8, 0x7C,
  0x78, 0x3E, 0x03, 0xE1, 0xE1, 0xE0, 0xF8, 0x0F, 0x8F, 0x87, 0x87, 0xC0,
  0x3E, 0x3C, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x7C, 0xF8, 0x03, 0xE7, 0xC1,
  0xF3, 0xE0, 0x0F, 0x9E, 0x07, 0xCF, 0x00, 0x3E, 0xF8, 0x1F, 0x7C, 0x00,
  0xFB, 0xC0, 0x7D, 0xF0, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0x0F, 0xF8, 0x07,
  0xBE, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x3F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x87,
  0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x1F, 0x80, 0x78, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7,
  0xC0, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1,
  0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00,
  0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFC, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F,
  0x00, 0x7C, 0x00, 0x03, 0xFE, 0x3C, 0x0F, 0xFE, 0xF8, 0x3F, 0xFD, 0xF0,
  0xFE, 0x7F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x9F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E,
  0x1F, 0x01, 0xFC, 0x3F, 0x07, 0xF8, 0x3F, 0xFD, 0xE0, 0x7F, 0xF3, 0xC0,
  0x7F, 0xC7, 0x80, 0x7F, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x3E, 0x7F, 0x80, 0x7D, 0xFF, 0x80, 0xF7, 0xFF, 0x83, 0xFE,
  0x3F, 0x07, 0xF8, 0x3F, 0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x00, 0x3F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F,
  0x01, 0xF8, 0x7F, 0x07, 0xE1, 0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0x07, 0x9F,
  0xF8, 0x0F, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0x1C, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x3F, 0xE7, 0xC0,
  0x3F, 0xFB, 0xE0, 0x3F, 0xFD, 0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0,
  0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0xFD, 0xE0, 0x1F, 0xFC, 0xF0, 0x07,
  0xFC, 0x78, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE3, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC3, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x03, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0D, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x3F, 0xFB, 0xE0, 0x3F, 0xFD,
  0xF0, 0x3F, 0x9F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0xFC, 0x3F, 0xC0,
  0x3F, 0xFD, 0xE0, 0x1F, 0xFD, 0xF0, 0x07, 0xFC, 0xF8, 0x01, 0xFC, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x60, 0x07, 0xC0, 0x3F, 0x1F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x7F,
  0xC0, 0x7D, 0xFF, 0xC0, 0xF7, 0xFF, 0x83, 0xFF, 0x3F, 0x07, 0xF8, 0x3F,
  0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83,
  0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x1F, 0x80, 0x1F, 0x3F,
  0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0xFF,
  0x07, 0xFC, 0x07, 0x9F, 0xF8, 0xFF, 0xE0, 0x7B, 0xFF, 0xDF, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE7, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x01,
  0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x01, 0xE1, 0xF8, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC3, 0xE0, 0x1F,
  0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x1F,
  0xF0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xE0, 0xFF, 0xCF, 0xE1, 0xFE, 0x0F,
  0xC3, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8,
  0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8,
  0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFE, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00,
  0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E, 0x03, 0xE1, 0xF0,
  0x7F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x3C, 0x7F, 0x80, 0x0F, 0x3F, 0xF0, 0x03, 0xDF,
  0xFE, 0x00, 0xFF, 0x1F, 0x80, 0x7F, 0x83, 0xF0, 0x1F, 0xC0, 0x7C, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0x7F, 0xF8, 0x07, 0xCF, 0xF8,
  0x01, 0xF1, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE,
  0x3C, 0x0F, 0xFE, 0x78, 0x3F, 0xFD, 0xF0, 0xFE, 0x3F, 0xC3, 0xF0, 0x3F,
  0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3F, 0x07,
  0xF0, 0x3F, 0xFD, 0xE0, 0x7F, 0xF7, 0xC0, 0x7F, 0xCF, 0x80, 0x7F, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0xF1, 0xF8, 0x1E, 0x7F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFC, 0x1C, 0x3F, 0x00, 0x87, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0x00, 0x3E, 0x30, 0x0F, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x0F, 0x80, 0xFE, 0x1F, 0x87,
  0xF8, 0x3F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x7F, 0xE3, 0xC0, 0x7F, 0x87,
  0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C,
  0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x80,
  0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1E, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F,
  0xE0, 0x3E, 0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x3D,
  0xE0, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x79, 0xE0, 0xF0, 0xF8, 0x79,
  0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0xF1, 0xE3, 0xE0, 0xF8, 0xF1,
  0xE3, 0xE0, 0xF9, 0xE1, 0xE7, 0xC0, 0xF9, 0xE1, 0xE7, 0xC0, 0xFB, 0xE1,
  0xE7, 0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x00, 0xFF, 0x81,
  0xEF, 0x00, 0xF7, 0x81, 0xFF, 0x00, 0xF7, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x09, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x1F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 36, 13, 1, -35 },
  { 60, 15, 13, 19, 5, -35 },
  { 85, 28, 35, 28, 1, -35 },
  { 208, 23, 40, 24, 1, -37 },
  { 323, 32, 35, 37, 3, -35 },
  { 463, 27, 36, 29, 1, -36 },
  { 585, 7, 13, 11, 5, -35 },
  { 597, 16, 43, 14, 2, -35 },
  { 683, 17, 43, 14, -4, -35 },
  { 775, 20, 21, 24, 5, -37 },
  { 828, 21, 23, 26, 3, -29 },
  { 889, 10, 12, 12, -2, -6 },
  { 904, 12, 4, 15, 1, -15 },
  { 910, 6, 7, 12, 1, -6 },
  { 916, 24, 35, 18, -2, -35 },
  { 1021, 22, 36, 24, 2, -36 },
  { 1120, 15, 35, 24, 6, -35 },
  { 1186, 25, 35, 24, -1, -35 },
  { 1296, 24, 35, 24, 0, -35 },
  { 1401, 24, 35, 24, 0, -35 },
  { 1506, 23, 35, 24, 1, -35 },
  { 1607, 23, 35, 24, 2, -35 },
  { 1708, 23, 35, 24, 3, -35 },
  { 1809, 23, 36, 24, 1, -36 },
  { 1913, 23, 35, 24, 1, -35 },
  { 2014, 10, 28, 12, 1, -27 },
  { 2049, 14, 33, 12, -3, -27 },
  { 2107, 21, 24, 26, 3, -30 },
  { 2170, 21, 14, 26, 3, -24 },
  { 2207, 21, 24, 26, 3, -30 },
  { 2270, 18, 36, 19, 3, -35 },
  { 2351, 34, 39, 37, 2, -35 },
  { 2517, 26, 35, 26, -3, -35 },
  { 2631, 26, 35, 27, 1, -35 },
  { 2745, 25, 35, 26, 3, -35 },
  { 2855, 27, 35, 29, 1, -35 },
  { 2974, 24, 35, 23, 1, -35 },
  { 3079, 24, 35, 22, 1, -35 },
  { 3184, 27, 35, 30, 3, -35 },
  { 3303, 30, 35, 30, 1, -35 },
  { 3435, 21, 35, 16, -2, -35 },
  { 3527, 22, 45, 13, -8, -35 },
  { 3651, 29, 35, 25, 1, -35 },
  { 3778, 17, 35, 22, 1, -35 },
  { 3853, 38, 35, 38, 1, -35 },
  { 4020, 31, 35, 32, 1, -35 },
  { 4156, 27, 36, 32, 3, -36 },
  { 4278, 25, 35, 26, 1, -35 },
  { 4388, 27, 44, 32, 3, -36 },
  { 4537, 25, 35, 26, 1, -35 },
  { 4647, 24, 35, 23, 0, -35 },
  { 4752, 22, 35, 22, 4, -35 },
  { 4849, 28, 35, 30, 3, -35 },
  { 4972, 25, 35, 25, 4, -35 },
  { 5082, 38, 35, 39, 5, -35 },
  { 5249, 31, 35, 24, -3, -35 },
  { 5385, 23, 35, 23, 4, -35 },
  { 5486, 26, 35, 23, -1, -35 },
  { 5600, 19, 43, 14, -1, -35 },
  { 5703, 10, 35, 18, 5, -35 },
  { 5747, 19, 43, 14, -3, -35 },
  { 5850, 23, 21, 25, 1, -35 },
  { 5911, 18, 4, 18, -4, 4 },
  { 5920, 8, 8, 14, 7, -38 },
  { 5928, 23, 27, 26, 2, -27 },
  { 6006, 23, 37, 26, 1, -37 },
  { 6113, 19, 27, 20, 2, -27 },
  { 6178, 25, 37, 26, 2, -37 },
  { 6294, 20, 27, 23, 2, -27 },
  { 6362, 27, 49, 15, -6, -37 },
  { 6528, 25, 39, 26, 0, -27 },
  { 6650, 23, 37, 26, 1, -37 },
  { 6757, 12, 36, 12, 1, -36 },
  { 6811, 19, 48, 12, -6, -36 },
  { 6925, 24, 37, 23, 1, -37 },
  { 7036, 13, 37, 12, 1, -37 },
  { 7097, 36, 27, 39, 1, -27 },
  { 7219, 23, 27, 26, 1, -27 },
  { 7297, 21, 27, 25, 2, -27 },
  { 7368, 26, 39, 26, -2, -27 },
  { 7495, 23, 39, 26, 2, -27 },
  { 7608, 19, 27, 18, 1, -27 },
  { 7673, 19, 27, 20, 0, -27 },
  { 7738, 15, 32, 16, 2, -32 },
  { 7798, 23, 26, 26, 2, -26 },
  { 7873, 21, 26, 21, 3, -26 },
  { 7942, 32, 26, 33, 3, -26 },
  { 8046, 26, 26, 22, -2, -26 },
  { 8131, 28, 38, 21, -4, -26 },
  { 8264, 21, 26, 19, -1, -26 },
  { 8333, 19, 43, 17, 1, -35 },
  { 8436, 4, 49, 24, 10, -37 },
  { 8461, 18, 43, 17, -2, -35 },
  { 8558, 21, 7, 26, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC49PT7B_H_
