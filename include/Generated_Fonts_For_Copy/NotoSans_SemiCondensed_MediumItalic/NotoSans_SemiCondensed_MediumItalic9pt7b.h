#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x00, 0xB8, 0x2B, 0xD5, 0xF5, 0x30, 0x17, 0x66, 0x3D,
  0x64, 0x4E, 0xB5, 0xFB, 0xAE, 0x60, 0x32, 0x94, 0x4E, 0xCB, 0xE0, 0xC0,
  0x29, 0x49, 0x30, 0x24, 0x92, 0x70, 0x4D, 0x6A, 0x2F, 0x22, 0xC0, 0xC0,
  0x80, 0x12, 0x44, 0x88, 0x25, 0x59, 0x99, 0x60, 0x79, 0x24, 0x80, 0x25,
  0x11, 0x24, 0xF0, 0x25, 0x16, 0x11, 0xE0, 0x13, 0x59, 0xF2, 0x74, 0x71,
  0x1E, 0x19, 0x10, 0xE9, 0x49, 0x80, 0x78, 0x88, 0x44, 0x60, 0x25, 0x52,
  0x59, 0x60, 0x25, 0x55, 0x71, 0xE0, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61,
  0xFC, 0xE1, 0x3C, 0x25, 0x12, 0x40, 0xC0, 0x3C, 0xB6, 0xAD, 0x5B, 0xC8,
  0x0E, 0x00, 0x18, 0xCA, 0x74, 0xE4, 0x7A, 0x5C, 0xA9, 0x78, 0x11, 0x50,
  0x88, 0x21, 0xC0, 0x7A, 0x52, 0x99, 0x78, 0x7A, 0x1C, 0x88, 0x70, 0x7A,
  0x1C, 0x88, 0x40, 0x18, 0x94, 0x14, 0x89, 0x27, 0x80, 0x6D, 0x27, 0x92,
  0x8A, 0x40, 0x69, 0x25, 0x80, 0x32, 0x22, 0x44, 0x48, 0x4A, 0x98, 0xC9,
  0x48, 0x49, 0x29, 0xC0, 0x66, 0xCD, 0xAB, 0x6B, 0x52, 0x80, 0x65, 0x95,
  0x96, 0x9A, 0x60, 0x10, 0xA4, 0x51, 0x89, 0x27, 0x00, 0x7A, 0x54, 0xC8,
  0x40, 0x10, 0xA4, 0x51, 0x89, 0x27, 0x04, 0x10, 0x7A, 0x54, 0xC9, 0x48,
  0x25, 0x46, 0x31, 0xE0, 0xF4, 0x44, 0x88, 0x9C, 0xA5, 0x29, 0x70, 0x9A,
  0xAA, 0xC8, 0x93, 0x6A, 0xD6, 0xCD, 0x92, 0x00, 0x2C, 0xA1, 0x0C, 0x33,
  0x20, 0xBA, 0xC4, 0x88, 0x78, 0x88, 0x8C, 0x78, 0x69, 0x29, 0x30, 0xAA,
  0x50, 0x31, 0x22, 0x22, 0xC0, 0x25, 0xD0, 0xF0, 0x90, 0x6A, 0xA5, 0x27,
  0x00, 0x44, 0x75, 0x59, 0xE0, 0x34, 0x88, 0x60, 0x08, 0x5A, 0xA9, 0x49,
  0xC0, 0x35, 0xE8, 0x60, 0x19, 0x1C, 0x42, 0x11, 0x08, 0xC0, 0x6A, 0xA5,
  0x27, 0x0B, 0x80, 0x44, 0x75, 0x59, 0x90, 0x45, 0x68, 0x20, 0x92, 0x92,
  0xC0, 0x42, 0x16, 0xC6, 0x52, 0x40, 0x69, 0x25, 0x20, 0x76, 0xB5, 0x4C,
  0xA9, 0x40, 0x75, 0x59, 0x90, 0x75, 0x99, 0x60, 0x75, 0x59, 0xE8, 0x80,
  0x6A, 0xA5, 0x27, 0x08, 0x80, 0x74, 0x48, 0x80, 0x74, 0x62, 0xE0, 0x5D,
  0x29, 0x80, 0x4A, 0x95, 0x2F, 0x00, 0x95, 0x66, 0x40, 0xAF, 0x7B, 0x6B,
  0x00, 0x56, 0x26, 0xA0, 0x49, 0x4C, 0x62, 0x13, 0x00, 0x72, 0x44, 0xE0,
  0x32, 0x48, 0x44, 0x40, 0xFF, 0x80, 0x69, 0x14, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 5, 7, 7, 1, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 2, 1, -6 },
  { 24, 3, 7, 3, 0, -6 },
  { 27, 3, 7, 3, -1, -6 },
  { 30, 4, 4, 4, 1, -7 },
  { 32, 4, 4, 5, 0, -5 },
  { 34, 1, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 0, -1 },
  { 37, 4, 6, 3, 0, -6 },
  { 40, 4, 7, 4, 0, -7 },
  { 44, 3, 6, 4, 1, -6 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 5, 7, 4, 0, -7 },
  { 66, 5, 6, 4, 0, -6 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 2, 6, 2, 0, -5 },
  { 82, 4, 4, 5, 0, -5 },
  { 84, 3, 2, 5, 1, -4 },
  { 85, 4, 4, 5, 0, -5 },
  { 87, 4, 7, 4, 0, -7 },
  { 91, 7, 7, 7, 0, -6 },
  { 98, 5, 6, 5, -1, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 5, 6, 4, 0, -6 },
  { 119, 5, 6, 4, 0, -6 },
  { 123, 6, 7, 6, 0, -7 },
  { 129, 6, 6, 6, 0, -6 },
  { 134, 3, 6, 3, 0, -6 },
  { 137, 4, 8, 2, -1, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 3, 6, 4, 0, -6 },
  { 148, 7, 6, 7, 0, -6 },
  { 154, 6, 6, 6, 0, -6 },
  { 159, 6, 7, 6, 0, -7 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 6, 9, 6, 0, -7 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 7, 4, 0, -7 },
  { 184, 4, 6, 4, 1, -6 },
  { 187, 5, 6, 5, 1, -6 },
  { 191, 4, 6, 5, 1, -6 },
  { 194, 7, 6, 7, 1, -6 },
  { 200, 6, 6, 4, -1, -6 },
  { 205, 4, 6, 4, 1, -6 },
  { 208, 5, 6, 4, 0, -6 },
  { 212, 3, 7, 3, 0, -6 },
  { 215, 2, 6, 3, 1, -6 },
  { 217, 4, 7, 3, -1, -6 },
  { 221, 4, 3, 5, 0, -6 },
  { 223, 4, 1, 3, -1, 1 },
  { 224, 2, 2, 3, 1, -7 },
  { 225, 5, 5, 5, 0, -5 },
  { 229, 4, 7, 5, 0, -7 },
  { 233, 4, 5, 4, 0, -5 },
  { 236, 5, 7, 5, 0, -7 },
  { 241, 4, 5, 4, 0, -5 },
  { 244, 5, 9, 3, -1, -7 },
  { 250, 5, 7, 5, 0, -5 },
  { 255, 4, 7, 5, 0, -7 },
  { 259, 2, 7, 2, 0, -7 },
  { 261, 3, 9, 2, -1, -7 },
  { 265, 5, 7, 4, 0, -7 },
  { 270, 3, 7, 2, 0, -7 },
  { 273, 7, 5, 7, 0, -5 },
  { 278, 4, 5, 5, 0, -5 },
  { 281, 4, 5, 5, 0, -5 },
  { 284, 4, 7, 5, 0, -5 },
  { 288, 5, 7, 5, 0, -5 },
  { 293, 4, 5, 3, 0, -5 },
  { 296, 4, 5, 4, 0, -5 },
  { 299, 3, 6, 3, 0, -6 },
  { 302, 5, 5, 5, 0, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 5, 5, 6, 1, -5 },
  { 313, 4, 5, 4, 0, -5 },
  { 316, 5, 7, 4, -1, -5 },
  { 321, 4, 5, 4, 0, -5 },
  { 324, 4, 7, 3, 0, -6 },
  { 328, 1, 9, 4, 2, -7 },
  { 330, 3, 7, 3, 0, -6 },
  { 333, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC9PT7B_H_
