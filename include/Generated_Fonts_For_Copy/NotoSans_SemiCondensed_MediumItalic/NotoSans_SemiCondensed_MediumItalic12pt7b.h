#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x82, 0xC0, 0x55, 0xAA, 0x14, 0x28, 0x53, 0xF2, 0x85,
  0x37, 0x28, 0x50, 0x08, 0xF5, 0x1C, 0x30, 0xA2, 0xBE, 0x20, 0x80, 0x62,
  0xA4, 0xA4, 0xA8, 0xB6, 0xD9, 0x2A, 0x4A, 0xCE, 0x18, 0x58, 0x91, 0x43,
  0x0A, 0xE3, 0x66, 0x74, 0x5A, 0x12, 0x24, 0x44, 0xCC, 0xC4, 0x40, 0x21,
  0x11, 0x11, 0x12, 0x24, 0xC0, 0x37, 0x0F, 0xA5, 0x00, 0x21, 0x3E, 0x42,
  0x10, 0x6A, 0x00, 0xE0, 0x70, 0x04, 0x10, 0x86, 0x10, 0xC2, 0x10, 0xC0,
  0x18, 0xB6, 0x51, 0x4D, 0x3C, 0x96, 0x70, 0x13, 0xF2, 0x22, 0x26, 0x40,
  0x19, 0xB0, 0x43, 0x08, 0x42, 0x10, 0xF8, 0x19, 0xB0, 0x42, 0x30, 0x20,
  0x82, 0xF0, 0x0C, 0x31, 0x8A, 0x49, 0x2F, 0xC4, 0x10, 0x3C, 0xF2, 0x10,
  0x78, 0x20, 0x82, 0xF0, 0x1B, 0x11, 0x0F, 0x4A, 0x52, 0xE0, 0xFF, 0xC6,
  0x22, 0x11, 0x18, 0x80, 0x18, 0xB6, 0x4B, 0x31, 0x2C, 0xB2, 0x70, 0x18,
  0xB4, 0x53, 0x4D, 0xE0, 0x84, 0xF0, 0x2C, 0x00, 0xB0, 0x13, 0x00, 0x00,
  0x64, 0x80, 0x09, 0xB1, 0xC1, 0x84, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x40,
  0x69, 0x13, 0x64, 0x88, 0x80, 0x0E, 0x08, 0x88, 0x29, 0xD5, 0x2A, 0xA6,
  0x54, 0xB4, 0x40, 0x1E, 0x00, 0x0C, 0x18, 0x70, 0xA1, 0x47, 0x89, 0x22,
  0xC6, 0x38, 0x58, 0x9B, 0x27, 0x89, 0x91, 0x26, 0xF8, 0x19, 0x94, 0x20,
  0x82, 0x08, 0x20, 0x70, 0x38, 0x78, 0x9B, 0x14, 0x28, 0xD1, 0x26, 0xF0,
  0x3C, 0xF2, 0x18, 0x79, 0x04, 0x10, 0xF8, 0x3C, 0xF2, 0x18, 0x79, 0x04,
  0x10, 0xC0, 0x1D, 0x94, 0x20, 0x9E, 0x38, 0xA2, 0x78, 0x23, 0x22, 0x22,
  0x62, 0x7E, 0x44, 0x44, 0x44, 0xCC, 0x79, 0x08, 0x42, 0x31, 0x08, 0xE0,
  0x08, 0x42, 0x31, 0x08, 0x42, 0x31, 0x38, 0x22, 0x48, 0xB3, 0xC7, 0x0A,
  0x16, 0x24, 0xCC, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xF8, 0x30, 0xCC, 0x63,
  0x19, 0xCA, 0x53, 0x95, 0x45, 0x51, 0x64, 0xD9, 0x00, 0x21, 0x31, 0x33,
  0x72, 0x5A, 0x4A, 0x4A, 0x4C, 0xC4, 0x19, 0xB4, 0x61, 0x86, 0x18, 0xE2,
  0x70, 0x38, 0xF2, 0x59, 0x4D, 0xC4, 0x10, 0xC0, 0x19, 0xB4, 0x61, 0x86,
  0x18, 0xE2, 0x70, 0x41, 0x80, 0x38, 0xB2, 0x59, 0x7D, 0xC4, 0x92, 0xCC,
  0x19, 0xB4, 0x18, 0x30, 0x60, 0xA6, 0xF0, 0xFF, 0xC8, 0x46, 0x21, 0x08,
  0xC0, 0x46, 0x89, 0x16, 0x28, 0xD1, 0x22, 0x4C, 0xF0, 0x86, 0x38, 0xA6,
  0xD3, 0xCE, 0x18, 0x40, 0x88, 0xE2, 0x29, 0x9A, 0x64, 0x99, 0x2A, 0x8A,
  0xA3, 0x18, 0xC4, 0x00, 0x33, 0x12, 0x14, 0x1C, 0x18, 0x18, 0x28, 0x64,
  0xC4, 0x8F, 0x25, 0x14, 0x61, 0x84, 0x10, 0xC0, 0x3D, 0xF0, 0x86, 0x30,
  0x84, 0x30, 0xF8, 0x32, 0x24, 0x44, 0x4C, 0x88, 0xC0, 0x99, 0x24, 0x92,
  0x60, 0x38, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x38, 0x10, 0x42, 0x92, 0x4A,
  0x10, 0xF0, 0x90, 0x10, 0xB4, 0xD3, 0xCB, 0x66, 0x80, 0x20, 0x82, 0x97,
  0x65, 0x14, 0xD2, 0xB0, 0x11, 0x50, 0x8C, 0x21, 0xC0, 0x06, 0x08, 0x53,
  0x64, 0xC9, 0xB2, 0x6C, 0x68, 0x11, 0x52, 0xFC, 0x21, 0xC0, 0x1C, 0x41,
  0x0E, 0x30, 0x82, 0x08, 0x61, 0x04, 0x30, 0x11, 0xB4, 0xD3, 0xCB, 0x66,
  0x86, 0x93, 0x80, 0x20, 0x82, 0x97, 0x65, 0x34, 0x92, 0x88, 0x24, 0x34,
  0x92, 0x80, 0x08, 0x40, 0x31, 0x08, 0x42, 0x21, 0x09, 0x80, 0x20, 0x82,
  0x5A, 0x51, 0xC5, 0x14, 0x98, 0x24, 0xB4, 0x96, 0x80, 0x09, 0x3F, 0xDB,
  0x29, 0x14, 0x9A, 0x4A, 0x64, 0x09, 0xF6, 0x53, 0x4B, 0x28, 0x80, 0x11,
  0xA4, 0xD3, 0xC9, 0x27, 0x00, 0x09, 0xF6, 0x51, 0x4D, 0x2B, 0x20, 0x82,
  0x00, 0x11, 0xB4, 0xD3, 0xCB, 0x66, 0x86, 0x10, 0x40, 0x2A, 0xD8, 0x84,
  0x22, 0x00, 0x32, 0x50, 0xC3, 0x0B, 0xC0, 0x4B, 0xC9, 0x26, 0xCC, 0x65,
  0x2B, 0x68, 0x9C, 0xA9, 0x4C, 0x60, 0x93, 0xB2, 0xB4, 0xD4, 0xD8, 0x98,
  0x26, 0x30, 0x61, 0xC2, 0x99, 0x80, 0x26, 0x48, 0xA1, 0x43, 0x06, 0x08,
  0x30, 0xC0, 0x78, 0x88, 0x8C, 0x78, 0x08, 0x88, 0x42, 0x61, 0x08, 0x42,
  0x18, 0xFF, 0xF0, 0x20, 0x84, 0x21, 0x0C, 0xC4, 0x21, 0x30, 0xEC, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 5, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 10, 6, 0, -9 },
  { 23, 8, 9, 9, 1, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 2, 4, 3, 1, -9 },
  { 41, 4, 11, 3, 0, -9 },
  { 47, 4, 11, 3, -1, -9 },
  { 53, 5, 5, 6, 1, -9 },
  { 57, 5, 6, 6, 1, -7 },
  { 61, 3, 3, 3, -1, -1 },
  { 63, 3, 1, 4, 0, -4 },
  { 64, 2, 2, 3, 0, -2 },
  { 65, 6, 9, 4, -1, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 4, 9, 6, 1, -9 },
  { 84, 6, 9, 6, 0, -9 },
  { 91, 6, 9, 6, 0, -9 },
  { 98, 6, 9, 6, 0, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 5, 9, 6, 1, -9 },
  { 118, 5, 9, 6, 1, -9 },
  { 124, 6, 9, 6, 0, -9 },
  { 131, 6, 9, 6, 0, -9 },
  { 138, 3, 7, 3, 0, -7 },
  { 141, 4, 9, 3, -1, -7 },
  { 146, 5, 6, 6, 1, -7 },
  { 150, 5, 3, 6, 1, -6 },
  { 152, 5, 6, 6, 1, -7 },
  { 156, 4, 9, 5, 1, -9 },
  { 161, 9, 10, 9, 0, -9 },
  { 173, 7, 9, 6, -1, -9 },
  { 181, 7, 9, 7, 0, -9 },
  { 189, 6, 9, 6, 1, -9 },
  { 196, 7, 9, 7, 0, -9 },
  { 204, 6, 9, 6, 0, -9 },
  { 211, 6, 9, 5, 0, -9 },
  { 218, 6, 9, 7, 1, -9 },
  { 225, 8, 9, 7, 0, -9 },
  { 234, 5, 9, 4, 0, -9 },
  { 240, 5, 11, 3, -2, -9 },
  { 247, 7, 9, 6, 0, -9 },
  { 255, 5, 9, 5, 0, -9 },
  { 261, 10, 9, 9, 0, -9 },
  { 273, 8, 9, 8, 0, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 6, 9, 6, 0, -9 },
  { 296, 6, 11, 8, 1, -9 },
  { 305, 6, 9, 6, 0, -9 },
  { 312, 6, 9, 6, 0, -9 },
  { 319, 5, 9, 5, 1, -9 },
  { 325, 7, 9, 7, 1, -9 },
  { 333, 6, 9, 6, 1, -9 },
  { 340, 10, 9, 10, 1, -9 },
  { 352, 8, 9, 6, -1, -9 },
  { 361, 6, 9, 6, 1, -9 },
  { 368, 6, 9, 6, 0, -9 },
  { 375, 4, 11, 4, 0, -9 },
  { 381, 3, 9, 4, 1, -9 },
  { 385, 5, 11, 4, -1, -9 },
  { 392, 6, 6, 6, 0, -9 },
  { 397, 4, 1, 4, -1, 1 },
  { 398, 2, 2, 3, 2, -9 },
  { 399, 6, 7, 6, 0, -7 },
  { 405, 6, 9, 6, 0, -9 },
  { 412, 5, 7, 5, 0, -7 },
  { 417, 7, 9, 6, 0, -9 },
  { 425, 5, 7, 6, 0, -7 },
  { 430, 6, 12, 4, -1, -9 },
  { 439, 6, 10, 6, 0, -7 },
  { 447, 6, 9, 6, 0, -9 },
  { 454, 3, 9, 3, 0, -9 },
  { 458, 5, 12, 3, -2, -9 },
  { 466, 6, 9, 6, 0, -9 },
  { 473, 3, 9, 3, 0, -9 },
  { 477, 9, 7, 9, 0, -7 },
  { 485, 6, 7, 6, 0, -7 },
  { 491, 6, 7, 6, 0, -7 },
  { 497, 6, 10, 6, 0, -7 },
  { 505, 6, 10, 6, 0, -7 },
  { 513, 5, 7, 4, 0, -7 },
  { 518, 5, 7, 5, 0, -7 },
  { 523, 3, 8, 4, 1, -8 },
  { 526, 5, 6, 6, 1, -6 },
  { 530, 5, 6, 5, 1, -6 },
  { 534, 8, 6, 8, 1, -6 },
  { 540, 7, 6, 5, -1, -6 },
  { 546, 7, 9, 5, -1, -6 },
  { 554, 5, 6, 5, 0, -6 },
  { 558, 5, 11, 4, 0, -9 },
  { 565, 1, 12, 6, 3, -9 },
  { 567, 5, 11, 4, -1, -9 },
  { 574, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC12PT7B_H_
