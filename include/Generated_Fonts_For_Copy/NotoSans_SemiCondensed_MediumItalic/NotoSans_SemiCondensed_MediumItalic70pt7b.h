#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0xC7,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF1,
  0xE1, 0xE0, 0x0F, 0xF1, 0xE0, 0x30, 0x07, 0xF0, 0xF0, 0x00, 0x03, 0xF0,
  0x78, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0xFE,
  0x1E, 0x00, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x0F,
  0xE3, 0xC0, 0x00, 0x07, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xCF, 0xF8,
  0x00, 0x01, 0xE3, 0xFC, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x78, 0x7F,
  0x00, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x1E, 0x0F,
  0xE0, 0x00, 0x0F, 0x07, 0xF0, 0x80, 0x07, 0x87, 0xF0, 0x30, 0x03, 0x83,
  0xF8, 0x1E, 0x03, 0xC7, 0xFC, 0x0F, 0xF1, 0xEF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0xFC, 0x07, 0x03, 0xF0, 0x1F, 0x87, 0xE1, 0xFF, 0x0F, 0xC0,
  0x7E, 0x3F, 0x0F, 0xFF, 0x1F, 0x03, 0xF0, 0xFC, 0x7F, 0xFC, 0x7C, 0x0F,
  0xC7, 0xE3, 0xFF, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0xEF, 0xE7, 0xF7, 0xF8,
  0xFC, 0x7E, 0x0F, 0xDF, 0xFF, 0xC7, 0xE3, 0xF0, 0x3F, 0x3F, 0xFE, 0x1F,
  0x0F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC, 0x7E, 0x03, 0xF0, 0xFF, 0x87, 0xE1,
  0xF8, 0x0F, 0xC0, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x07,
  0xFD, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0xFF,
  0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF8,
  0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x7F, 0x00,
  0x1F, 0xEF, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x20,
  0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xF8, 0x78,
  0x00, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x3E, 0x00,
  0x0F, 0xF3, 0xE0, 0x01, 0xFE, 0x3F, 0x00, 0x3F, 0xC1, 0xF0, 0x07, 0xF8,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x06, 0x00, 0xFE,
  0x00, 0x20, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xDF, 0xC7, 0xFE, 0x7F, 0x3F, 0xF3, 0xF8, 0x7F, 0x0F, 0xE0, 0xF8,
  0x3F, 0x81, 0x80, 0xFE, 0x04, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x03, 0x80, 0x03,
  0xFC, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x00,
  0x38, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x08,
  0x00, 0x00, 0xFF, 0x83, 0x00, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x70, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x20, 0x00, 0x07,
  0xFC, 0x0C, 0x00, 0x03, 0xFE, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x8F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x1E, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC3, 0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xC0,
  0x3F, 0xBF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xCF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0,
  0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xF9, 0xFC, 0x01, 0xFF,
  0xF3, 0xF8, 0x00, 0xFF, 0xC3, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x07, 0xFC, 0x00, 0xFC, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xCF, 0xFE, 0x1E, 0x00, 0xFF, 0x0C, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x7E, 0x0F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0x87,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xC7, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xE3,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF9,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xBE, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x9F, 0x01, 0xF8, 0x01, 0xF0, 0x07,
  0xCF, 0x80, 0xF8, 0x01, 0xF8, 0x03, 0xEF, 0xC0, 0xFC, 0x00, 0xFC, 0x03,
  0xF7, 0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xF3, 0xF0, 0x3F, 0x00, 0x7E, 0x00,
  0xF9, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x7C, 0x7C, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x1F, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x0F, 0xF8,
  0x3F, 0x07, 0xC0, 0x3F, 0x9F, 0x7E, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xBF,
  0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0x00, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0x00, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x02, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x00, 0x10, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0xFE,
  0x00, 0x1F, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xF8, 0x00, 0x7F,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x3F,
  0xC0, 0x04, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xCF, 0xE0, 0x00,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x0F,
  0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x83, 0xF0, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x1F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0x7E, 0x7E, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xDF,
  0x80, 0x01, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xDF, 0xC0,
  0x01, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x03,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xBF, 0x00, 0x3F, 0x80, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0xFF,
  0x80, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x08, 0x00,
  0x01, 0xFF, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xEF, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xDF, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x3F, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x01, 0xF9, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x07,
  0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0xFE, 0x0F,
  0xC0, 0x1F, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFB,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC7, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0,
  0x1F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0xE1, 0xF8,
  0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0x00,
  0x7F, 0x3F, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xF8, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xE0, 0x1F,
  0x1F, 0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0x80, 0x60, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0x03, 0xFC, 0x00, 0xC0, 0x7F, 0xE0, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xE3,
  0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xFC, 0xFC,
  0x00, 0x3F, 0xFF, 0x8F, 0x80, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x0F,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xE7,
  0xF0, 0x0F, 0xFC, 0x7F, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x07, 0xF8, 0x00, 0x60, 0x7F,
  0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x87, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xF0, 0x00, 0x7F,
  0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xFE, 0x7E, 0x00,
  0x3F, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xBF, 0x80, 0x0F, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xFE, 0x3F, 0x00, 0x03,
  0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x00, 0x1C, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x7F, 0x80,
  0x0E, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0xFE, 0x3F, 0xFC, 0x00,
  0x7E, 0x3F, 0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x87, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7E,
  0x7F, 0x80, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xE1, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xFE, 0x03, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7E, 0x07, 0xFC,
  0x00, 0x3F, 0x0F, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0xC0, 0x1F, 0x8F, 0xFF,
  0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFE, 0x03, 0xFF, 0xC1,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x81,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF3, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0x0F,
  0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0xE0, 0x03,
  0xF7, 0xF7, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF,
  0xF8, 0x00, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0xC0, 0x01, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0x80, 0x1F, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0xE7,
  0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xC0,
  0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xE3, 0xF0,
  0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0xE1, 0xFC, 0x00, 0x07, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x1F,
  0x87, 0xFC, 0x03, 0xE1, 0xFF, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xFC,
  0x03, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0x60, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0xFC, 0x07, 0xF8, 0x01, 0xC0, 0x7F, 0x00, 0x08, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x80, 0x01, 0xFE, 0x0E, 0x00, 0x3F, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x86, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFE,
  0x07, 0xF0, 0x03, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0x8F, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xE7,
  0xE0, 0x07, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xC0,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFB, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFB, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xEF,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x3E, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0xF8,
  0x07, 0xF0, 0xFE, 0x03, 0xF3, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0x8F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7E, 0x3E, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0xF8, 0x1F,
  0xC0, 0x7E, 0x0F, 0xC3, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x0F, 0x83, 0xF8,
  0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x03, 0xE1, 0xFC, 0x01, 0xF8, 0xFC, 0x0F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF0, 0x3E, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x00, 0x7E,
  0x7E, 0x03, 0xE7, 0xF0, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0x07, 0xEF,
  0xC0, 0x3E, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8,
  0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x83, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x3F,
  0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xF9, 0x00, 0x00, 0x7F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 51, 18, 1, -50 },
  { 116, 22, 18, 27, 7, -50 },
  { 166, 40, 50, 40, 1, -50 },
  { 416, 33, 57, 35, 1, -53 },
  { 652, 46, 52, 53, 4, -51 },
  { 951, 40, 52, 42, 1, -51 },
  { 1211, 10, 18, 15, 7, -50 },
  { 1234, 23, 61, 20, 2, -50 },
  { 1410, 23, 61, 20, -5, -50 },
  { 1586, 28, 29, 34, 7, -53 },
  { 1688, 31, 34, 37, 4, -42 },
  { 1820, 14, 17, 17, -3, -8 },
  { 1850, 18, 6, 21, 1, -22 },
  { 1864, 9, 10, 17, 1, -9 },
  { 1876, 34, 50, 26, -3, -50 },
  { 2089, 31, 52, 35, 3, -51 },
  { 2291, 22, 50, 35, 8, -50 },
  { 2429, 35, 51, 35, -1, -51 },
  { 2653, 34, 52, 35, 0, -51 },
  { 2874, 34, 50, 35, 0, -50 },
  { 3087, 34, 51, 35, 1, -50 },
  { 3304, 32, 52, 35, 3, -51 },
  { 3512, 33, 50, 35, 4, -50 },
  { 3719, 33, 52, 35, 2, -51 },
  { 3934, 32, 52, 35, 2, -51 },
  { 4142, 15, 39, 17, 1, -38 },
  { 4216, 20, 47, 17, -4, -38 },
  { 4334, 31, 34, 37, 4, -42 },
  { 4466, 31, 20, 37, 4, -35 },
  { 4544, 31, 34, 37, 4, -42 },
  { 4676, 25, 52, 27, 4, -51 },
  { 4839, 49, 56, 53, 3, -50 },
  { 5182, 37, 50, 37, -4, -50 },
  { 5414, 36, 50, 38, 2, -50 },
  { 5639, 36, 52, 37, 4, -51 },
  { 5873, 38, 50, 42, 2, -50 },
  { 6111, 34, 50, 33, 2, -50 },
  { 6324, 34, 50, 31, 2, -50 },
  { 6537, 39, 52, 43, 4, -51 },
  { 6791, 42, 50, 43, 2, -50 },
  { 7054, 29, 50, 22, -2, -50 },
  { 7236, 31, 64, 18, -11, -50 },
  { 7484, 41, 50, 36, 2, -50 },
  { 7741, 24, 50, 31, 2, -50 },
  { 7891, 54, 50, 55, 2, -50 },
  { 8229, 44, 50, 46, 2, -50 },
  { 8504, 39, 52, 45, 4, -51 },
  { 8758, 35, 50, 36, 2, -50 },
  { 8977, 39, 63, 45, 4, -51 },
  { 9285, 35, 50, 37, 2, -50 },
  { 9504, 34, 52, 33, 0, -51 },
  { 9725, 32, 50, 32, 6, -50 },
  { 9925, 40, 51, 43, 4, -50 },
  { 10180, 36, 50, 36, 6, -50 },
  { 10405, 55, 50, 56, 7, -50 },
  { 10749, 44, 50, 35, -4, -50 },
  { 11024, 33, 50, 33, 6, -50 },
  { 11231, 38, 50, 33, -2, -50 },
  { 11469, 27, 61, 21, -1, -50 },
  { 11675, 14, 50, 26, 7, -50 },
  { 11763, 27, 61, 21, -5, -50 },
  { 11969, 32, 30, 36, 2, -50 },
  { 12089, 26, 5, 26, -6, 6 },
  { 12106, 12, 12, 20, 10, -54 },
  { 12124, 33, 39, 37, 3, -38 },
  { 12285, 33, 54, 37, 1, -53 },
  { 12508, 27, 39, 29, 3, -38 },
  { 12640, 36, 54, 37, 3, -53 },
  { 12883, 28, 39, 33, 3, -38 },
  { 13020, 37, 71, 21, -8, -54 },
  { 13349, 36, 55, 37, 0, -38 },
  { 13597, 33, 53, 37, 1, -53 },
  { 13816, 18, 52, 17, 1, -52 },
  { 13933, 28, 69, 17, -9, -52 },
  { 14175, 34, 53, 33, 1, -53 },
  { 14401, 18, 53, 17, 1, -53 },
  { 14521, 51, 38, 55, 1, -38 },
  { 14764, 33, 39, 37, 1, -39 },
  { 14925, 30, 39, 36, 3, -38 },
  { 15072, 36, 55, 37, -2, -38 },
  { 15320, 33, 55, 37, 3, -38 },
  { 15547, 27, 38, 25, 1, -38 },
  { 15676, 28, 39, 28, 0, -38 },
  { 15813, 21, 47, 22, 3, -46 },
  { 15937, 33, 39, 37, 3, -38 },
  { 16098, 30, 38, 30, 4, -38 },
  { 16241, 46, 38, 47, 4, -38 },
  { 16460, 37, 38, 31, -3, -38 },
  { 16636, 40, 55, 31, -6, -38 },
  { 16911, 30, 38, 28, -2, -38 },
  { 17054, 27, 61, 24, 1, -50 },
  { 17260, 5, 70, 34, 15, -53 },
  { 17304, 26, 61, 24, -3, -50 },
  { 17503, 31, 10, 37, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC70PT7B_H_
