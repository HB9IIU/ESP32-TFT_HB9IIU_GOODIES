#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xDE, 0x7E,
  0x01, 0xFC, 0x78, 0x30, 0x0F, 0xE1, 0xC0, 0x00, 0x3F, 0x0F, 0x00, 0x00,
  0xFC, 0x3C, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x3F,
  0x0E, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7B, 0xFC, 0x00,
  0x01, 0xE7, 0xF0, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x3C, 0x3F, 0x80, 0x00,
  0xF0, 0xFE, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x38,
  0x3F, 0x04, 0x01, 0xE1, 0xFC, 0x3E, 0x07, 0x8F, 0xE0, 0xFF, 0x9F, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF0,
  0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x07,
  0xC3, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x7E,
  0x1F, 0xC3, 0xE0, 0x3E, 0x1F, 0x0F, 0xF8, 0xF8, 0x1F, 0x8F, 0x8F, 0xFF,
  0x3E, 0x07, 0xC7, 0xE7, 0xFF, 0xEF, 0xC3, 0xF1, 0xF1, 0xFF, 0xF9, 0xFB,
  0xF8, 0xF8, 0xFC, 0x3E, 0x7F, 0xFC, 0x7E, 0x3E, 0x0F, 0x9F, 0xFE, 0x1F,
  0x1F, 0x03, 0xF3, 0xFF, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0x87, 0xE3, 0xF0,
  0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF7,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0xBF,
  0x80, 0x7E, 0x0F, 0xE1, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0x87, 0xE0, 0x07, 0xF3, 0xF0, 0x7E, 0x00, 0x3F, 0xFF, 0x0F, 0xE0, 0x03,
  0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F,
  0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x74, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x02, 0x00,
  0xF8, 0x00, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0xE3, 0xC0, 0x0F,
  0xFE, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFD,
  0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0xC3, 0xE0, 0x0F,
  0xE0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x06, 0x01, 0xF8,
  0x00, 0x80, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFB, 0xF3, 0xFE,
  0x7E, 0x7F, 0x0F, 0xC7, 0xC3, 0xF8, 0x60, 0x7E, 0x08, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x7F,
  0x00, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x20, 0x00, 0x0F, 0xF0,
  0x70, 0x00, 0x3F, 0xC0, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x20, 0x00,
  0x1F, 0xE0, 0x70, 0x00, 0x7F, 0x80, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x18, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xE3, 0xFF, 0x00, 0x7E, 0x7F, 0xFC, 0x03, 0xF7,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE3, 0xFE, 0x0F, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7F, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0x7F,
  0x00, 0xFF, 0xC3, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xBF, 0x01, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0x9F, 0xC0, 0x0F, 0xF0, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0x87, 0x80, 0x7F, 0x88, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0xF8,
  0x3F, 0x00, 0x7F, 0xFF, 0x07, 0xC1, 0xF0, 0x07, 0xFF, 0xF0, 0x1E, 0x1F,
  0x00, 0xFF, 0xFF, 0x80, 0xF8, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xCF, 0x80,
  0x7E, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x7E,
  0x01, 0xF0, 0x0F, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF9, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xCF, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x3E,
  0x01, 0xF7, 0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0xBE, 0x07, 0xC0, 0x1F, 0x80,
  0xF9, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0x07, 0xC0, 0x3E,
  0x7C, 0x0F, 0x80, 0x7E, 0x03, 0xE3, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x1F,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x87, 0xC0,
  0xF8, 0x1F, 0xE0, 0xF8, 0x3E, 0x07, 0xF3, 0xFF, 0x9F, 0xC1, 0xF0, 0x1F,
  0xFE, 0x7F, 0xFC, 0x0F, 0x80, 0xFF, 0xE3, 0xFF, 0xC0, 0x7C, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0x00, 0x38, 0x03,
  0xFE, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x02, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7E, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0xC7,
  0xF0, 0x01, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x07, 0xFF,
  0xE3, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x41, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03,
  0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x0F, 0xFF,
  0x00, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x1F,
  0x9F, 0x00, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xF8, 0x01,
  0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7C, 0x00, 0x3E, 0x3F, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xF0,
  0x03, 0xF1, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x3E, 0x03, 0xE0,
  0xFE, 0x00, 0x7E, 0x0F, 0x81, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x0F,
  0x81, 0xFC, 0x00, 0xFC, 0x0F, 0x87, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE1,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x3E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x00, 0x7E, 0x03,
  0xF7, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x0F,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x9F, 0x80,
  0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x07, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x0F, 0xC0, 0x03, 0xF7,
  0xE0, 0x07, 0xE0, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0,
  0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x10, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x7F, 0xC0, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC3, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x7C, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x03,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF9, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x7C, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0xC0, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF8, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x81, 0xF8,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF,
  0x80, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xF1, 0xF0, 0x07,
  0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xE7, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0, 0x1F,
  0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x1F, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x01, 0xF9, 0xFF, 0xF0, 0x07,
  0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFD, 0xF1, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x03, 0xFC,
  0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xF3, 0xFF, 0xFC, 0x0F,
  0xCF, 0xFF, 0xC0, 0x3F, 0x1F, 0xFE, 0x00, 0xF8, 0x3F, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xC0, 0x7F,
  0xC0, 0x10, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x10, 0x1F, 0xF0, 0x1C, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0xFC, 0xFC,
  0x00, 0x3F, 0xFF, 0xBF, 0x00, 0x1F, 0xFF, 0xEF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xF0,
  0x1F, 0xF8, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0x00, 0x0F,
  0xFF, 0xE7, 0xC0, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x7F, 0xF8, 0x7C, 0x00,
  0x07, 0xF8, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x7F,
  0x80, 0x38, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x80,
  0x07, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xF3, 0xE0,
  0x07, 0xFF, 0xFB, 0xF0, 0x07, 0xFE, 0x7F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0,
  0x07, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xDF, 0x80, 0x0F, 0xFF, 0xCF, 0xC0, 0x03,
  0xFF, 0xCF, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x06, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x20, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xF8, 0x01, 0xF9,
  0xFF, 0xF0, 0x07, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFD, 0xF9,
  0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x43, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x1F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0xFF,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xE1, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF, 0x8F,
  0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0x7E,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x07, 0xC1, 0xFF, 0x80,
  0x1F, 0x1F, 0xFF, 0x00, 0x7C, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF8, 0x0F,
  0xFF, 0xBF, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x07, 0xFC,
  0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80,
  0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x07,
  0xCF, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0x80,
  0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0,
  0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0x80, 0x0F, 0xDF,
  0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0x80, 0x07, 0xE0, 0xFF, 0x80, 0x03, 0xF0,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xF1,
  0xF0, 0x07, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xE7, 0xFF,
  0x81, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xDF, 0x80, 0x3F, 0xFF, 0x3F, 0x00, 0x3F, 0xFC, 0x7E,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x06, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x7F, 0x80, 0x7C, 0x7F,
  0xC0, 0x3E, 0x7F, 0xE0, 0x3F, 0x7F, 0xF0, 0x1F, 0xBF, 0xF0, 0x0F, 0xFF,
  0x08, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0xF8,
  0x1F, 0xC0, 0x18, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x3F, 0x87,
  0x80, 0x3F, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x41, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00,
  0x7F, 0xC0, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x3E, 0xFC, 0x0F, 0xFF, 0xFB,
  0xE0, 0x3F, 0xFF, 0xCF, 0x80, 0x7F, 0xFE, 0x7E, 0x00, 0xFF, 0xF1, 0xF8,
  0x01, 0xFF, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xCF, 0xC0, 0x1F, 0xF0, 0x07, 0xF3,
  0xF0, 0x0F, 0xBC, 0x01, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x3F, 0x01,
  0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x7C,
  0x07, 0xE0, 0xFC, 0x0F, 0x9F, 0x01, 0xF8, 0x3F, 0x03, 0xE7, 0xC0, 0xFC,
  0x0F, 0xC1, 0xF9, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0x7E, 0x1F, 0xC0, 0xFC,
  0x3F, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x87, 0xE3, 0xF8, 0x0F, 0xC3, 0xE1,
  0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x81, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x1F, 0x3F, 0x00, 0x3F, 0x7C,
  0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xC7,
  0xF0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x13, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE8, 0x00,
  0x3F, 0xFC, 0x80, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 47, 17, 1, -46 },
  { 101, 20, 17, 25, 7, -46 },
  { 144, 36, 46, 36, 1, -46 },
  { 351, 30, 53, 32, 1, -49 },
  { 550, 42, 47, 48, 4, -46 },
  { 797, 36, 47, 38, 1, -46 },
  { 1009, 9, 17, 14, 7, -46 },
  { 1029, 21, 56, 18, 2, -46 },
  { 1176, 21, 56, 19, -5, -46 },
  { 1323, 26, 28, 31, 6, -49 },
  { 1414, 28, 31, 34, 4, -38 },
  { 1523, 13, 15, 16, -3, -7 },
  { 1548, 16, 6, 19, 1, -20 },
  { 1560, 8, 9, 16, 1, -8 },
  { 1569, 31, 46, 23, -3, -46 },
  { 1748, 29, 47, 32, 2, -46 },
  { 1919, 19, 46, 32, 8, -46 },
  { 2029, 32, 46, 32, -1, -46 },
  { 2213, 31, 47, 32, 0, -46 },
  { 2396, 31, 46, 32, 0, -46 },
  { 2575, 31, 47, 32, 1, -46 },
  { 2758, 29, 47, 32, 3, -46 },
  { 2929, 31, 46, 32, 3, -46 },
  { 3108, 31, 47, 32, 1, -46 },
  { 3291, 29, 47, 32, 2, -46 },
  { 3462, 14, 36, 16, 1, -35 },
  { 3525, 18, 43, 16, -3, -35 },
  { 3622, 28, 32, 34, 4, -39 },
  { 3734, 28, 19, 34, 4, -32 },
  { 3801, 28, 32, 34, 4, -39 },
  { 3913, 23, 47, 25, 4, -46 },
  { 4049, 45, 52, 49, 3, -46 },
  { 4342, 34, 46, 34, -4, -46 },
  { 4538, 34, 46, 35, 1, -46 },
  { 4734, 33, 47, 34, 4, -46 },
  { 4928, 36, 46, 38, 1, -46 },
  { 5135, 32, 46, 30, 1, -46 },
  { 5319, 32, 46, 28, 1, -46 },
  { 5503, 35, 47, 39, 4, -46 },
  { 5709, 39, 46, 39, 1, -46 },
  { 5934, 26, 46, 20, -2, -46 },
  { 6084, 28, 59, 17, -10, -46 },
  { 6291, 38, 46, 33, 1, -46 },
  { 6510, 23, 46, 28, 1, -46 },
  { 6643, 50, 46, 50, 1, -46 },
  { 6931, 41, 46, 42, 1, -46 },
  { 7167, 36, 47, 41, 4, -46 },
  { 7379, 33, 46, 33, 1, -46 },
  { 7569, 36, 57, 41, 4, -46 },
  { 7826, 33, 46, 34, 1, -46 },
  { 8016, 31, 47, 30, 0, -46 },
  { 8199, 29, 46, 29, 5, -46 },
  { 8366, 36, 47, 39, 4, -46 },
  { 8578, 32, 46, 33, 6, -46 },
  { 8762, 50, 46, 51, 6, -46 },
  { 9050, 40, 46, 32, -4, -46 },
  { 9280, 30, 46, 30, 6, -46 },
  { 9453, 35, 46, 30, -2, -46 },
  { 9655, 25, 56, 19, -1, -46 },
  { 9830, 12, 46, 23, 7, -46 },
  { 9899, 24, 56, 19, -4, -46 },
  { 10067, 30, 28, 33, 1, -46 },
  { 10172, 25, 4, 23, -6, 6 },
  { 10185, 11, 10, 18, 9, -49 },
  { 10199, 31, 36, 34, 2, -35 },
  { 10339, 30, 50, 34, 1, -49 },
  { 10527, 26, 36, 27, 2, -35 },
  { 10644, 34, 50, 34, 2, -49 },
  { 10857, 27, 36, 30, 2, -35 },
  { 10979, 34, 64, 19, -7, -49 },
  { 11251, 33, 50, 34, 0, -35 },
  { 11458, 30, 49, 34, 1, -49 },
  { 11642, 16, 48, 16, 1, -48 },
  { 11738, 25, 63, 16, -8, -48 },
  { 11935, 31, 49, 30, 1, -49 },
  { 12125, 17, 49, 16, 1, -49 },
  { 12230, 47, 35, 51, 1, -35 },
  { 12436, 30, 35, 34, 1, -35 },
  { 12568, 28, 36, 33, 2, -35 },
  { 12694, 33, 50, 34, -2, -35 },
  { 12901, 31, 50, 34, 2, -35 },
  { 13095, 25, 35, 23, 1, -35 },
  { 13205, 25, 36, 26, 0, -35 },
  { 13318, 19, 43, 20, 3, -42 },
  { 13421, 30, 36, 34, 3, -35 },
  { 13556, 28, 35, 28, 3, -35 },
  { 13679, 42, 35, 43, 4, -35 },
  { 13863, 34, 35, 29, -3, -35 },
  { 14012, 37, 50, 28, -6, -35 },
  { 14244, 28, 35, 25, -2, -35 },
  { 14367, 25, 56, 22, 1, -46 },
  { 14542, 6, 64, 31, 13, -49 },
  { 14590, 24, 56, 22, -3, -46 },
  { 14758, 28, 9, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC64PT7B_H_
