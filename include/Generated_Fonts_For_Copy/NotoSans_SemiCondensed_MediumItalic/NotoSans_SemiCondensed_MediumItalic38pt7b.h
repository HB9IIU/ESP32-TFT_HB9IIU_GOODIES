#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x78,
  0xF7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1,
  0x8E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x01, 0xC1,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x78, 0xC4, 0x1E, 0x70, 0x07, 0x98, 0x01,
  0xE6, 0x00, 0x79, 0x80, 0x1F, 0x60, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x19, 0xE0, 0x06, 0x38, 0x01, 0x8E,
  0x00, 0x67, 0x88, 0x39, 0xE3, 0x8C, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFE, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0x07, 0xF8, 0x07, 0x03, 0x9C, 0x07, 0x83,
  0x87, 0x03, 0x81, 0xC3, 0x83, 0x81, 0xC1, 0xC3, 0xC0, 0xE1, 0xE1, 0xC0,
  0x70, 0xE1, 0xC0, 0x38, 0x71, 0xE0, 0x1C, 0x38, 0xE0, 0x1E, 0x1C, 0xE1,
  0x8E, 0x1C, 0xF3, 0xF3, 0x8E, 0x73, 0xFD, 0xCE, 0x73, 0x9E, 0xFF, 0x7B,
  0xC7, 0x3F, 0x39, 0xC3, 0x84, 0x38, 0xE1, 0xC0, 0x3C, 0xE0, 0xE0, 0x1C,
  0x70, 0x70, 0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x0E, 0x0E, 0x1C, 0x0E,
  0x07, 0x1E, 0x0F, 0x03, 0x8E, 0x07, 0x01, 0xEF, 0x07, 0x00, 0xFF, 0x07,
  0x80, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xDF, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0x3C, 0xF0, 0x73,
  0xC3, 0xC7, 0xBC, 0x1F, 0x39, 0xE0, 0x7B, 0xCF, 0x01, 0xFC, 0x78, 0x0F,
  0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xF0, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x1F,
  0xFC, 0xF0, 0x7F, 0x83, 0xC0, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C, 0xE7, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x04, 0x0E, 0x0E, 0x18, 0x1F, 0x30, 0x3F,
  0xE7, 0x9F, 0xFF, 0x07, 0xFE, 0x1F, 0x04, 0x7F, 0x01, 0xEE, 0x07, 0x8E,
  0x0F, 0x1C, 0x0C, 0x3C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x39, 0xE7, 0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0x87, 0x83, 0xC1, 0xE1,
  0xF0, 0x38, 0x78, 0x0E, 0x1E, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xF0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x1C, 0x07, 0x87,
  0x03, 0xC1, 0xE0, 0xF0, 0x7C, 0x78, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFE, 0x3F, 0xEF, 0xDE, 0x79, 0xE3,
  0x1E, 0x23, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x3E, 0x02, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x03,
  0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF2, 0x00, 0x78, 0xE0, 0x7E, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xDE, 0x00, 0xE7,
  0x80, 0x71, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0x83, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0x3F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x88, 0x03, 0xE3, 0x03, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x3F, 0x07, 0xFF, 0xC3, 0xBF, 0xF3,
  0xF0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCE, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF8, 0x78, 0x3F,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38,
  0x0F, 0x0E, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x1E, 0x7C, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x87,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x20,
  0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF8, 0xF0, 0x3C, 0x78,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0xF9, 0xE0, 0x7C, 0xF8, 0xFE, 0x3F, 0xEE, 0x1F, 0xEF, 0x07, 0xE7,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x81, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x07,
  0xC3, 0xE1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x3E, 0x1F, 0x07, 0x80, 0x01, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x7F, 0xC7,
  0xFF, 0x8F, 0xFF, 0x30, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xE7, 0xE0, 0x0F, 0x80, 0x3C, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x70, 0x1F, 0x07, 0x38,
  0x1F, 0xF1, 0xCE, 0x0F, 0xF8, 0x77, 0x07, 0x0E, 0x1D, 0xC3, 0x83, 0x87,
  0xE1, 0xE0, 0xE1, 0xF8, 0x70, 0x70, 0x7E, 0x1C, 0x1C, 0x1F, 0x8E, 0x07,
  0x06, 0xE3, 0x83, 0xC3, 0xB8, 0xE0, 0xE0, 0xEE, 0x38, 0x38, 0x73, 0x8E,
  0x1E, 0x3C, 0xE1, 0xFD, 0xFE, 0x38, 0x7E, 0x7F, 0x0E, 0x0F, 0x0F, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x04,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1D, 0xC0,
  0x03, 0xDC, 0x00, 0x39, 0xC0, 0x07, 0x9C, 0x00, 0x79, 0xC0, 0x0F, 0x1C,
  0x00, 0xF1, 0xC0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x0E, 0x3C, 0x00, 0xE7, 0xC0, 0x0E, 0x78,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x00,
  0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1C, 0x3F, 0x03, 0xC0, 0x78, 0x3C,
  0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x0F, 0x87, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xE0, 0x60, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x06, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0x0F, 0xC0,
  0x78, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F,
  0x00, 0x7C, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07, 0xC1, 0xE0,
  0x7E, 0x0F, 0x3F, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7E, 0x03, 0x07, 0xE0, 0x08, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0xFB, 0xE0, 0x7F, 0xDE, 0x03, 0xFC, 0xF0, 0x1F, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x7C, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x80, 0x78, 0x7E, 0x07, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x7F, 0x81, 0xFF, 0x83, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xE0,
  0xF8, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0,
  0x0F, 0x3E, 0x00, 0x39, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x9E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0xC1, 0xDC, 0x01, 0xDE, 0x0E, 0xF0, 0x1E, 0xE0, 0x77, 0x80,
  0xEF, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xE0, 0x73, 0xC1, 0xE7, 0x07, 0x9E,
  0x0E, 0x38, 0x38, 0xE0, 0x71, 0xC3, 0xCF, 0x07, 0x8E, 0x1C, 0x78, 0x3C,
  0x71, 0xE3, 0xC1, 0xC3, 0x8E, 0x1C, 0x0E, 0x1C, 0xF1, 0xE0, 0xF0, 0xE7,
  0x0F, 0x07, 0x87, 0x78, 0x78, 0x3C, 0x3F, 0x83, 0xC1, 0xC1, 0xFC, 0x1C,
  0x0E, 0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0E, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xE0, 0x0F,
  0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E,
  0x0E, 0xF0, 0x1E, 0x0E, 0x70, 0x1C, 0x0E, 0x78, 0x3C, 0x1E, 0x78, 0x3C,
  0x1E, 0x38, 0x3C, 0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x38, 0x3C, 0x1C, 0x78,
  0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x70, 0x38, 0x0E, 0x70,
  0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0xF0, 0x70, 0x07, 0xE0,
  0x70, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xC1, 0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00,
  0x7C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F,
  0x87, 0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x7E, 0x1F, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xC3, 0xF0, 0x78, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF0,
  0x3E, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF0,
  0x00, 0xF7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x87, 0x80,
  0x3C, 0x1F, 0x01, 0xF0, 0x7E, 0x1F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xC3, 0xE0, 0x78, 0x3E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03,
  0xE1, 0xE3, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3C, 0x78,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7C,
  0x18, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x84, 0x01, 0xF0, 0xE0, 0x7C,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x80, 0xF0, 0x1F, 0x0F, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x01, 0xF7,
  0x00, 0x1E, 0x70, 0x03, 0xE7, 0x00, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F,
  0x00, 0x38, 0xF0, 0x03, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xBC, 0x00, 0x3B,
  0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03,
  0xF8, 0x03, 0xC0, 0x3D, 0xC0, 0x3E, 0x01, 0xEE, 0x01, 0xF0, 0x1E, 0x70,
  0x1F, 0x80, 0xF3, 0x80, 0xFC, 0x07, 0x9C, 0x0F, 0xE0, 0x78, 0xE0, 0x77,
  0x03, 0xC7, 0x03, 0xB8, 0x3C, 0x38, 0x39, 0xC1, 0xE1, 0xC1, 0xCF, 0x0E,
  0x0E, 0x1E, 0x78, 0xF0, 0x70, 0xE3, 0xC7, 0x83, 0x8F, 0x1E, 0x78, 0x1C,
  0x70, 0xF3, 0xC0, 0xE7, 0x87, 0x9C, 0x07, 0xB8, 0x3D, 0xE0, 0x39, 0xC1,
  0xEE, 0x01, 0xDE, 0x0F, 0xF0, 0x0E, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xB8,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07,
  0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x01, 0xE0,
  0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xEF,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF9, 0xE0,
  0x3C, 0x78, 0x1E, 0x0E, 0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78,
  0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C,
  0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70, 0xE1,
  0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xF0, 0x0E,
  0x38, 0x0E, 0x1C, 0x07, 0x07, 0x07, 0x03, 0x87, 0x81, 0xE3, 0x80, 0x73,
  0xC0, 0x39, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF3, 0xC7, 0x9E, 0x38, 0x70, 0x00, 0xE0, 0x20, 0x7F, 0x38, 0x1F, 0xF7,
  0x07, 0xEF, 0xE1, 0xF0, 0xFC, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0xC1,
  0xFF, 0xF8, 0x1F, 0xEE, 0x01, 0xF9, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x1C, 0x03, 0x9F, 0xC1, 0xEF, 0xF8, 0x7F, 0x3E, 0x1F, 0x87,
  0x87, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1E, 0x3F, 0x0F, 0x8E, 0xFF, 0xC3, 0xBF, 0xE0, 0xE7, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x7E, 0xE1, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x21, 0xFF,
  0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xE1, 0xC0, 0x3F, 0x9C, 0x07, 0xFF, 0xC0, 0xF9, 0xFC, 0x1F,
  0x0F, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x07, 0x87, 0xE0, 0x7F, 0xFE,
  0x03, 0xFD, 0xC0, 0x1F, 0x1C, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0x9F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x78, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xE2, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x10, 0x1F, 0xCE, 0x03, 0xFE, 0xE0, 0x7E, 0xFE, 0x0F, 0x87, 0xE0,
  0xF0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F,
  0x87, 0x81, 0xF0, 0x3C, 0x1F, 0x03, 0xC3, 0xF0, 0x3F, 0xFF, 0x01, 0xFE,
  0xE0, 0x0F, 0x9E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x08, 0x03, 0xC0, 0xE0, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x1E, 0x07, 0x3F, 0x87,
  0xBF, 0xE3, 0xFD, 0xF1, 0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCE, 0x03, 0xC0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x43, 0xC1, 0xE1, 0xE0, 0xF0, 0x78,
  0x7C, 0x1E, 0x3E, 0x07, 0x9F, 0x01, 0xC7, 0x80, 0xF3, 0xC0, 0x3D, 0xE0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xE0, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x81, 0xCF, 0xE3, 0xF8,
  0x7B, 0xFC, 0xFF, 0x8F, 0xE7, 0xFD, 0xF1, 0xF8, 0x7E, 0x1E, 0x3E, 0x0F,
  0x81, 0xC7, 0x81, 0xE0, 0x79, 0xF0, 0x3C, 0x0F, 0x3C, 0x07, 0x81, 0xE7,
  0x81, 0xE0, 0x3C, 0xF0, 0x3C, 0x07, 0x1C, 0x07, 0x81, 0xE7, 0x80, 0xF0,
  0x3C, 0xF0, 0x1C, 0x07, 0x9E, 0x07, 0x80, 0xF3, 0xC0, 0xF0, 0x1C, 0x70,
  0x1E, 0x07, 0x9E, 0x03, 0xC0, 0xF3, 0xC0, 0x70, 0x1E, 0x78, 0x1E, 0x03,
  0xCE, 0x03, 0xC0, 0xF0, 0x07, 0x0F, 0x01, 0xCF, 0xE0, 0xF7, 0xFC, 0x3F,
  0xDF, 0x0F, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF3,
  0xE1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x77, 0x80, 0x7B, 0xC0, 0x3C,
  0xE0, 0x3C, 0x78, 0x1E, 0x3E, 0x3E, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x39, 0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0x3E, 0x07,
  0xE1, 0xE0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x83, 0xF0, 0xF8, 0x3F, 0xFF,
  0x03, 0xDF, 0xE0, 0x38, 0xFC, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x20, 0x7F, 0x38, 0x1F, 0xF7, 0x07,
  0xCF, 0xE1, 0xF0, 0xFC, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0xC1, 0xFF,
  0xF8, 0x1F, 0xEE, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x39, 0xF1, 0xEF, 0xC7, 0xFE, 0x1F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8,
  0xE1, 0xE0, 0x47, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x79, 0x81, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3F, 0xC7, 0xF8, 0x7F, 0x00, 0x1E, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0xFC, 0x7F, 0xFE, 0x3F, 0xEE,
  0x0F, 0xC7, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x38, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71,
  0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x7B, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F,
  0x03, 0xFC, 0x1F, 0x83, 0xDE, 0x0F, 0xC1, 0xEF, 0x0F, 0xE1, 0xE7, 0x87,
  0x70, 0xF3, 0xC3, 0xB8, 0x71, 0xE3, 0x9C, 0x78, 0xF1, 0xCE, 0x38, 0x79,
  0xC7, 0x3C, 0x1C, 0xE3, 0x9E, 0x0E, 0xF1, 0xDE, 0x07, 0x70, 0xEF, 0x03,
  0xB8, 0x77, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x38, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xC7, 0x80, 0x1E,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x07, 0x9C, 0x00,
  0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0,
  0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0x81, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xDE, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1C, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xBF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 27, 10, 1, -27 },
  { 35, 12, 10, 15, 4, -27 },
  { 50, 21, 27, 22, 1, -27 },
  { 121, 18, 31, 19, 1, -29 },
  { 191, 25, 28, 29, 2, -28 },
  { 279, 21, 28, 23, 1, -28 },
  { 353, 5, 10, 8, 4, -27 },
  { 360, 13, 33, 11, 1, -27 },
  { 414, 13, 33, 11, -3, -27 },
  { 468, 15, 16, 18, 4, -29 },
  { 498, 17, 19, 20, 2, -23 },
  { 539, 8, 9, 9, -2, -4 },
  { 548, 9, 4, 11, 1, -12 },
  { 553, 6, 5, 9, 0, -5 },
  { 557, 19, 27, 14, -2, -27 },
  { 622, 18, 28, 19, 1, -28 },
  { 685, 12, 27, 19, 4, -27 },
  { 726, 19, 28, 19, -1, -28 },
  { 793, 18, 28, 19, 0, -28 },
  { 856, 18, 27, 19, 0, -27 },
  { 917, 18, 27, 19, 1, -27 },
  { 978, 17, 28, 19, 2, -28 },
  { 1038, 18, 27, 19, 2, -27 },
  { 1099, 18, 28, 19, 1, -28 },
  { 1162, 17, 28, 19, 1, -28 },
  { 1222, 9, 21, 9, 0, -21 },
  { 1246, 11, 26, 9, -2, -21 },
  { 1282, 17, 19, 20, 2, -23 },
  { 1323, 17, 11, 20, 2, -19 },
  { 1347, 17, 19, 20, 2, -23 },
  { 1388, 14, 28, 15, 2, -28 },
  { 1437, 26, 30, 29, 2, -27 },
  { 1535, 20, 27, 20, -2, -27 },
  { 1603, 20, 27, 21, 1, -27 },
  { 1671, 20, 28, 20, 2, -28 },
  { 1741, 21, 27, 23, 1, -27 },
  { 1812, 18, 27, 18, 1, -27 },
  { 1873, 18, 27, 17, 1, -27 },
  { 1934, 21, 28, 23, 2, -28 },
  { 2008, 23, 27, 23, 1, -27 },
  { 2086, 15, 27, 12, -1, -27 },
  { 2137, 17, 34, 10, -6, -27 },
  { 2210, 22, 27, 20, 1, -27 },
  { 2285, 13, 27, 17, 1, -27 },
  { 2329, 29, 27, 30, 1, -27 },
  { 2427, 24, 27, 25, 1, -27 },
  { 2508, 22, 28, 25, 2, -28 },
  { 2585, 19, 27, 20, 1, -27 },
  { 2650, 22, 34, 25, 2, -28 },
  { 2744, 19, 27, 20, 1, -27 },
  { 2809, 19, 28, 18, 0, -28 },
  { 2876, 17, 27, 17, 3, -27 },
  { 2934, 22, 27, 23, 2, -27 },
  { 3009, 20, 27, 19, 3, -27 },
  { 3077, 29, 27, 30, 4, -27 },
  { 3175, 24, 27, 19, -2, -27 },
  { 3256, 18, 27, 18, 3, -27 },
  { 3317, 21, 27, 18, -1, -27 },
  { 3388, 15, 33, 11, -1, -27 },
  { 3450, 7, 27, 14, 4, -27 },
  { 3474, 15, 33, 11, -3, -27 },
  { 3536, 17, 16, 19, 1, -27 },
  { 3570, 14, 3, 14, -3, 3 },
  { 3576, 6, 6, 11, 6, -29 },
  { 3581, 19, 21, 20, 1, -21 },
  { 3631, 18, 29, 20, 1, -29 },
  { 3697, 15, 21, 16, 1, -21 },
  { 3737, 20, 29, 20, 1, -29 },
  { 3810, 16, 21, 18, 1, -21 },
  { 3852, 20, 38, 11, -4, -29 },
  { 3947, 20, 30, 20, 0, -21 },
  { 4022, 17, 29, 20, 1, -29 },
  { 4084, 9, 28, 9, 1, -28 },
  { 4116, 15, 37, 9, -5, -28 },
  { 4186, 18, 29, 18, 1, -29 },
  { 4252, 10, 29, 9, 1, -29 },
  { 4289, 27, 21, 30, 1, -21 },
  { 4360, 18, 21, 20, 0, -21 },
  { 4408, 17, 21, 20, 1, -21 },
  { 4453, 20, 30, 20, -1, -21 },
  { 4528, 19, 30, 20, 1, -21 },
  { 4600, 14, 21, 14, 1, -21 },
  { 4637, 15, 21, 15, 0, -21 },
  { 4677, 11, 25, 12, 2, -25 },
  { 4712, 17, 20, 20, 2, -20 },
  { 4755, 16, 20, 16, 2, -20 },
  { 4795, 25, 20, 26, 2, -20 },
  { 4858, 20, 20, 17, -2, -20 },
  { 4908, 22, 29, 17, -3, -20 },
  { 4988, 16, 20, 15, -1, -20 },
  { 5028, 15, 33, 13, 0, -27 },
  { 5090, 3, 38, 18, 8, -29 },
  { 5105, 15, 33, 13, -2, -27 },
  { 5167, 17, 5, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC38PT7B_H_
