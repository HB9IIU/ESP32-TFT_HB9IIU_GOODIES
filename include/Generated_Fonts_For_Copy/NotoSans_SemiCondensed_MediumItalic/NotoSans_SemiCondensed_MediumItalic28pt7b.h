#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x73, 0xB1, 0x99,
  0xDC, 0xEE, 0x66, 0x33, 0x18, 0x01, 0xC6, 0x01, 0x86, 0x01, 0x8C, 0x01,
  0x8C, 0x03, 0x0C, 0x03, 0x18, 0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x38, 0x06,
  0x30, 0x0E, 0x30, 0x0C, 0x30, 0x7F, 0xFE, 0x7F, 0xFE, 0x98, 0x60, 0x18,
  0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x00, 0xC0, 0x04,
  0x01, 0xF8, 0x3F, 0xF1, 0xFF, 0x1C, 0x80, 0xE4, 0x07, 0x60, 0x3B, 0x00,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0x70, 0x13, 0x80, 0x9C, 0x8C,
  0xE7, 0xFE, 0x3F, 0xE0, 0x78, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1E,
  0x03, 0x8F, 0xC1, 0xC7, 0x30, 0x61, 0x8C, 0x30, 0xE3, 0x1C, 0x30, 0xC6,
  0x0C, 0x73, 0x03, 0x19, 0xC0, 0xC6, 0x67, 0xB3, 0xB3, 0xFF, 0xDD, 0x8D,
  0xE6, 0xE3, 0x03, 0x38, 0xC1, 0xCC, 0x70, 0x63, 0x1C, 0x30, 0xC6, 0x1C,
  0x31, 0x86, 0x0C, 0xE3, 0x03, 0xF1, 0xC0, 0x78, 0x03, 0xE0, 0x1F, 0xE0,
  0x39, 0xC0, 0xE1, 0x81, 0xC3, 0x03, 0x8E, 0x07, 0x38, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x3B, 0x9C, 0x7E, 0x39, 0xDC, 0x3B, 0xB0, 0x7E,
  0x60, 0x78, 0xE0, 0xF1, 0xC7, 0xE3, 0xFE, 0xE3, 0xF9, 0xE0, 0x76, 0x6E,
  0xEC, 0xC0, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0x80, 0xE0, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC1, 0xC0, 0x07, 0x00, 0xC2, 0x18,
  0x73, 0x0F, 0xDE, 0x3F, 0xC7, 0x99, 0xF0, 0x73, 0x1C, 0x60, 0x8E, 0x01,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC,
  0xE6, 0x73, 0x00, 0xFF, 0xFB, 0xF0, 0x27, 0xFF, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x9C, 0x38, 0x63,
  0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x33, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC3, 0x9C, 0x1F, 0xE0,
  0x7C, 0x00, 0x03, 0x87, 0xC7, 0xC7, 0xEF, 0x73, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0x82, 0x0F, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8,
  0x07, 0xF0, 0x7F, 0xE0, 0xE3, 0x82, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE3, 0x07, 0x8F, 0xFC, 0x1F, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0E, 0xC0, 0x33, 0x01,
  0x9C, 0x0E, 0x70, 0x71, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF3, 0x07, 0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F,
  0xC3, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x30, 0x77, 0xE3,
  0xFF, 0x1E, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xE0,
  0xE3, 0x8E, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x1E, 0x30, 0x73, 0x83, 0x9C,
  0x1C, 0x61, 0xC3, 0x9E, 0x0F, 0xC0, 0x7C, 0x0F, 0xF0, 0xF3, 0x8F, 0x0E,
  0x70, 0x73, 0x81, 0x9C, 0x1C, 0xE0, 0xE7, 0x8F, 0x1F, 0xF0, 0x7E, 0x00,
  0x07, 0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x30, 0x77, 0x03, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x0F, 0x7F, 0xF3, 0xF7, 0x0C, 0x60, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x88, 0xF8, 0xFF, 0x0F, 0xC0, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x73, 0xCF, 0x00, 0x0E, 0x1C, 0x38, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0x1C, 0x38, 0xE1, 0x83, 0x00, 0x00,
  0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x03, 0xE1, 0xF8, 0x7C,
  0x0F, 0x00, 0xC0, 0x08, 0x00, 0x3F, 0x3F, 0xE6, 0x3C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x1C, 0x0F, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07,
  0x81, 0xC0, 0xE0, 0x0E, 0x1C, 0x00, 0x61, 0x81, 0x87, 0x30, 0xFE, 0x37,
  0x1C, 0xE3, 0x63, 0x8C, 0x36, 0x30, 0xC3, 0xE7, 0x0C, 0x7E, 0x61, 0xC6,
  0xE6, 0x18, 0x6C, 0x61, 0x8E, 0xC6, 0x39, 0xCC, 0x7E, 0xF8, 0xE3, 0xCF,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x40, 0x1F, 0x7C, 0x00, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B,
  0x80, 0x77, 0x01, 0xC6, 0x03, 0x8C, 0x0E, 0x18, 0x1C, 0x30, 0x30, 0x60,
  0xFF, 0xE1, 0xFF, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1D, 0xC0,
  0x3F, 0x80, 0x70, 0x0F, 0xF0, 0x3F, 0xE1, 0xC7, 0xC7, 0x07, 0x1C, 0x1C,
  0x70, 0x73, 0x81, 0xCE, 0x0E, 0x3F, 0xF0, 0xFF, 0x03, 0xFF, 0x1C, 0x1C,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0x98, 0x1E, 0xE0, 0x73, 0x8F, 0xCF, 0xFC,
  0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xF1, 0xF1, 0x87, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE3, 0x07, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE1, 0xC0, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0xF7,
  0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x30, 0x3C, 0xE0, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0xFC, 0x0F,
  0xFC, 0x7C, 0x38, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC1, 0xFB, 0x83, 0xF7, 0x0F, 0xEE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xF0, 0x38, 0xF0, 0xE1, 0xFF, 0xC0, 0xFF, 0x00, 0x0E,
  0x03, 0x86, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x30,
  0xE0, 0x38, 0x70, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x00, 0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0x0F, 0xF0,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1E, 0x0F, 0xC0,
  0xF8, 0x04, 0x00, 0x0E, 0x0F, 0x0C, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C,
  0x70, 0x1C, 0xE0, 0x39, 0xE0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x3F,
  0x80, 0x7B, 0x80, 0x73, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x61, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x3F, 0xFF, 0xFB, 0xFE, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xB0, 0x1B, 0x0D, 0x81, 0xF8,
  0xEC, 0x0D, 0xC7, 0x60, 0xEE, 0x3B, 0x06, 0x61, 0xD8, 0x77, 0x0C, 0xE3,
  0x38, 0xE7, 0x39, 0xC7, 0x39, 0x8E, 0x39, 0xDC, 0x61, 0x86, 0xC7, 0x0C,
  0x3E, 0x38, 0xE1, 0xE1, 0xC7, 0x0F, 0x0E, 0x38, 0x70, 0x61, 0x83, 0x87,
  0x00, 0x0E, 0x01, 0xC3, 0x80, 0x61, 0xF0, 0x38, 0x7C, 0x0E, 0x1B, 0x03,
  0x86, 0xE0, 0xC3, 0xB8, 0x70, 0xE6, 0x1C, 0x39, 0xC7, 0x0E, 0x71, 0xC3,
  0x1C, 0x61, 0xC3, 0x38, 0x70, 0xEE, 0x1C, 0x3B, 0x86, 0x06, 0xE1, 0x81,
  0xF0, 0xE0, 0x7C, 0x38, 0x1F, 0x0E, 0x03, 0xC3, 0x00, 0xE0, 0x03, 0xF0,
  0x1F, 0xF8, 0x7C, 0xF1, 0xE0, 0x73, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x78, 0xF3, 0xE1, 0xFF, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x73, 0x81,
  0xCE, 0x0F, 0x38, 0x38, 0xE3, 0xE3, 0xFF, 0x1F, 0xF0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x03,
  0xF8, 0x1F, 0xF8, 0x7C, 0xF1, 0xE0, 0x73, 0x80, 0xEE, 0x01, 0xDC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xB8, 0x07, 0x70, 0x1C, 0xE0, 0x78, 0xF3, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0xE0,
  0x3F, 0xE1, 0xCF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x0E,
  0x38, 0x78, 0xFF, 0xC3, 0xFE, 0x1F, 0xE0, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x18, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0F, 0x38, 0x1C, 0x03, 0xF8, 0x3F,
  0xF1, 0xF3, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x80, 0xE3, 0x8F, 0x8F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x30, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0xF0, 0xF1, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xC0, 0x3F, 0x00,
  0xEC, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1,
  0xC3, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x1B,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x3F, 0x01,
  0xC0, 0xEC, 0x0F, 0x03, 0xB0, 0x3C, 0x1C, 0xC1, 0xF0, 0x73, 0x06, 0xC3,
  0x8E, 0x3B, 0x0E, 0x38, 0xEC, 0x30, 0xE3, 0x31, 0xC3, 0x9C, 0xC7, 0x0E,
  0x63, 0x38, 0x3B, 0x8C, 0xE0, 0xEC, 0x33, 0x03, 0xF0, 0xDC, 0x0D, 0xC3,
  0x60, 0x36, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0,
  0x38, 0x0E, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x38, 0x70, 0x0E, 0x3C,
  0x03, 0x8E, 0x00, 0x67, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x07, 0x81, 0xC3, 0xC0, 0x70,
  0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC3, 0xCE, 0x1C, 0x31, 0xC1, 0xCE, 0x0E,
  0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x80, 0x03,
  0xE0, 0xFC, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1F, 0x87, 0xE0, 0xE7, 0x39, 0xC6, 0x31,
  0x8E, 0x73, 0x9C, 0x63, 0x18, 0xE7, 0x39, 0xC6, 0x30, 0x07, 0xE0, 0xFC,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x3F, 0x07, 0xE0, 0x03, 0x00, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xDC, 0x0E, 0x60, 0x63, 0x07, 0x1C, 0x30, 0x63, 0x83, 0xB8, 0x0D,
  0x80, 0x70, 0x7F, 0xFF, 0xFC, 0xE3, 0x8C, 0x30, 0x0F, 0x98, 0xFE, 0xCF,
  0x1E, 0x70, 0xF7, 0x07, 0x38, 0x39, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x07,
  0x38, 0x39, 0xC3, 0xCF, 0x3E, 0x3F, 0x71, 0xF3, 0x00, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xDF, 0x07, 0xFE, 0x1F,
  0x38, 0x78, 0x71, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8C,
  0x0E, 0x70, 0x79, 0xE1, 0xC7, 0x8E, 0x1B, 0xF8, 0xE7, 0xC0, 0x0F, 0xE3,
  0xFC, 0xF1, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x18, 0xFF, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x03, 0xEE, 0x0F, 0xFC, 0x3C, 0x78,
  0x70, 0xF1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x70, 0xE0, 0xE1, 0xC3, 0xC3, 0xCF, 0x83, 0xF6, 0x03, 0xCC, 0x00, 0x0F,
  0xC1, 0xFE, 0x3C, 0x63, 0x87, 0x70, 0x67, 0x0E, 0xFF, 0xCF, 0xF8, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0xCC, 0x3F, 0xB1, 0xE3, 0xC7, 0x0F, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x3C,
  0x79, 0xF0, 0xFD, 0x83, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x88, 0x1C,
  0x3F, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xDF, 0x87, 0xFE, 0x1F, 0x38, 0x78, 0x71,
  0xC1, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8C, 0x0C, 0x70, 0x71,
  0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0xE0, 0x06, 0x0F, 0x0E, 0x04, 0x00,
  0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0xE0, 0x04, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC3, 0xC7, 0x0E,
  0x1C, 0x70, 0x73, 0x81, 0x9C, 0x0E, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x0E, 0x60, 0x71, 0xC1, 0xC7, 0x07, 0x0E, 0x1C, 0x38, 0xE0, 0xE0, 0x07,
  0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x1D, 0xF1, 0xF0, 0xFF,
  0xDF, 0xC7, 0xCF, 0x8E, 0x38, 0x78, 0x71, 0xC3, 0xC3, 0x9C, 0x1C, 0x1C,
  0xE0, 0xE0, 0xC7, 0x07, 0x0E, 0x38, 0x30, 0x71, 0x83, 0x83, 0x9C, 0x1C,
  0x1C, 0xE0, 0xE0, 0xC7, 0x06, 0x0E, 0x38, 0x70, 0x73, 0x83, 0x83, 0x80,
  0x1D, 0xF8, 0x7F, 0xE1, 0xF3, 0x87, 0x87, 0x1C, 0x18, 0xF0, 0xE3, 0x83,
  0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xCE, 0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0x73, 0x87, 0x70, 0x77, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xF8,
  0x3F, 0x00, 0x0E, 0x78, 0x1F, 0xF8, 0x3E, 0x70, 0x78, 0x70, 0xE0, 0xE3,
  0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x30, 0x38, 0xE0, 0xF1, 0xE1,
  0xC3, 0xC7, 0x06, 0xFE, 0x0C, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x98, 0xFE, 0xCF,
  0x1E, 0x70, 0xF7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07,
  0x38, 0x39, 0xC3, 0xCF, 0x3E, 0x3F, 0x60, 0xF7, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1D, 0xE3, 0xFC, 0x7E,
  0x8F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0xE3, 0xFC, 0xE1, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x06, 0x01, 0xC8, 0x39, 0xFF,
  0x3F, 0x80, 0x0C, 0x0E, 0x07, 0x0F, 0xFF, 0xF1, 0xC0, 0xE0, 0x70, 0x30,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xFC, 0x3E, 0x00, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E,
  0x60, 0x67, 0x07, 0x38, 0x39, 0xC3, 0xCF, 0x3E, 0x3F, 0x61, 0xF3, 0x00,
  0xE0, 0x7B, 0x03, 0x98, 0x38, 0xC1, 0xC7, 0x1C, 0x38, 0xE1, 0xCE, 0x0E,
  0x70, 0x77, 0x03, 0xB8, 0x1D, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0xC1, 0xC1, 0xF0, 0x70, 0x6C, 0x3C, 0x3B, 0x0F, 0x0E, 0xC7, 0xC7,
  0x31, 0xB1, 0xCC, 0xEC, 0x63, 0x33, 0x38, 0xCC, 0xCC, 0x37, 0x37, 0x0D,
  0x8D, 0xC3, 0xE3, 0x60, 0xF0, 0xF8, 0x3C, 0x3C, 0x0E, 0x0F, 0x00, 0x1C,
  0x1E, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0x6E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x77, 0x01, 0xC6, 0x03, 0x8E, 0x0E,
  0x1C, 0x38, 0x1C, 0x00, 0x0C, 0x0F, 0x0C, 0x0E, 0x0C, 0x1C, 0x0E, 0x1C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0xE0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xC0, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xFC, 0xFF, 0xC0, 0x00,
  0xE0, 0x7C, 0x0F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC1, 0xF0, 0xE0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0xE3,
  0xDF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 7, 11, 3, -20 },
  { 29, 16, 20, 16, 0, -20 },
  { 69, 13, 23, 14, 1, -21 },
  { 107, 18, 20, 21, 2, -20 },
  { 152, 15, 20, 17, 1, -20 },
  { 190, 4, 7, 6, 3, -20 },
  { 194, 9, 24, 8, 1, -20 },
  { 221, 9, 24, 8, -2, -20 },
  { 248, 11, 12, 14, 3, -21 },
  { 265, 12, 14, 15, 2, -17 },
  { 286, 5, 7, 7, -1, -3 },
  { 291, 7, 3, 8, 1, -9 },
  { 294, 4, 4, 7, 0, -4 },
  { 296, 13, 20, 10, -1, -20 },
  { 329, 13, 20, 14, 1, -20 },
  { 362, 9, 20, 14, 3, -20 },
  { 385, 14, 20, 14, 0, -20 },
  { 420, 14, 20, 14, 0, -20 },
  { 455, 14, 20, 14, 0, -20 },
  { 490, 14, 20, 14, 0, -20 },
  { 525, 13, 20, 14, 1, -20 },
  { 558, 13, 20, 14, 2, -20 },
  { 591, 13, 20, 14, 1, -20 },
  { 624, 12, 20, 14, 1, -20 },
  { 654, 6, 15, 7, 0, -15 },
  { 666, 7, 19, 7, -1, -15 },
  { 683, 12, 14, 15, 2, -17 },
  { 704, 12, 8, 15, 2, -14 },
  { 716, 12, 14, 15, 2, -17 },
  { 737, 10, 20, 11, 2, -20 },
  { 762, 20, 22, 21, 1, -20 },
  { 817, 15, 20, 15, -2, -20 },
  { 855, 14, 20, 15, 1, -20 },
  { 890, 14, 20, 15, 2, -20 },
  { 925, 15, 20, 17, 1, -20 },
  { 963, 13, 20, 13, 1, -20 },
  { 996, 13, 20, 12, 1, -20 },
  { 1029, 15, 20, 17, 2, -20 },
  { 1067, 17, 20, 17, 1, -20 },
  { 1110, 12, 20, 9, -1, -20 },
  { 1140, 12, 26, 7, -4, -20 },
  { 1179, 16, 20, 15, 1, -20 },
  { 1219, 10, 20, 12, 1, -20 },
  { 1244, 21, 20, 22, 1, -20 },
  { 1297, 18, 20, 18, 1, -20 },
  { 1342, 15, 20, 18, 2, -20 },
  { 1380, 14, 20, 15, 1, -20 },
  { 1415, 15, 25, 18, 2, -20 },
  { 1462, 14, 20, 15, 1, -20 },
  { 1497, 14, 20, 13, 0, -20 },
  { 1532, 13, 20, 13, 2, -20 },
  { 1565, 16, 20, 17, 2, -20 },
  { 1605, 14, 20, 14, 3, -20 },
  { 1640, 22, 20, 22, 3, -20 },
  { 1695, 18, 20, 14, -2, -20 },
  { 1740, 13, 20, 13, 3, -20 },
  { 1773, 15, 20, 13, -1, -20 },
  { 1811, 11, 24, 8, -1, -20 },
  { 1844, 5, 20, 10, 3, -20 },
  { 1857, 11, 24, 8, -2, -20 },
  { 1890, 13, 12, 14, 1, -20 },
  { 1910, 11, 2, 10, -3, 2 },
  { 1913, 5, 4, 8, 4, -21 },
  { 1916, 13, 15, 15, 1, -15 },
  { 1941, 14, 21, 15, 0, -21 },
  { 1978, 11, 15, 12, 1, -15 },
  { 1999, 15, 21, 15, 1, -21 },
  { 2039, 12, 15, 13, 1, -15 },
  { 2062, 15, 28, 8, -3, -21 },
  { 2115, 14, 22, 15, 0, -15 },
  { 2154, 14, 21, 15, 0, -21 },
  { 2191, 8, 21, 7, 0, -21 },
  { 2212, 12, 28, 7, -4, -21 },
  { 2254, 14, 21, 13, 0, -21 },
  { 2291, 8, 21, 7, 0, -21 },
  { 2312, 21, 15, 22, 0, -15 },
  { 2352, 14, 15, 15, 0, -15 },
  { 2379, 12, 15, 14, 1, -15 },
  { 2402, 15, 22, 15, -1, -15 },
  { 2444, 13, 22, 15, 1, -15 },
  { 2480, 11, 15, 10, 0, -15 },
  { 2501, 11, 15, 11, 0, -15 },
  { 2522, 9, 18, 9, 1, -18 },
  { 2543, 13, 15, 15, 1, -15 },
  { 2568, 13, 15, 12, 1, -15 },
  { 2593, 18, 15, 19, 2, -15 },
  { 2627, 15, 15, 13, -1, -15 },
  { 2656, 16, 22, 12, -2, -15 },
  { 2700, 12, 15, 11, -1, -15 },
  { 2723, 11, 24, 10, 0, -20 },
  { 2756, 2, 28, 14, 6, -21 },
  { 2763, 10, 24, 10, -1, -20 },
  { 2793, 12, 4, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC28PT7B_H_
