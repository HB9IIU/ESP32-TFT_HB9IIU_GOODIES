#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x79, 0xEF, 0x3D, 0xC7, 0xB8,
  0xEF, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x07,
  0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xE1,
  0xC0, 0x06, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01,
  0xC3, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3D, 0xCC, 0x3C, 0xC0, 0x1C, 0x60,
  0x0E, 0x30, 0x07, 0x98, 0x03, 0xD8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xDF, 0x00, 0x67, 0x80, 0x33, 0xC0,
  0x39, 0xE4, 0x18, 0xF3, 0x0C, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x03, 0x80, 0x02,
  0x0F, 0xC0, 0x1C, 0x1F, 0xE0, 0x38, 0x3C, 0xE0, 0x38, 0x38, 0xE0, 0x70,
  0x78, 0xE0, 0xE0, 0x70, 0xE0, 0xE0, 0x70, 0xE1, 0xC0, 0x70, 0xE3, 0x80,
  0x70, 0xE3, 0x80, 0xE1, 0xE7, 0x00, 0xE1, 0xCE, 0x3E, 0xE1, 0xCE, 0xFF,
  0x73, 0x9C, 0xFF, 0x7F, 0xB9, 0xC7, 0x7F, 0x39, 0xC7, 0x1C, 0x73, 0x87,
  0x00, 0xE3, 0x87, 0x00, 0xE3, 0x87, 0x01, 0xC3, 0x87, 0x03, 0x87, 0x07,
  0x03, 0x87, 0x0E, 0x07, 0x07, 0x0E, 0x0E, 0x07, 0x1E, 0x0E, 0x03, 0xBC,
  0x1C, 0x03, 0xF8, 0x38, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0x9F, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E,
  0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xE7, 0xDE, 0x1E,
  0x78, 0xF0, 0xE3, 0x83, 0xCF, 0x3C, 0x0F, 0x71, 0xE0, 0x7F, 0x8E, 0x01,
  0xF8, 0x70, 0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x0F, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0x9E, 0x0F, 0xF0, 0xF8, 0x7B, 0xDC, 0xEF, 0x73, 0x9C, 0xE0, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x04, 0x1C, 0x0E, 0x38, 0x1F, 0x70,
  0x3F, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x3F, 0x00, 0xF7, 0x03, 0xCE, 0x0F,
  0x8E, 0x06, 0x1C, 0x08, 0x3C, 0x00, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xDF, 0xF7,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFB, 0xE0, 0xF8,
  0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1C, 0xE0, 0x1E,
  0x70, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0x81,
  0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x0F, 0xE1, 0xFE, 0x3F, 0xEF, 0xDE, 0x71, 0xC2, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x38, 0x3E, 0x04, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0x3F, 0x06, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x88, 0x01, 0xE3,
  0x01, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1F, 0xE0, 0x07,
  0x78, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1C, 0x38,
  0x0E, 0x0E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE4, 0x01, 0xE3, 0x03, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFE,
  0x60, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x38, 0x0F, 0x7F, 0x07, 0x7F, 0xC7, 0xF3, 0xE3, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0xCE, 0x03,
  0xC7, 0x01, 0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78,
  0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x0E, 0x07, 0x87, 0x87, 0x83, 0xC7,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0x7C, 0x78, 0x7C,
  0x3E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xF0, 0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xF3, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x01,
  0xF3, 0xC0, 0xF1, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xDE, 0x0F, 0xCE, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE1,
  0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x78, 0xF8, 0xF8, 0x78, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x07, 0xC0, 0xFF, 0xC7, 0xFF, 0x8F, 0xBE, 0x20, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x01,
  0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x3F,
  0xC7, 0x38, 0x3F, 0xE1, 0xB8, 0x3C, 0x70, 0xDC, 0x38, 0x70, 0x6C, 0x38,
  0x38, 0x3E, 0x1C, 0x1C, 0x3F, 0x1E, 0x0E, 0x1F, 0x8E, 0x0E, 0x0F, 0xC7,
  0x07, 0x07, 0xC3, 0x83, 0x87, 0x61, 0xC3, 0xC3, 0xB0, 0xE1, 0xE3, 0x98,
  0x7B, 0xFF, 0x8E, 0x1F, 0x9F, 0xC7, 0x07, 0x87, 0x83, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x07, 0xE3, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0xF0,
  0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0,
  0x3C, 0x1C, 0x07, 0x83, 0x81, 0xE0, 0x70, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3C, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x3E, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x1E, 0x1C, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7C, 0x04, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x60, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x70, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80,
  0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x81, 0xF0, 0x70,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0x03, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xF3, 0xC0, 0x7F, 0x9E, 0x07,
  0xFC, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x7C, 0x01, 0xC1, 0xF0, 0x1E, 0x0F, 0xC0, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0xC1, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x1F, 0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0x80, 0xFC, 0x1E, 0x07, 0xC0, 0x78, 0x1E, 0x01, 0xC0, 0xF0,
  0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x0E,
  0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0x78, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xEE, 0x0E, 0xE0, 0x1F, 0xE0, 0xEE, 0x01, 0xDE,
  0x0E, 0xE0, 0x3D, 0xE1, 0xEE, 0x03, 0x9C, 0x1E, 0xE0, 0x7B, 0xC1, 0xCF,
  0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x38, 0x3C, 0x71, 0xE3,
  0x83, 0xC7, 0x1C, 0x78, 0x38, 0x73, 0xC7, 0x83, 0x87, 0x38, 0x78, 0x78,
  0x77, 0x87, 0x07, 0x87, 0x70, 0x70, 0x78, 0x7F, 0x0F, 0x07, 0x07, 0xE0,
  0xF0, 0x70, 0x7E, 0x0F, 0x0F, 0x07, 0xC0, 0xE0, 0xF0, 0x7C, 0x1E, 0x0E,
  0x07, 0x81, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0E, 0x07, 0xE0, 0x1E,
  0x07, 0xE0, 0x1E, 0x0F, 0xE0, 0x1E, 0x0E, 0xE0, 0x1C, 0x0E, 0xF0, 0x3C,
  0x0E, 0xF0, 0x3C, 0x0E, 0x70, 0x3C, 0x1E, 0x78, 0x38, 0x1E, 0x78, 0x38,
  0x1C, 0x38, 0x78, 0x1C, 0x38, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x70,
  0x3C, 0x1C, 0x70, 0x38, 0x1E, 0xF0, 0x38, 0x1E, 0xF0, 0x78, 0x0E, 0xF0,
  0x78, 0x0E, 0xE0, 0x78, 0x0F, 0xE0, 0x70, 0x0F, 0xE0, 0x70, 0x07, 0xE0,
  0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80,
  0x78, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0xC3, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03,
  0xC1, 0xC3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07,
  0x80, 0x78, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0xC3,
  0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1C, 0x1F, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0xF1,
  0xE0, 0x3C, 0x78, 0x0E, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x80, 0x83,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x88, 0x03, 0xE3, 0x81, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xC0,
  0x0F, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87,
  0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x07, 0x38,
  0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0xFF,
  0x00, 0xF8, 0x07, 0xB8, 0x07, 0xC0, 0x79, 0xC0, 0x3E, 0x03, 0xCE, 0x03,
  0xF0, 0x1C, 0x70, 0x1F, 0x81, 0xE3, 0x81, 0xDC, 0x0F, 0x1C, 0x0E, 0xE0,
  0xF0, 0xE0, 0xF7, 0x07, 0x87, 0x07, 0x38, 0x38, 0x38, 0x39, 0xC3, 0xC1,
  0xC3, 0x8E, 0x1C, 0x0E, 0x1C, 0x71, 0xE0, 0x71, 0xE3, 0x8F, 0x03, 0x8E,
  0x1C, 0xF0, 0x1C, 0xF0, 0xE7, 0x80, 0xE7, 0x07, 0x38, 0x07, 0x78, 0x3B,
  0xC0, 0x3B, 0x81, 0xDC, 0x01, 0xDC, 0x0E, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x03, 0x80,
  0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x77, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x9E, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0x07,
  0xDC, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x0E, 0x0F, 0x03,
  0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xDE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xE1, 0xC3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x3C, 0x38, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x0E, 0x1C, 0x07, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xF8, 0xF0, 0xE0,
  0xE1, 0xC1, 0xC0, 0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x8F, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03,
  0xE3, 0xC0, 0xF8, 0x78, 0x7E, 0x1F, 0xF7, 0x03, 0xFD, 0xC0, 0x7C, 0x70,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x7E, 0x0F, 0x7F, 0x87, 0xFF, 0xC3,
  0xF0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9C, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x78, 0xF0, 0x3C, 0xFC, 0x3C, 0x77, 0xFE, 0x3B, 0xFE, 0x1C, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8, 0x21, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x10, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xF3,
  0xC0, 0x7F, 0xBC, 0x0F, 0xFF, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x87, 0x80, 0x70, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F,
  0x03, 0xE0, 0x78, 0x7C, 0x07, 0xFD, 0xC0, 0x3F, 0xDC, 0x01, 0xF1, 0xC0,
  0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0E,
  0x3C, 0x1E, 0x78, 0x3E, 0x7B, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x08, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x09, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0xE0, 0x7F, 0xBC, 0x1F, 0xFF, 0x07, 0xC3, 0xE0, 0xF0,
  0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07,
  0xC3, 0xC0, 0xF8, 0x3C, 0x3E, 0x07, 0xFD, 0xC0, 0x7F, 0x78, 0x07, 0xCF,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x80, 0x78,
  0x1C, 0x1F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x7E, 0x0F, 0x7F, 0x87, 0xFF, 0xE3, 0xF0, 0xF1,
  0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0E, 0x3C, 0x07, 0x1E, 0x07,
  0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xC0, 0x78, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1C, 0x07, 0x80, 0x01, 0x03,
  0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x01, 0x3E, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x07,
  0xC7, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x1E, 0x03,
  0xCF, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x07, 0x0F, 0x01, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x00, 0x0E, 0x7E, 0x1F, 0x83, 0xDF, 0xE7, 0xF8, 0x77, 0xFD,
  0xFF, 0x0F, 0xC7, 0xF1, 0xF1, 0xF0, 0x7C, 0x1E, 0x3C, 0x0F, 0x03, 0xCF,
  0x81, 0xE0, 0x71, 0xE0, 0x78, 0x0E, 0x3C, 0x0F, 0x03, 0xC7, 0x81, 0xE0,
  0x78, 0xE0, 0x38, 0x0F, 0x3C, 0x07, 0x01, 0xC7, 0x81, 0xE0, 0x78, 0xF0,
  0x3C, 0x0F, 0x1C, 0x07, 0x81, 0xE7, 0x80, 0xE0, 0x3C, 0xF0, 0x3C, 0x07,
  0x1E, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x3C, 0x70, 0x1E, 0x07, 0x80, 0x07,
  0x3F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0x0F, 0x83, 0xC3, 0xC0,
  0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x83, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xBC, 0x03, 0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x73, 0xC0, 0x78, 0xF0, 0x7C, 0x78, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0x9F, 0x80, 0xF7, 0xF8, 0x1F, 0xFF, 0x03, 0xF0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x3F, 0x0F, 0x07, 0xFF, 0xE0, 0xEF, 0xF8,
  0x1C, 0xFC, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xF1, 0xC1, 0xFE, 0xF0, 0xFF, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F,
  0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF8,
  0x78, 0x7C, 0x1F, 0xF7, 0x03, 0xFB, 0xC0, 0xFC, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x7C, 0x7B, 0xE1, 0xFF, 0x87,
  0x72, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xF0,
  0x63, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x80,
  0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0x01, 0xC0, 0x38, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x01,
  0xFC, 0x3F, 0x83, 0xF0, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81,
  0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x38,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x81, 0xF1,
  0xE0, 0xF8, 0xF1, 0xF8, 0x7F, 0xDC, 0x3F, 0xCE, 0x0F, 0xC7, 0x00, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0x70, 0xF0, 0x70, 0xF0, 0x71, 0xE0, 0x71, 0xE0, 0x73, 0xC0, 0x73,
  0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x07, 0xBC, 0x1F, 0x03,
  0xDE, 0x0F, 0x83, 0xCF, 0x0E, 0xC1, 0xE7, 0x87, 0x60, 0xE3, 0xC3, 0xF0,
  0xF1, 0xE3, 0xB8, 0x70, 0xF1, 0xDC, 0x78, 0x79, 0xC6, 0x3C, 0x3C, 0xE3,
  0xBC, 0x1E, 0xE1, 0x9E, 0x0F, 0x70, 0xCE, 0x07, 0xB8, 0x6F, 0x01, 0xF8,
  0x37, 0x00, 0xFC, 0x1B, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1E,
  0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x03,
  0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0xF1, 0xC0, 0x1E, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x0E, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xC1, 0xE0,
  0x0E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3,
  0xC0, 0x07, 0x9C, 0x00, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x04, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00,
  0xFC, 0x07, 0xE0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x3E, 0x03, 0xF8, 0x0F,
  0xC0, 0x38, 0x00, 0x08, 0x01, 0x7F, 0x81, 0xFF, 0xF7, 0xE7, 0xFF, 0x80,
  0xFE, 0x80, 0x08,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 10, 1, -26 },
  { 31, 11, 9, 14, 4, -26 },
  { 44, 21, 26, 21, 1, -26 },
  { 113, 17, 30, 18, 1, -28 },
  { 177, 24, 27, 28, 2, -27 },
  { 258, 21, 27, 22, 1, -27 },
  { 329, 5, 9, 8, 4, -26 },
  { 335, 12, 32, 11, 1, -26 },
  { 383, 12, 33, 11, -3, -27 },
  { 433, 15, 16, 18, 4, -28 },
  { 463, 16, 18, 19, 2, -22 },
  { 499, 8, 9, 9, -2, -4 },
  { 508, 9, 4, 11, 1, -12 },
  { 513, 5, 5, 9, 0, -5 },
  { 517, 18, 27, 14, -2, -27 },
  { 578, 17, 27, 18, 1, -27 },
  { 636, 12, 26, 18, 4, -26 },
  { 675, 19, 27, 18, -1, -27 },
  { 740, 18, 27, 18, 0, -27 },
  { 801, 18, 26, 18, 0, -26 },
  { 860, 17, 26, 18, 1, -26 },
  { 916, 17, 27, 18, 2, -27 },
  { 974, 18, 26, 18, 2, -26 },
  { 1033, 17, 27, 18, 1, -27 },
  { 1091, 17, 27, 18, 1, -27 },
  { 1149, 8, 20, 9, 0, -20 },
  { 1169, 11, 25, 9, -2, -20 },
  { 1204, 16, 18, 19, 2, -22 },
  { 1240, 16, 10, 19, 2, -18 },
  { 1260, 16, 18, 19, 2, -22 },
  { 1296, 14, 27, 14, 2, -27 },
  { 1344, 25, 29, 28, 2, -26 },
  { 1435, 19, 26, 19, -2, -26 },
  { 1497, 19, 26, 20, 1, -26 },
  { 1559, 19, 27, 19, 2, -27 },
  { 1624, 20, 26, 22, 1, -26 },
  { 1689, 18, 26, 17, 1, -26 },
  { 1748, 18, 26, 16, 1, -26 },
  { 1807, 21, 27, 23, 2, -27 },
  { 1878, 22, 26, 23, 1, -26 },
  { 1950, 15, 26, 12, -1, -26 },
  { 1999, 16, 33, 10, -6, -26 },
  { 2065, 22, 26, 19, 1, -26 },
  { 2137, 13, 26, 16, 1, -26 },
  { 2180, 28, 26, 29, 1, -26 },
  { 2271, 24, 26, 24, 1, -26 },
  { 2349, 21, 27, 24, 2, -27 },
  { 2420, 19, 26, 19, 1, -26 },
  { 2482, 21, 33, 24, 2, -27 },
  { 2569, 18, 26, 20, 1, -26 },
  { 2628, 18, 27, 17, 0, -27 },
  { 2689, 17, 26, 17, 3, -26 },
  { 2745, 21, 26, 23, 2, -26 },
  { 2814, 19, 26, 19, 3, -26 },
  { 2876, 29, 26, 29, 4, -26 },
  { 2971, 23, 26, 18, -2, -26 },
  { 3046, 18, 26, 17, 3, -26 },
  { 3105, 20, 26, 17, -1, -26 },
  { 3170, 15, 32, 11, -1, -26 },
  { 3230, 7, 27, 14, 4, -27 },
  { 3254, 15, 32, 11, -3, -26 },
  { 3314, 17, 17, 19, 1, -27 },
  { 3351, 14, 3, 14, -3, 3 },
  { 3357, 7, 6, 10, 5, -28 },
  { 3363, 18, 20, 19, 1, -20 },
  { 3408, 17, 28, 20, 1, -28 },
  { 3468, 15, 20, 15, 1, -20 },
  { 3506, 20, 28, 20, 1, -28 },
  { 3576, 16, 20, 17, 1, -20 },
  { 3616, 20, 37, 11, -4, -28 },
  { 3709, 19, 29, 20, 0, -20 },
  { 3778, 17, 28, 20, 1, -28 },
  { 3838, 9, 28, 9, 1, -28 },
  { 3870, 15, 37, 9, -5, -28 },
  { 3940, 18, 28, 17, 1, -28 },
  { 4003, 9, 28, 9, 1, -28 },
  { 4035, 27, 20, 29, 1, -20 },
  { 4103, 18, 20, 20, 0, -20 },
  { 4148, 17, 20, 19, 1, -20 },
  { 4191, 19, 29, 20, -1, -20 },
  { 4260, 18, 29, 20, 1, -20 },
  { 4326, 14, 20, 13, 1, -20 },
  { 4361, 15, 20, 15, 0, -20 },
  { 4399, 11, 24, 12, 2, -24 },
  { 4432, 17, 20, 20, 2, -20 },
  { 4475, 16, 20, 16, 2, -20 },
  { 4515, 25, 20, 25, 2, -20 },
  { 4578, 20, 20, 17, -2, -20 },
  { 4628, 21, 29, 16, -3, -20 },
  { 4705, 16, 20, 15, -1, -20 },
  { 4745, 15, 32, 13, 0, -26 },
  { 4805, 3, 37, 18, 8, -28 },
  { 4819, 14, 32, 13, -2, -26 },
  { 4875, 16, 6, 19, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC37PT7B_H_
