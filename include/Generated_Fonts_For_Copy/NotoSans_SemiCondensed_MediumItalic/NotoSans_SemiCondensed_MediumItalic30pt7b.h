#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0xF0, 0x70, 0x73, 0xDC,
  0xE7, 0x39, 0x8C, 0xE3, 0x39, 0xCC, 0x70, 0x01, 0x86, 0x00, 0xC7, 0x00,
  0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x38, 0xC4, 0xFF, 0xFC, 0xFF, 0xFE,
  0x06, 0x38, 0x07, 0x18, 0x03, 0x0C, 0x01, 0x8E, 0x01, 0xC6, 0x07, 0xFF,
  0xF3, 0xFF, 0xF0, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x70, 0x0E,
  0x30, 0x06, 0x38, 0x00, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x01, 0xFE, 0x0F,
  0xFC, 0x7E, 0x63, 0x98, 0x0E, 0x60, 0x39, 0x80, 0xF4, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x2F, 0x01, 0x9C, 0x06, 0x70, 0x19, 0xCC,
  0x4E, 0x3F, 0xF8, 0xFF, 0x80, 0x78, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x43, 0xE0, 0x30, 0xFE, 0x0E, 0x39, 0xC3, 0x86, 0x38, 0x61,
  0xC7, 0x1C, 0x38, 0xE3, 0x07, 0x18, 0xC0, 0xC3, 0x38, 0x18, 0xE6, 0x7B,
  0x19, 0x9F, 0xF7, 0x77, 0x37, 0xCC, 0xC6, 0x63, 0x38, 0xC0, 0xE6, 0x18,
  0x18, 0xC3, 0x06, 0x18, 0xE1, 0xC7, 0x1C, 0x30, 0xE3, 0x0C, 0x0C, 0xE3,
  0x81, 0xF8, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x0E,
  0x38, 0x0E, 0x18, 0x0C, 0x38, 0x0C, 0x38, 0x0E, 0x70, 0x0E, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x87, 0x3B, 0x87, 0x71, 0xC7, 0xE1, 0xEE, 0xE0,
  0xFC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0xF8, 0xF3, 0xFC, 0xFF, 0xDC, 0x3F,
  0x1E, 0x77, 0x76, 0x6E, 0xC0, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x00,
  0x03, 0x80, 0x30, 0x03, 0x04, 0x70, 0xF6, 0x0F, 0xFF, 0x0F, 0xF0, 0xF3,
  0x3B, 0x07, 0xB8, 0x73, 0x82, 0x1C, 0x01, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0xE3, 0x9C,
  0x71, 0x8E, 0x30, 0xFF, 0xFC, 0x77, 0xF7, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0xFF, 0x87, 0x8E, 0x1C, 0x38, 0xF0, 0x73, 0x81, 0xCE, 0x07,
  0x70, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8F, 0x1E, 0x1E, 0xF0, 0x7F, 0x80, 0xFC,
  0x00, 0x07, 0x8F, 0x8F, 0xCF, 0xEF, 0x76, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0x70, 0xE0, 0x81, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0x60, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF2, 0x01, 0xC7, 0x9F, 0x8F, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x37,
  0x00, 0xEE, 0x03, 0x9C, 0x0E, 0x38, 0x18, 0x60, 0x71, 0xC1, 0xC3, 0x87,
  0x07, 0x0C, 0x0E, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x63, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x79, 0x01, 0xE3, 0xCF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x07,
  0xF0, 0x7F, 0xC1, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0xC1, 0xDF, 0x87, 0xFF, 0x1E, 0x1C, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xB8,
  0x1C, 0xE0, 0x73, 0x81, 0xC7, 0x0F, 0x1E, 0x78, 0x3F, 0xC0, 0x7E, 0x00,
  0x7F, 0xFD, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0x70, 0x71,
  0xC1, 0xC7, 0x0E, 0x1E, 0x78, 0x3F, 0xC0, 0x7C, 0x07, 0xF0, 0x3D, 0xE1,
  0xC3, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x78,
  0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x38, 0x73, 0x83,
  0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0x7B, 0xF3,
  0xFB, 0x8F, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x71, 0x1F,
  0x0F, 0xF0, 0x7F, 0x00, 0x1E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x0E, 0x3C, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x0F, 0x0F, 0xF1, 0xFF, 0x30, 0xF0,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x78, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xE0, 0x1C, 0x1C, 0x00, 0x61,
  0xC0, 0x03, 0x8C, 0x0E, 0x0C, 0xE1, 0xFC, 0x66, 0x1C, 0xE3, 0x71, 0xC7,
  0x1B, 0x1C, 0x30, 0xD8, 0xC1, 0x87, 0xC6, 0x1C, 0x7E, 0x30, 0xE3, 0xF3,
  0x86, 0x1B, 0x9C, 0x71, 0xDC, 0x77, 0xDC, 0xE3, 0xE7, 0xC3, 0x0E, 0x18,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x20, 0x0F, 0xDF, 0x00, 0x3F,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x8E, 0x03, 0x8E,
  0x07, 0x0E, 0x07, 0x0E, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1C, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x0F, 0xF8,
  0x1F, 0xF8, 0x38, 0x78, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x0E, 0x38, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xC3, 0xC7, 0x83, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x1E, 0x70, 0x39, 0xC0, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xF8, 0xF8, 0x21, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xE7, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0E, 0x3E, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0E,
  0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x03,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x7E, 0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xF0, 0x1C, 0xF0, 0x38, 0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0E, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78,
  0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x00,
  0x0F, 0xF0, 0x7E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x7F,
  0x07, 0xF0, 0x3E, 0x00, 0x0E, 0x07, 0x87, 0x07, 0x83, 0x87, 0x83, 0x87,
  0x81, 0xC7, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x3B, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xB8, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07,
  0x80, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3B, 0x87, 0xE0, 0x7E,
  0x0D, 0xC1, 0xDC, 0x39, 0x83, 0xB8, 0x73, 0x0E, 0x70, 0xE6, 0x1C, 0xE1,
  0xCC, 0x73, 0x87, 0x18, 0xE7, 0x0E, 0x33, 0x8E, 0x1C, 0x77, 0x1C, 0x38,
  0xFC, 0x70, 0x61, 0xF8, 0xE1, 0xC3, 0xE1, 0xC3, 0x87, 0x83, 0x87, 0x0F,
  0x07, 0x0E, 0x1C, 0x1C, 0x00, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x07,
  0x0F, 0xC0, 0xE1, 0xF8, 0x1C, 0x3F, 0x03, 0x87, 0x70, 0x61, 0xCE, 0x1C,
  0x39, 0xC3, 0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x73, 0x87, 0x0E, 0x70,
  0xE0, 0xEE, 0x1C, 0x1D, 0xC3, 0x83, 0xB8, 0x70, 0x3E, 0x1C, 0x07, 0xC3,
  0x80, 0xF8, 0x70, 0x0F, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xFE, 0x03,
  0xFF, 0x83, 0xE1, 0xE1, 0xC0, 0x71, 0xE0, 0x39, 0xE0, 0x1E, 0xE0, 0x0F,
  0x70, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0E, 0x3C, 0x0F, 0x0F,
  0xBF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x38, 0xF0,
  0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x38, 0x1C, 0x70,
  0x78, 0xFF, 0xE1, 0xFF, 0x87, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFE, 0x03, 0xFF, 0x83, 0xE1, 0xE1, 0xC0, 0x71, 0xE0, 0x39, 0xE0,
  0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0E,
  0x3C, 0x0F, 0x0F, 0xBF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x38, 0xF0, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x38,
  0x3C, 0x71, 0xF0, 0xFF, 0xC1, 0xFE, 0x07, 0x9C, 0x0E, 0x3C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xE1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x80,
  0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x78, 0x61, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE2, 0x03, 0xC7,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x8E, 0x03, 0x8F, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x38, 0x3F, 0x7C, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x07, 0x9C,
  0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x03, 0x1C,
  0x06, 0x38, 0x0C, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x3F,
  0x81, 0xE0, 0x77, 0x07, 0xC0, 0xEE, 0x0F, 0x83, 0x9C, 0x1B, 0x07, 0x38,
  0x76, 0x1C, 0x70, 0xCC, 0x38, 0xE3, 0x98, 0x71, 0xC7, 0x31, 0xC3, 0x9C,
  0x63, 0x87, 0x38, 0xCE, 0x0E, 0x61, 0x9C, 0x1D, 0xC3, 0x70, 0x3B, 0x06,
  0xE0, 0x7E, 0x0D, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x78,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x77, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x1C, 0x03,
  0x83, 0x80, 0xE0, 0x70, 0x3C, 0x0F, 0x0F, 0x00, 0xE0, 0xE0, 0x3F, 0x81,
  0xEE, 0x07, 0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x37,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0x82, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xE3, 0x8E,
  0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0x61,
  0x87, 0x1C, 0x70, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xF0, 0x06, 0xC0, 0x3B, 0x00, 0xCE, 0x07, 0x18, 0x38, 0x70, 0xC1, 0xC7,
  0x03, 0x18, 0x0E, 0xE0, 0x1B, 0x00, 0x70, 0xFF, 0xFF, 0xFE, 0xF3, 0x8E,
  0x71, 0x80, 0x0F, 0xCC, 0x7F, 0xF1, 0xE7, 0xCF, 0x0F, 0x78, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0,
  0xF3, 0xCF, 0xC7, 0xF6, 0x0F, 0x98, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x7C, 0x0D, 0xFC, 0x3E,
  0x38, 0x78, 0x78, 0xE0, 0x71, 0xC0, 0xE7, 0x83, 0xCE, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0xCF, 0x0D, 0xFC, 0x39,
  0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x1E, 0x23, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x98, 0x7F,
  0x83, 0xF8, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x0F, 0xDC, 0x1F, 0xFC, 0x1E, 0x7C, 0x38, 0x3C,
  0x78, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x78, 0xE0, 0x70,
  0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xF0, 0xF3, 0xE0, 0x7F, 0x60, 0x3E, 0x60,
  0x07, 0xE1, 0xFF, 0x1C, 0x73, 0x83, 0x78, 0x77, 0x07, 0x73, 0xEF, 0xFC,
  0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x8C, 0x7F, 0xC3, 0xFC,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x09, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xBC, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x07, 0xE6, 0x1F, 0xFC, 0x3C, 0xF8, 0xE0, 0xF3, 0xC1, 0xC7, 0x03, 0x8E,
  0x07, 0x3C, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x8F,
  0x8F, 0x3F, 0x0F, 0xFC, 0x0F, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x84,
  0x07, 0x0E, 0x3C, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xBE, 0x0D, 0xFC,
  0x7C, 0x71, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xCF, 0x07,
  0x00, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0xBC, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0x0E, 0x3C,
  0x38, 0xF0, 0x73, 0xC0, 0xE7, 0x01, 0xDC, 0x07, 0x70, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3D, 0xC0, 0x73, 0x81, 0xC7, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1E,
  0x3C, 0x1C, 0x00, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0x0C, 0xF8, 0xF8, 0x37, 0xF7, 0xF1, 0xF1, 0xF1, 0xC7, 0x87,
  0x87, 0x1C, 0x1E, 0x1C, 0x70, 0x70, 0x73, 0xC1, 0xC1, 0xCE, 0x07, 0x07,
  0x38, 0x38, 0x1C, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x9C, 0x0E, 0x0E, 0x70,
  0x70, 0x39, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x3C, 0x1C, 0x1C, 0x00, 0x20,
  0x19, 0xF8, 0x77, 0xF0, 0xF8, 0xE1, 0xE1, 0xE3, 0xC3, 0x87, 0x07, 0x1E,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x70, 0x07, 0xE0, 0xFF, 0x87, 0x1E, 0x70,
  0x77, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D,
  0xC0, 0xEF, 0x0F, 0x3D, 0xF1, 0xFF, 0x03, 0xF0, 0x06, 0x7C, 0x06, 0xFE,
  0x0F, 0x8E, 0x0F, 0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x0E,
  0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3E, 0x78,
  0x3F, 0xF0, 0x3B, 0xE0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xCC, 0x7F, 0xF1, 0xC7, 0xCE,
  0x0F, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x81, 0xCE,
  0x07, 0x38, 0x3C, 0xE0, 0xF3, 0xCF, 0x87, 0xFE, 0x0F, 0xB8, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x0C,
  0xF0, 0xDF, 0x1F, 0xE1, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x0F,
  0xF1, 0xFE, 0x3C, 0x23, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xCC, 0x3C, 0xFF, 0x8F, 0xF0, 0x06,
  0x06, 0x03, 0x03, 0x87, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x79, 0x1F, 0x8F, 0xC0, 0x1C, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x3C, 0xF1, 0xF3, 0xCF, 0x87, 0xF6,
  0x1F, 0x98, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3,
  0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x3B, 0x80, 0xDC, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xE0, 0xE0, 0xFE, 0x1E, 0x0E, 0xE1, 0xE1, 0xCE,
  0x3E, 0x1C, 0xE3, 0x61, 0xCE, 0x36, 0x38, 0xE7, 0x63, 0x8E, 0x66, 0x70,
  0xEE, 0x67, 0x0E, 0xC6, 0x60, 0xFC, 0x6E, 0x0F, 0x86, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x0E, 0x1C,
  0x0E, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0,
  0x70, 0x70, 0xE0, 0x70, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x1C,
  0x1C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x03, 0x38,
  0x00, 0xCE, 0x00, 0x37, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x9E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x11, 0xFF, 0x1F, 0xF8, 0x00, 0xF0,
  0x1F, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x01, 0xF0, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x0C, 0x01, 0xE0, 0x1E, 0x07, 0xC1, 0xC0, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x07, 0xC0, 0xF0, 0x18,
  0x00, 0x38, 0x0F, 0xF0, 0xFF, 0xFF, 0x07, 0xE8, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 8, 0, -21 },
  { 22, 10, 7, 12, 3, -21 },
  { 31, 17, 21, 17, 1, -21 },
  { 76, 14, 25, 15, 1, -23 },
  { 120, 19, 22, 23, 2, -22 },
  { 173, 16, 22, 18, 1, -22 },
  { 217, 4, 7, 7, 3, -21 },
  { 221, 10, 26, 9, 1, -21 },
  { 254, 10, 27, 9, -2, -22 },
  { 288, 12, 13, 15, 3, -23 },
  { 308, 13, 15, 16, 2, -18 },
  { 333, 6, 8, 7, -1, -4 },
  { 339, 7, 2, 9, 1, -9 },
  { 341, 4, 4, 7, 0, -4 },
  { 343, 14, 22, 11, -1, -22 },
  { 382, 14, 22, 15, 1, -22 },
  { 421, 9, 21, 15, 4, -21 },
  { 445, 15, 22, 15, 0, -22 },
  { 487, 15, 22, 15, 0, -22 },
  { 529, 15, 21, 15, 0, -21 },
  { 569, 15, 21, 15, 0, -21 },
  { 609, 14, 22, 15, 1, -22 },
  { 648, 14, 21, 15, 2, -21 },
  { 685, 14, 22, 15, 1, -22 },
  { 724, 13, 22, 15, 1, -22 },
  { 760, 7, 16, 7, 0, -16 },
  { 774, 9, 20, 7, -2, -16 },
  { 797, 13, 14, 16, 2, -18 },
  { 820, 13, 9, 16, 2, -15 },
  { 835, 13, 14, 16, 2, -18 },
  { 858, 11, 22, 12, 2, -22 },
  { 889, 21, 24, 23, 1, -21 },
  { 952, 16, 21, 16, -2, -21 },
  { 994, 15, 21, 16, 1, -21 },
  { 1034, 15, 22, 16, 2, -22 },
  { 1076, 16, 21, 18, 1, -21 },
  { 1118, 14, 21, 14, 1, -21 },
  { 1155, 14, 21, 13, 1, -21 },
  { 1192, 16, 22, 18, 2, -22 },
  { 1236, 18, 21, 19, 1, -21 },
  { 1284, 12, 21, 10, -1, -21 },
  { 1316, 13, 27, 8, -5, -21 },
  { 1360, 17, 21, 16, 1, -21 },
  { 1405, 10, 21, 13, 1, -21 },
  { 1432, 23, 21, 23, 1, -21 },
  { 1493, 19, 21, 20, 1, -21 },
  { 1543, 17, 22, 19, 2, -22 },
  { 1590, 15, 21, 16, 1, -21 },
  { 1630, 17, 27, 19, 2, -22 },
  { 1688, 15, 21, 16, 1, -21 },
  { 1728, 15, 22, 14, 0, -22 },
  { 1770, 13, 21, 14, 3, -21 },
  { 1805, 17, 21, 18, 2, -21 },
  { 1850, 15, 21, 15, 3, -21 },
  { 1890, 23, 21, 24, 3, -21 },
  { 1951, 19, 21, 15, -2, -21 },
  { 2001, 14, 21, 14, 3, -21 },
  { 2038, 17, 21, 14, -1, -21 },
  { 2083, 12, 26, 9, -1, -21 },
  { 2122, 6, 22, 11, 3, -22 },
  { 2139, 12, 26, 9, -2, -21 },
  { 2178, 14, 14, 15, 1, -22 },
  { 2203, 12, 2, 11, -3, 3 },
  { 2206, 5, 5, 8, 4, -23 },
  { 2210, 14, 16, 16, 1, -16 },
  { 2238, 15, 23, 16, 0, -23 },
  { 2282, 12, 16, 12, 1, -16 },
  { 2306, 16, 23, 16, 1, -23 },
  { 2352, 12, 16, 14, 1, -16 },
  { 2376, 16, 30, 9, -3, -23 },
  { 2436, 15, 23, 16, 0, -16 },
  { 2480, 14, 23, 16, 0, -23 },
  { 2521, 8, 22, 7, 0, -22 },
  { 2543, 12, 29, 7, -4, -22 },
  { 2587, 15, 23, 14, 0, -23 },
  { 2631, 8, 23, 7, 0, -23 },
  { 2654, 22, 16, 24, 0, -16 },
  { 2698, 15, 17, 16, 0, -17 },
  { 2730, 13, 16, 15, 1, -16 },
  { 2756, 16, 23, 16, -1, -16 },
  { 2802, 14, 23, 16, 1, -16 },
  { 2843, 12, 16, 11, 0, -16 },
  { 2867, 12, 16, 12, 0, -16 },
  { 2891, 9, 20, 10, 1, -20 },
  { 2914, 14, 16, 16, 1, -16 },
  { 2942, 13, 16, 13, 2, -16 },
  { 2968, 20, 16, 20, 2, -16 },
  { 3008, 16, 16, 13, -1, -16 },
  { 3040, 18, 23, 13, -3, -16 },
  { 3092, 13, 16, 12, -1, -16 },
  { 3118, 12, 26, 10, 0, -21 },
  { 3157, 3, 30, 15, 6, -23 },
  { 3169, 11, 26, 10, -1, -21 },
  { 3205, 13, 5, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC30PT7B_H_
