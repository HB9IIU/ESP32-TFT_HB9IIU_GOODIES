#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x00, 0x01, 0x8E,
  0x38, 0x77, 0x66, 0x66, 0x64, 0x4C, 0xCC, 0x03, 0x30, 0x11, 0x81, 0x8C,
  0x0C, 0xC3, 0xFF, 0x9F, 0xFC, 0x31, 0x01, 0x98, 0x08, 0xC3, 0xFF, 0xBF,
  0xFC, 0x23, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x01, 0x80, 0x70,
  0x3F, 0x8E, 0xB1, 0xB0, 0x74, 0x0E, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x17,
  0x02, 0x60, 0x4C, 0x9B, 0x3F, 0xE3, 0xF0, 0x08, 0x03, 0x00, 0x0C, 0x00,
  0x7C, 0x18, 0xD8, 0x63, 0x31, 0x86, 0x63, 0x0C, 0xCC, 0x11, 0xB0, 0x63,
  0x6F, 0x4D, 0xBE, 0xF6, 0xCC, 0xCD, 0x98, 0x33, 0x30, 0xC6, 0x61, 0x88,
  0xC6, 0x11, 0x18, 0x36, 0x70, 0x78, 0x03, 0x80, 0x3E, 0x03, 0xB8, 0x18,
  0xC0, 0xC6, 0x06, 0x60, 0x37, 0x01, 0xE0, 0x1E, 0x01, 0xF8, 0xDC, 0xCE,
  0xC7, 0x66, 0x1F, 0x70, 0x71, 0x87, 0x8F, 0xFC, 0x3E, 0x70, 0x76, 0x66,
  0x4C, 0x0E, 0x18, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x00, 0x04, 0x06, 0x06, 0x07, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0xC0, 0x08, 0x01, 0x80, 0x41, 0xB0, 0xFF, 0xC3, 0xF1,
  0xC0, 0xD8, 0x66, 0x08, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39, 0x9C, 0xC6, 0x60, 0x7F,
  0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06,
  0x00, 0x07, 0x03, 0xE1, 0xDC, 0xE3, 0x70, 0xDC, 0x36, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x06, 0xC3, 0xB0, 0xCE, 0x71, 0xF8, 0x7C, 0x00, 0x1E,
  0x79, 0xF7, 0x69, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C,
  0x30, 0x03, 0x81, 0xF8, 0x73, 0x88, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0x83, 0xF8, 0x73, 0x88, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x1C,
  0x0E, 0x03, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xA0, 0xE7, 0xFC, 0xFE,
  0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x6C, 0x19, 0x86, 0x70, 0xCC,
  0x31, 0x8C, 0x33, 0xFF, 0xFF, 0xF0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x0F,
  0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0xE1, 0xFC, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1D, 0x07, 0x3F, 0xE7, 0xF0, 0x01, 0xE0, 0xF8,
  0x38, 0x8C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x7C, 0x7B, 0x9C, 0x33, 0x86,
  0x60, 0xCC, 0x19, 0x83, 0x38, 0xC3, 0xF8, 0x3E, 0x00, 0x3F, 0xEF, 0xFC,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0x07, 0x07, 0xF3, 0x9C, 0xC3,
  0x30, 0xCC, 0x33, 0x9C, 0x7C, 0x1E, 0x1F, 0xCE, 0x3B, 0x06, 0xC1, 0xB0,
  0x6C, 0x3B, 0xFC, 0x7E, 0x00, 0x06, 0x07, 0xE3, 0x9D, 0xC3, 0x60, 0xD8,
  0x36, 0x0D, 0x87, 0x63, 0xDF, 0xE3, 0xD8, 0x06, 0x03, 0x00, 0xC0, 0x63,
  0xF0, 0xF8, 0x00, 0x19, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x00,
  0x0C, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x71, 0x8E, 0x30,
  0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x3C, 0x3C, 0x3C, 0x3C, 0x0C, 0x00,
  0x0C, 0x3F, 0x9C, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0C, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x03, 0xFC, 0x0E, 0x0E,
  0x1C, 0x06, 0x30, 0x03, 0x31, 0xF3, 0x63, 0xF3, 0x66, 0x33, 0xC4, 0x23,
  0xCC, 0x63, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0xE6, 0xCF, 0xFC, 0xC2, 0x10,
  0x60, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xE0, 0x1E, 0x03,
  0x60, 0x36, 0x06, 0x60, 0x66, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0xFE, 0x3F,
  0xE3, 0x06, 0x70, 0x66, 0x07, 0xE0, 0x7C, 0x07, 0x1F, 0xC3, 0xFC, 0xE1,
  0x9C, 0x33, 0x06, 0x61, 0xCF, 0xF3, 0xF8, 0x63, 0xCC, 0x19, 0x83, 0x70,
  0x6E, 0x1D, 0x87, 0xBF, 0xE7, 0xF0, 0x01, 0xC0, 0x7F, 0x0F, 0x71, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x47, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFE, 0x38,
  0x73, 0x87, 0x30, 0x33, 0x03, 0x30, 0x37, 0x03, 0x60, 0x76, 0x07, 0x60,
  0x6E, 0x0E, 0xE1, 0xCC, 0x38, 0xFF, 0x0F, 0xC0, 0x1F, 0xE3, 0xF8, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0xFC, 0x7F, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x01, 0xE0, 0x3F, 0xC3, 0xCE, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x61, 0xF7, 0x0F, 0xB8, 0x1D, 0xC0, 0xCE,
  0x06, 0x30, 0x31, 0xC3, 0x87, 0xFC, 0x1F, 0xC0, 0x18, 0x18, 0xC0, 0xCE,
  0x0E, 0x70, 0x73, 0x03, 0x18, 0x18, 0xFF, 0xCF, 0xFE, 0x60, 0x73, 0x03,
  0x18, 0x19, 0xC0, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x18, 0x1F, 0xC1,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x07, 0xE3, 0xF0, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x87, 0xC1, 0xE0, 0xA0, 0x00, 0x18, 0x78, 0xC3,
  0x0E, 0x38, 0x73, 0x83, 0x38, 0x1B, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xB0, 0x19, 0xC1, 0xC6, 0x0E, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x38, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0,
  0xC0, 0xFF, 0xFE, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x03, 0xE6, 0xC1, 0xE3,
  0x61, 0xB1, 0xB0, 0xD8, 0xD8, 0xCC, 0xEC, 0x6E, 0x66, 0x66, 0x33, 0x33,
  0x19, 0xB1, 0x9C, 0xD9, 0xCC, 0x78, 0xE6, 0x3C, 0x63, 0x1C, 0x31, 0x8E,
  0x18, 0x0E, 0x06, 0x1C, 0x0C, 0x78, 0x38, 0xD8, 0x61, 0xB0, 0xC3, 0x61,
  0x86, 0xE3, 0x1C, 0xCE, 0x31, 0x98, 0x63, 0xB0, 0xC3, 0x63, 0x86, 0xC6,
  0x0F, 0x8C, 0x1E, 0x18, 0x1C, 0x70, 0x38, 0x01, 0xC0, 0x7F, 0x87, 0x9C,
  0x30, 0x73, 0x81, 0xB8, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x6E, 0x07, 0x30, 0x31, 0xC3, 0x8F, 0xF8, 0x1F, 0x80, 0x1F,
  0xC3, 0xFC, 0xE3, 0x9C, 0x33, 0x06, 0x60, 0xCC, 0x3B, 0x9E, 0x7F, 0x8F,
  0xC1, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x7F,
  0x87, 0x9C, 0x30, 0x73, 0x81, 0xB8, 0x0D, 0xC0, 0x6C, 0x03, 0x60, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0x30, 0x31, 0xC3, 0x8F, 0xF8, 0x1F,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0xC3, 0xFC, 0xE3,
  0x9C, 0x33, 0x06, 0x61, 0xCC, 0x33, 0xFE, 0x7F, 0x0C, 0xE1, 0x8C, 0x71,
  0x8E, 0x39, 0x87, 0x30, 0x66, 0x0E, 0x03, 0x81, 0xFC, 0x7B, 0x9C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x20, 0xE7, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x18, 0x19, 0xC0, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x19,
  0xC0, 0xCE, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x19, 0xC1, 0xCE, 0x0C, 0x30,
  0xE1, 0xFE, 0x07, 0xE0, 0xC0, 0x7C, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0x8E,
  0x38, 0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0xC1, 0xF8, 0x70, 0x6E, 0x1C, 0x1B, 0x8F,
  0x0E, 0xE3, 0xC3, 0x38, 0xF1, 0xCE, 0x6C, 0x63, 0x9B, 0x18, 0xEC, 0x4C,
  0x3B, 0x13, 0x0F, 0x85, 0xC3, 0x61, 0x60, 0xD8, 0x58, 0x3C, 0x1C, 0x0F,
  0x07, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x30, 0xE0, 0xE3, 0x01, 0x98, 0x06,
  0xE0, 0x1B, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x06,
  0x70, 0x38, 0xC1, 0xC3, 0x06, 0x0E, 0x38, 0x38, 0xE0, 0xFC, 0x39, 0x86,
  0x31, 0x86, 0x70, 0xEC, 0x1F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0,
  0xC0, 0xC0, 0xF8, 0xF0, 0xE3, 0x18, 0xC6, 0x31, 0x86, 0x31, 0x8C, 0x63,
  0x18, 0x63, 0x0F, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x1E, 0x1F,
  0x00, 0x07, 0x00, 0xE0, 0x34, 0x06, 0xC1, 0x98, 0x31, 0x8C, 0x31, 0x86,
  0xE0, 0x60, 0xFF, 0xFF, 0x80, 0xE6, 0x73, 0x0C, 0x03, 0xEC, 0xE7, 0x38,
  0xE6, 0x0D, 0xC3, 0xB8, 0x76, 0x0C, 0xC1, 0x98, 0x73, 0x9E, 0x7F, 0x87,
  0xB0, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x98, 0x37, 0xC7, 0xB9, 0xC3,
  0x38, 0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0xFC, 0xCF,
  0x00, 0x06, 0x0F, 0xCE, 0x4E, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x0F, 0xC7, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x61,
  0xFE, 0x39, 0xC7, 0x1C, 0x60, 0xCE, 0x1C, 0xE1, 0xCC, 0x18, 0xC1, 0x8C,
  0x38, 0xC7, 0x8F, 0xF0, 0x7B, 0x00, 0x06, 0x0F, 0xCE, 0x6E, 0x36, 0x1F,
  0x3F, 0xFD, 0xF0, 0xC0, 0x60, 0x38, 0x4F, 0xE7, 0xE0, 0x00, 0x20, 0x07,
  0xC0, 0x74, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x3F, 0x80, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x5C, 0x03, 0xC0, 0x08, 0x00,
  0x06, 0x00, 0xFB, 0x1C, 0xE3, 0x8E, 0x30, 0x67, 0x0E, 0x70, 0xE6, 0x0C,
  0x60, 0xC6, 0x1C, 0x73, 0xC7, 0xF8, 0x3D, 0x80, 0x18, 0x01, 0x80, 0x30,
  0xCF, 0x0F, 0xE0, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x98,
  0x37, 0xC7, 0xB9, 0xC3, 0x38, 0x66, 0x0C, 0xC3, 0x98, 0x67, 0x0C, 0xC1,
  0x98, 0x73, 0x0E, 0xE1, 0x80, 0x0C, 0x70, 0x80, 0x00, 0x61, 0x8E, 0x30,
  0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE0, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x0B, 0x87, 0x81, 0x00, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x11, 0x8E, 0x19, 0xC3, 0xB8, 0x33, 0x03, 0x60, 0x3E,
  0x03, 0xE0, 0x77, 0x06, 0x30, 0x63, 0x06, 0x38, 0xE1, 0x80, 0x0C, 0x31,
  0xC7, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0xE0, 0x01,
  0x82, 0x0D, 0xE7, 0xC7, 0xBE, 0xE7, 0x0E, 0x33, 0x8E, 0x19, 0x87, 0x0C,
  0xC3, 0x0E, 0x61, 0x86, 0x70, 0xC3, 0x30, 0xE1, 0x98, 0x70, 0xCC, 0x30,
  0xEE, 0x18, 0x60, 0x01, 0x83, 0x7C, 0x7B, 0x9C, 0x33, 0x86, 0x61, 0xCC,
  0x3B, 0x86, 0x70, 0xCC, 0x19, 0x87, 0x30, 0xEE, 0x18, 0x06, 0x07, 0xE3,
  0x99, 0xC7, 0x60, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xB0, 0x6E, 0x31, 0xFC,
  0x3E, 0x00, 0x00, 0xC0, 0xDF, 0x0F, 0x71, 0xC3, 0x1C, 0x31, 0x83, 0x18,
  0x31, 0x87, 0x38, 0x73, 0x86, 0x38, 0xE3, 0xFC, 0x77, 0x87, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x04, 0x03, 0xEC, 0xE7, 0x38, 0xE6, 0x0D,
  0xC3, 0xB8, 0x76, 0x0C, 0xC1, 0x98, 0x73, 0x1E, 0x7F, 0x87, 0xB0, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x8D, 0xC7, 0xE7,
  0x83, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x0E,
  0x1F, 0xCE, 0x4E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xA1, 0xDF,
  0xCF, 0xC0, 0x18, 0x30, 0xC7, 0xF3, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86,
  0x0C, 0x1F, 0x1E, 0x00, 0x30, 0xEE, 0x19, 0xC3, 0x30, 0x66, 0x1C, 0xC3,
  0x38, 0x67, 0x0C, 0xC3, 0x98, 0xF3, 0xFC, 0x3D, 0x80, 0xE1, 0xF8, 0x6E,
  0x39, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x7C, 0x1E, 0x07, 0x81, 0xC0,
  0xE3, 0x87, 0xE3, 0x8E, 0xE7, 0x8C, 0xE7, 0x8C, 0xE5, 0x98, 0x6D, 0x98,
  0x6D, 0xB8, 0x79, 0xB0, 0x79, 0xB0, 0x71, 0xE0, 0x71, 0xE0, 0x61, 0xC0,
  0x18, 0x71, 0xCE, 0x0D, 0xC0, 0xD8, 0x0F, 0x00, 0x70, 0x0F, 0x01, 0xF0,
  0x1B, 0x03, 0x38, 0x71, 0x8E, 0x1C, 0x1C, 0x38, 0xE1, 0x83, 0x1C, 0x18,
  0xC0, 0xCE, 0x06, 0x60, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x17, 0x00, 0xF0, 0x02, 0x00, 0x00,
  0x1F, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x07, 0xF3, 0xFC, 0x03, 0x83, 0x83, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x78, 0x70, 0x1C, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x0F, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x06, 0x01, 0xC3, 0xC1, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x38, 0x3C, 0x18, 0x00, 0x30, 0x7F, 0x9C, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 8, 6, 9, 2, -16 },
  { 19, 13, 16, 13, 0, -16 },
  { 45, 11, 18, 11, 0, -17 },
  { 70, 15, 17, 17, 1, -17 },
  { 102, 13, 17, 14, 0, -17 },
  { 130, 4, 6, 5, 2, -16 },
  { 133, 7, 20, 7, 1, -16 },
  { 151, 8, 21, 7, -2, -17 },
  { 172, 10, 10, 11, 2, -18 },
  { 185, 10, 11, 12, 1, -14 },
  { 199, 5, 6, 6, -1, -3 },
  { 203, 6, 2, 7, 0, -7 },
  { 205, 3, 3, 6, 0, -3 },
  { 207, 11, 16, 8, -1, -16 },
  { 229, 10, 17, 11, 1, -17 },
  { 251, 7, 16, 11, 3, -16 },
  { 265, 11, 17, 11, 0, -17 },
  { 289, 11, 17, 11, 0, -17 },
  { 313, 11, 16, 11, 0, -16 },
  { 335, 11, 16, 11, 0, -16 },
  { 357, 11, 17, 11, 1, -17 },
  { 381, 11, 16, 11, 1, -16 },
  { 403, 10, 17, 11, 1, -17 },
  { 425, 10, 17, 11, 1, -17 },
  { 447, 5, 13, 6, 0, -13 },
  { 456, 6, 16, 6, -1, -13 },
  { 468, 10, 11, 12, 1, -14 },
  { 482, 10, 6, 12, 1, -11 },
  { 490, 10, 11, 12, 1, -14 },
  { 504, 9, 17, 9, 1, -17 },
  { 524, 16, 18, 17, 1, -16 },
  { 560, 12, 16, 12, -1, -16 },
  { 584, 11, 16, 13, 1, -16 },
  { 606, 12, 17, 12, 1, -17 },
  { 632, 12, 16, 14, 1, -16 },
  { 656, 11, 16, 11, 1, -16 },
  { 678, 11, 16, 10, 1, -16 },
  { 700, 13, 17, 14, 1, -17 },
  { 728, 13, 16, 14, 1, -16 },
  { 754, 10, 16, 7, -1, -16 },
  { 774, 10, 21, 6, -4, -16 },
  { 801, 13, 16, 12, 1, -16 },
  { 827, 8, 16, 10, 1, -16 },
  { 843, 17, 16, 18, 1, -16 },
  { 877, 15, 16, 15, 0, -16 },
  { 907, 13, 17, 15, 1, -17 },
  { 935, 11, 16, 12, 1, -16 },
  { 957, 13, 21, 15, 1, -17 },
  { 992, 11, 16, 12, 1, -16 },
  { 1014, 11, 17, 11, 0, -17 },
  { 1038, 10, 16, 10, 2, -16 },
  { 1058, 13, 16, 14, 1, -16 },
  { 1084, 12, 16, 12, 2, -16 },
  { 1108, 18, 16, 18, 2, -16 },
  { 1144, 14, 16, 11, -1, -16 },
  { 1172, 11, 16, 11, 2, -16 },
  { 1194, 13, 16, 11, -1, -16 },
  { 1220, 8, 20, 7, 0, -16 },
  { 1240, 5, 16, 8, 2, -16 },
  { 1250, 9, 20, 7, -2, -16 },
  { 1273, 11, 9, 12, 0, -16 },
  { 1286, 9, 2, 8, -2, 2 },
  { 1289, 4, 4, 6, 3, -18 },
  { 1291, 11, 13, 12, 1, -13 },
  { 1309, 11, 17, 12, 0, -17 },
  { 1333, 9, 13, 10, 1, -13 },
  { 1348, 12, 17, 12, 1, -17 },
  { 1374, 9, 13, 11, 1, -13 },
  { 1389, 13, 24, 7, -3, -18 },
  { 1428, 12, 19, 12, 0, -13 },
  { 1457, 11, 17, 12, 0, -17 },
  { 1481, 6, 17, 6, 0, -17 },
  { 1494, 9, 23, 6, -3, -17 },
  { 1520, 12, 17, 11, 0, -17 },
  { 1546, 6, 17, 6, 0, -17 },
  { 1559, 17, 13, 18, 0, -13 },
  { 1587, 11, 13, 12, 0, -13 },
  { 1605, 10, 13, 12, 1, -13 },
  { 1622, 12, 18, 12, -1, -13 },
  { 1649, 11, 19, 12, 1, -13 },
  { 1676, 9, 13, 8, 0, -13 },
  { 1691, 9, 13, 9, 0, -13 },
  { 1706, 7, 15, 7, 1, -15 },
  { 1720, 11, 12, 12, 1, -12 },
  { 1737, 10, 12, 10, 1, -12 },
  { 1752, 16, 12, 16, 1, -12 },
  { 1776, 12, 12, 10, -1, -12 },
  { 1794, 13, 18, 10, -2, -12 },
  { 1824, 10, 12, 9, -1, -12 },
  { 1839, 9, 20, 8, 0, -16 },
  { 1862, 2, 23, 11, 5, -18 },
  { 1868, 9, 20, 8, -1, -16 },
  { 1891, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC23PT7B_H_
