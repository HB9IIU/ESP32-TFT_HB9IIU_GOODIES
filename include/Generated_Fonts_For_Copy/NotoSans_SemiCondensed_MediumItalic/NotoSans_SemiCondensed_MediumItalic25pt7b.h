#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x00, 0x00, 0x38, 0xF1, 0xC0, 0xE7, 0xCF, 0x3E, 0x6C, 0xD9, 0xA3, 0x00,
  0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x23, 0x07, 0xFF, 0xCF,
  0xFF, 0x03, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x03, 0xFF, 0xCF, 0xFF,
  0x83, 0x10, 0x04, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x66, 0x00, 0x00, 0x80,
  0x08, 0x03, 0xE0, 0xFF, 0x1D, 0x31, 0x90, 0x19, 0x01, 0xB0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x06, 0xE0, 0x6E, 0x04, 0xE6, 0x5C, 0xFF, 0x83,
  0xE0, 0x08, 0x00, 0x80, 0x3C, 0x0E, 0x7E, 0x0C, 0x66, 0x18, 0xC6, 0x30,
  0xC6, 0x30, 0xC6, 0x60, 0xC6, 0xC0, 0xCC, 0xDE, 0xCD, 0xBE, 0xFB, 0x33,
  0x73, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x0C, 0xE6, 0x18, 0xC6, 0x30, 0xC6,
  0x30, 0x7C, 0x60, 0x78, 0x03, 0xE0, 0x0F, 0xE0, 0x39, 0xC0, 0x61, 0x80,
  0xC7, 0x01, 0x8C, 0x03, 0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x1C, 0xEE,
  0x33, 0x8C, 0xE6, 0x1F, 0x9C, 0x1E, 0x38, 0x38, 0x38, 0xF8, 0x7F, 0xB0,
  0x7E, 0x70, 0xFF, 0xED, 0xA0, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30,
  0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x70,
  0xE0, 0x07, 0x00, 0xC1, 0x18, 0x3B, 0x0F, 0xFE, 0x1F, 0xC7, 0x81, 0xD8,
  0x73, 0x04, 0x70, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61,
  0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x39, 0x9C,
  0xC6, 0x60, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x81, 0xF8,
  0x73, 0x9C, 0x73, 0x06, 0xE0, 0xDC, 0x1B, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x6C, 0x1D, 0x83, 0xB8, 0xE7, 0x1C, 0x7F, 0x07, 0xC0, 0x07, 0x0E,
  0x3E, 0x7E, 0xEE, 0x4E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x07, 0xC1, 0xFE, 0x1C, 0x70, 0x87, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xC1, 0xFF, 0x18, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x1C, 0x0F, 0x80, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC8, 0x1C, 0xFF, 0x8F, 0xF0, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0x60, 0x76, 0x0E, 0xE0, 0xCE, 0x18, 0xC3,
  0x8C, 0x71, 0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xCC,
  0x3C, 0xFF, 0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x06, 0xF8, 0x7F, 0xCF, 0x1C, 0xE0, 0xCE, 0x0C, 0xE0, 0xCE,
  0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x3F, 0xF3, 0xFF, 0x40, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0xC3,
  0xFC, 0xE3, 0x9C, 0x33, 0x86, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x07, 0xF1,
  0xCE, 0x70, 0xEC, 0x1D, 0x83, 0xB0, 0x77, 0x0C, 0xFF, 0x8F, 0xE0, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x0E, 0xC1, 0xD8, 0x3B, 0x07, 0x71, 0xEF,
  0xF8, 0xFB, 0x04, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0xFE, 0x1F, 0x00,
  0x08, 0x73, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF3, 0x80, 0x0C,
  0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x0E, 0x18,
  0x70, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x38, 0x1E, 0x1F, 0x0F, 0x83, 0xC0, 0x60, 0x00, 0x1F, 0x1F,
  0xE2, 0x38, 0x07, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0xC0, 0x30, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0xF0, 0x70, 0x70, 0x06, 0x18, 0x01, 0x8C, 0x3E, 0x66, 0x1F,
  0x8D, 0x8C, 0x63, 0x66, 0x18, 0xB1, 0x8C, 0x6C, 0xE3, 0x1B, 0x30, 0xC6,
  0xCC, 0x73, 0x31, 0xBD, 0xCC, 0x79, 0xE3, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x02, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x06, 0xE0, 0x39, 0x80, 0xC6, 0x07, 0x18, 0x18, 0x60,
  0xE1, 0x83, 0xFE, 0x1F, 0xF8, 0x60, 0x63, 0x81, 0x8C, 0x06, 0x70, 0x1F,
  0x80, 0x70, 0x1F, 0xC0, 0xFF, 0x86, 0x1C, 0x30, 0x73, 0x83, 0x9C, 0x18,
  0xE1, 0xC6, 0x3C, 0x3F, 0xC3, 0xFE, 0x1C, 0x38, 0xE0, 0xC6, 0x06, 0x30,
  0x73, 0x83, 0x9C, 0x78, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC3,
  0xC6, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x08, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x06, 0x3C, 0x30, 0x73, 0x83, 0x9C, 0x0C,
  0xE0, 0x66, 0x03, 0x30, 0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0x76, 0x07, 0x30,
  0x3B, 0x83, 0x9C, 0x78, 0xFF, 0x87, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC7, 0xF8, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF1, 0xFE, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x3F,
  0xC7, 0xF8, 0x7F, 0x87, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xF0, 0xC7, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0xF9, 0x83, 0xEE, 0x1F, 0xB8, 0x0E, 0xE0,
  0x31, 0x80, 0xC7, 0x07, 0x1E, 0x1C, 0x3F, 0xF0, 0x7F, 0x80, 0x1C, 0x0E,
  0x38, 0x18, 0x60, 0x30, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18,
  0x0C, 0x3F, 0xF8, 0xFF, 0xF1, 0xC0, 0xE3, 0x81, 0x86, 0x03, 0x0C, 0x0E,
  0x38, 0x1C, 0x70, 0x30, 0xC0, 0x61, 0x81, 0xC0, 0x0F, 0xE1, 0xF8, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x7E, 0x1F, 0xC0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x09, 0xC1, 0xF8, 0x3C, 0x00, 0x1C, 0x1C, 0x70, 0xE1, 0x87, 0x06, 0x38,
  0x38, 0xE0, 0xE7, 0x03, 0xB8, 0x0D, 0xC0, 0x3E, 0x01, 0xFC, 0x07, 0x70,
  0x18, 0xC0, 0x63, 0x81, 0x8E, 0x0E, 0x18, 0x38, 0x70, 0xC1, 0xC3, 0x03,
  0x80, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xFF, 0xFF, 0x1E, 0x01, 0xE3, 0xC0, 0x7C,
  0x78, 0x0F, 0x0F, 0x03, 0xE3, 0xE0, 0x6C, 0x7C, 0x1F, 0x8D, 0x83, 0x71,
  0xB0, 0xEC, 0x36, 0x19, 0x8E, 0xE7, 0x71, 0xDC, 0xCE, 0x31, 0xB9, 0x86,
  0x36, 0x30, 0xC7, 0xC6, 0x38, 0xF1, 0xC6, 0x1E, 0x38, 0xC3, 0x86, 0x18,
  0x70, 0xC0, 0x1C, 0x07, 0x1E, 0x06, 0x1E, 0x06, 0x1E, 0x0E, 0x3E, 0x0E,
  0x3F, 0x0C, 0x33, 0x0C, 0x33, 0x0C, 0x33, 0x9C, 0x73, 0x9C, 0x71, 0x98,
  0x61, 0x98, 0x61, 0xD8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF0, 0xC0, 0x70,
  0xC0, 0x70, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF0, 0xE0, 0xE3, 0x80, 0xC7,
  0x01, 0xDC, 0x03, 0xB8, 0x06, 0x60, 0x0C, 0xC0, 0x3B, 0x80, 0x77, 0x00,
  0xEE, 0x03, 0x8C, 0x07, 0x1C, 0x1C, 0x3C, 0x78, 0x3F, 0xE0, 0x3F, 0x00,
  0x1F, 0x81, 0xFE, 0x18, 0xF1, 0x87, 0x38, 0x33, 0x83, 0x38, 0x73, 0x07,
  0x30, 0xE7, 0xFC, 0x7F, 0x87, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF0, 0xE0, 0xE3, 0x80,
  0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x60, 0x0C, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0xEE, 0x03, 0x8C, 0x07, 0x1C, 0x1C, 0x3C, 0x78, 0x3F, 0xE0, 0x3F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x81, 0xFE,
  0x18, 0xF1, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73, 0x06, 0x33, 0xE7, 0xFC,
  0x7F, 0x06, 0x38, 0x63, 0x86, 0x18, 0xE1, 0x8E, 0x1C, 0xC1, 0xCC, 0x0E,
  0x07, 0xE0, 0xFF, 0x1E, 0x31, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xCC, 0x3C,
  0xFF, 0x8F, 0xE0, 0x7F, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x1C, 0x0E, 0x38, 0x18, 0x60, 0x31, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0,
  0xC3, 0x01, 0x86, 0x07, 0x1C, 0x0E, 0x18, 0x18, 0x38, 0x70, 0x7F, 0xC0,
  0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xC6, 0x0E, 0x30, 0x61,
  0x87, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x19, 0xC0, 0xCC, 0x06, 0xE0, 0x36,
  0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x60, 0x7E, 0x0E,
  0x06, 0xE0, 0xE0, 0xEE, 0x0E, 0x0E, 0xE1, 0xE0, 0xCE, 0x1E, 0x1C, 0x63,
  0x61, 0x86, 0x36, 0x38, 0x67, 0x73, 0x06, 0x67, 0x70, 0x6E, 0x77, 0x06,
  0xC7, 0x60, 0x6C, 0x7E, 0x07, 0x87, 0xC0, 0x78, 0x6C, 0x07, 0x83, 0x80,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x0C, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x31,
  0xC0, 0x67, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1F, 0x00, 0x7E, 0x01, 0xCC, 0x03, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x60,
  0x61, 0xC0, 0xE0, 0xE0, 0x76, 0x0E, 0x60, 0xE6, 0x1C, 0x71, 0x87, 0x38,
  0x37, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x7F, 0xE3,
  0xFF, 0x80, 0x0F, 0x87, 0xC3, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x0F, 0x87, 0xC0, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x66, 0x73, 0x33, 0x33,
  0x07, 0xC1, 0xF0, 0x98, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x7C, 0x3E, 0x00, 0x06, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0x98, 0x33,
  0x0C, 0x63, 0x86, 0x60, 0xDC, 0x1F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xEE,
  0x63, 0x06, 0x01, 0xF7, 0x3D, 0xE3, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE,
  0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xD8, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xCC, 0x1B, 0xE1, 0xFF, 0x1C, 0x73,
  0x83, 0x38, 0x33, 0x03, 0x30, 0x73, 0x07, 0x70, 0x67, 0x0E, 0x71, 0xC7,
  0xFC, 0xEF, 0x80, 0x07, 0x87, 0xF3, 0xD9, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x84, 0x7F, 0x0F, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x38, 0x7D, 0xC7, 0xBC, 0x70, 0xE3,
  0x87, 0x18, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3,
  0x87, 0xFC, 0x1F, 0x60, 0x07, 0x07, 0xF3, 0xDD, 0xC3, 0x70, 0xD8, 0x7F,
  0xFB, 0xF8, 0xE0, 0x30, 0x0E, 0x03, 0x82, 0x7F, 0x0F, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x40, 0xFE, 0x03, 0xF8,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x7F, 0xC7, 0xBC, 0x70,
  0xE3, 0x87, 0x18, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x78,
  0xE3, 0xC7, 0xFC, 0x1E, 0x60, 0x07, 0x00, 0x38, 0x01, 0x86, 0x1C, 0x3F,
  0xC0, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xCC,
  0x1B, 0xF1, 0xFF, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x63, 0x06,
  0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x0C, 0xE0, 0xC0, 0x04, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC3,
  0x80, 0x00, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x04, 0x71, 0xC3, 0x1C, 0x19, 0xC1,
  0xDC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x81, 0xCE, 0x0E, 0x70, 0x61,
  0x83, 0x0E, 0x38, 0x70, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x80, 0x00, 0xC1, 0x83,
  0x7C, 0xF8, 0x7F, 0xFF, 0x8E, 0x3C, 0x73, 0x87, 0x0E, 0x70, 0xE1, 0x8E,
  0x18, 0x31, 0x83, 0x0E, 0x30, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x86, 0x30,
  0x60, 0xC6, 0x0C, 0x39, 0xC3, 0x87, 0x00, 0x18, 0xC1, 0xBF, 0x1F, 0xF1,
  0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE6,
  0x0E, 0x60, 0xCE, 0x1C, 0x07, 0x03, 0xF8, 0xF7, 0x38, 0x77, 0x0E, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xD8, 0x1B, 0x87, 0x71, 0xC7, 0xF0, 0x7C, 0x00,
  0x00, 0x60, 0x6F, 0x83, 0xEE, 0x1C, 0x31, 0xC1, 0x8E, 0x0C, 0x60, 0x63,
  0x07, 0x18, 0x39, 0xC1, 0x8E, 0x1C, 0x71, 0xC3, 0xFE, 0x3B, 0xE1, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xFF,
  0x3D, 0xE3, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE0, 0xCE, 0x1C,
  0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0x98, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x00, 0xC6, 0xF1, 0xFC, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x0F, 0x07, 0xF3,
  0x98, 0xC0, 0x30, 0x0E, 0x03, 0xC0, 0x7C, 0x07, 0x00, 0xC0, 0x32, 0x1C,
  0xFF, 0x3F, 0x80, 0x18, 0x18, 0x39, 0xFE, 0xFE, 0x30, 0x70, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xF8, 0x78, 0x38, 0x73, 0x06, 0x70, 0x67,
  0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0x8F,
  0xD8, 0x79, 0x80, 0xE0, 0xFC, 0x19, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x19,
  0xC3, 0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE1, 0xC3, 0xB1,
  0xE1, 0x98, 0xF1, 0xCC, 0x78, 0xC6, 0x6C, 0xE3, 0x36, 0x61, 0xB3, 0x30,
  0xD9, 0xB8, 0x7C, 0xD8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0E, 0x1E, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x63, 0x83, 0x38, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1F, 0x80, 0xCC, 0x0E, 0x70, 0xE3, 0x8E, 0x0C, 0x00, 0x1C,
  0x1C, 0x30, 0x60, 0xC3, 0x83, 0x0C, 0x0C, 0x70, 0x31, 0x80, 0xCE, 0x03,
  0x30, 0x0D, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0,
  0x3F, 0xCF, 0xF8, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x07, 0x83, 0xC0, 0x38, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x07, 0x81, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xE0, 0xF0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07,
  0x0F, 0x07, 0x00, 0x10, 0x2F, 0xC7, 0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 7, 7, 10, 3, -18 },
  { 24, 15, 18, 14, 0, -18 },
  { 58, 12, 20, 12, 0, -19 },
  { 88, 16, 18, 19, 2, -18 },
  { 124, 15, 18, 15, 0, -18 },
  { 158, 3, 7, 6, 3, -18 },
  { 161, 8, 22, 7, 1, -18 },
  { 183, 8, 22, 7, -2, -18 },
  { 205, 11, 11, 12, 2, -19 },
  { 221, 11, 12, 13, 1, -15 },
  { 238, 5, 6, 6, -1, -3 },
  { 242, 7, 2, 7, 0, -8 },
  { 244, 4, 3, 6, 0, -3 },
  { 246, 12, 18, 9, -1, -18 },
  { 273, 11, 18, 12, 1, -18 },
  { 298, 8, 18, 12, 3, -18 },
  { 316, 12, 18, 12, 0, -18 },
  { 343, 12, 18, 12, 0, -18 },
  { 370, 12, 18, 12, 0, -18 },
  { 397, 12, 18, 12, 0, -18 },
  { 424, 12, 18, 12, 1, -18 },
  { 451, 12, 18, 12, 1, -18 },
  { 478, 11, 18, 12, 1, -18 },
  { 503, 11, 18, 12, 1, -18 },
  { 528, 6, 14, 6, 0, -14 },
  { 539, 7, 17, 6, -1, -14 },
  { 554, 11, 12, 13, 1, -15 },
  { 571, 11, 7, 13, 1, -12 },
  { 581, 11, 12, 13, 1, -15 },
  { 598, 10, 18, 10, 1, -18 },
  { 621, 18, 20, 19, 1, -18 },
  { 666, 14, 18, 13, -2, -18 },
  { 698, 13, 18, 14, 1, -18 },
  { 728, 13, 18, 13, 1, -18 },
  { 758, 13, 18, 15, 1, -18 },
  { 788, 12, 18, 12, 1, -18 },
  { 815, 12, 18, 11, 1, -18 },
  { 842, 14, 18, 15, 1, -18 },
  { 874, 15, 18, 15, 1, -18 },
  { 908, 11, 18, 8, -1, -18 },
  { 933, 11, 23, 7, -4, -18 },
  { 965, 14, 18, 13, 1, -18 },
  { 997, 8, 18, 11, 1, -18 },
  { 1015, 19, 18, 20, 1, -18 },
  { 1058, 16, 18, 16, 1, -18 },
  { 1094, 15, 18, 16, 1, -18 },
  { 1128, 12, 18, 13, 1, -18 },
  { 1155, 15, 22, 16, 1, -18 },
  { 1197, 12, 18, 13, 1, -18 },
  { 1224, 12, 18, 12, 0, -18 },
  { 1251, 11, 18, 11, 2, -18 },
  { 1276, 15, 18, 15, 1, -18 },
  { 1310, 13, 18, 13, 2, -18 },
  { 1340, 20, 18, 20, 2, -18 },
  { 1385, 15, 18, 12, -1, -18 },
  { 1419, 12, 18, 12, 2, -18 },
  { 1446, 14, 18, 12, -1, -18 },
  { 1478, 9, 22, 7, 0, -18 },
  { 1503, 4, 18, 9, 3, -18 },
  { 1512, 10, 22, 7, -2, -18 },
  { 1540, 11, 11, 13, 1, -18 },
  { 1556, 9, 2, 9, -2, 2 },
  { 1559, 4, 4, 7, 4, -19 },
  { 1561, 12, 14, 13, 1, -14 },
  { 1582, 12, 19, 13, 0, -19 },
  { 1611, 10, 14, 10, 1, -14 },
  { 1629, 13, 19, 13, 1, -19 },
  { 1660, 10, 14, 12, 1, -14 },
  { 1678, 14, 25, 8, -3, -19 },
  { 1722, 13, 20, 13, 0, -14 },
  { 1755, 12, 19, 13, 0, -19 },
  { 1784, 7, 19, 6, 0, -19 },
  { 1801, 10, 25, 6, -3, -19 },
  { 1833, 13, 19, 12, 0, -19 },
  { 1864, 7, 19, 6, 0, -19 },
  { 1881, 19, 14, 20, 0, -14 },
  { 1915, 12, 14, 13, 0, -14 },
  { 1936, 11, 14, 13, 1, -14 },
  { 1956, 13, 20, 13, -1, -14 },
  { 1989, 12, 20, 13, 1, -14 },
  { 2019, 10, 14, 9, 0, -14 },
  { 2037, 10, 14, 10, 0, -14 },
  { 2055, 8, 16, 8, 1, -16 },
  { 2071, 12, 13, 13, 1, -13 },
  { 2091, 11, 13, 11, 1, -13 },
  { 2109, 17, 13, 17, 1, -13 },
  { 2137, 13, 13, 11, -1, -13 },
  { 2159, 14, 19, 11, -2, -13 },
  { 2193, 11, 13, 10, -1, -13 },
  { 2211, 10, 22, 9, 0, -18 },
  { 2239, 2, 25, 12, 5, -19 },
  { 2246, 9, 22, 9, -1, -18 },
  { 2271, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC25PT7B_H_
