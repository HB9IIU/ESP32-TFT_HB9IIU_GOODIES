#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x21, 0x80, 0x10, 0xE3, 0x80,
  0x6D, 0x3C, 0xF2, 0xD8, 0x06, 0x60, 0x44, 0x04, 0xC0, 0xCC, 0x3F, 0xF0,
  0x88, 0x19, 0x81, 0x90, 0xFF, 0xCF, 0xFC, 0x33, 0x02, 0x20, 0x26, 0x06,
  0x60, 0x03, 0x00, 0xC1, 0xFC, 0xEA, 0x36, 0x0D, 0x03, 0xC0, 0x78, 0x07,
  0x02, 0xE0, 0x9A, 0x2C, 0xFF, 0x1F, 0x81, 0x00, 0x40, 0x3C, 0x33, 0x23,
  0x11, 0x10, 0x99, 0x8C, 0xD8, 0x66, 0x9B, 0x6D, 0xEF, 0xD9, 0x04, 0x88,
  0x6C, 0xC2, 0x66, 0x23, 0x33, 0x1B, 0x30, 0x70, 0x02, 0x00, 0xF8, 0x1D,
  0xC1, 0x8C, 0x19, 0x81, 0xB8, 0x0F, 0x01, 0xC0, 0x36, 0x76, 0x66, 0x63,
  0xCC, 0x3C, 0xE3, 0x87, 0xFC, 0x7C, 0xE0, 0x6B, 0x6C, 0x0C, 0x63, 0x0C,
  0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x40, 0x0C, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x0C, 0x18,
  0xE0, 0x0C, 0x08, 0xC8, 0x7F, 0x1F, 0x68, 0xEC, 0x46, 0x08, 0x04, 0x02,
  0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x36, 0x64, 0xC0,
  0x7F, 0xC0, 0x5F, 0x80, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x04, 0x0F,
  0x8E, 0xCE, 0x36, 0x1B, 0x0F, 0x07, 0x87, 0xC3, 0x61, 0xB0, 0xD8, 0xCC,
  0x67, 0xE1, 0xE0, 0x0E, 0x7B, 0xF2, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60,
  0xC1, 0x83, 0x0E, 0x00, 0x1F, 0x8E, 0x71, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0x86,
  0x70, 0x0C, 0x03, 0x01, 0x80, 0xC1, 0xE0, 0x3C, 0x03, 0x00, 0xE0, 0x30,
  0x0C, 0xFF, 0x3F, 0x00, 0x01, 0xC0, 0xE0, 0x78, 0x16, 0x0D, 0x86, 0x43,
  0x30, 0x8C, 0x63, 0x3F, 0xFF, 0xF8, 0x18, 0x06, 0x01, 0x80, 0x1F, 0xC7,
  0xF1, 0x80, 0x40, 0x30, 0x0F, 0x83, 0xF0, 0x0E, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0xFF, 0x3F, 0x00, 0x0F, 0x8E, 0x0C, 0x0C, 0x06, 0x03, 0xF3, 0xFD,
  0xC6, 0xC3, 0x61, 0xB0, 0xD8, 0xCF, 0xE3, 0xE0, 0x7F, 0xDF, 0xE0, 0x38,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x00, 0x02, 0x03, 0xE1, 0x9C, 0x63, 0x30, 0xC6, 0x61, 0xF8, 0x38,
  0x3F, 0x18, 0xE6, 0x1B, 0x86, 0x63, 0x9D, 0xC3, 0xE0, 0x3F, 0x19, 0x98,
  0xEC, 0x3C, 0x3E, 0x19, 0x9C, 0xFE, 0x3B, 0x01, 0x01, 0x81, 0x8F, 0xC7,
  0x80, 0x31, 0xCC, 0x00, 0x00, 0x00, 0x47, 0x38, 0x18, 0x71, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xC6, 0x18, 0xC3, 0x00, 0x00, 0x81, 0xC3, 0x87, 0x0E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3C, 0x78, 0xF0, 0xE0,
  0x40, 0x00, 0x7E, 0xCC, 0x18, 0x30, 0x61, 0x86, 0x18, 0x60, 0xC0, 0x02,
  0x0E, 0x18, 0x00, 0x07, 0xF0, 0x70, 0xE3, 0x00, 0x88, 0x03, 0x67, 0xCD,
  0x33, 0x3C, 0xCC, 0xF2, 0x33, 0x98, 0x8A, 0x66, 0x69, 0xFF, 0x33, 0xB8,
  0xC0, 0x01, 0x80, 0x03, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x68, 0x1B,
  0x0C, 0xC3, 0x30, 0xCC, 0x63, 0x1F, 0xCF, 0xF3, 0x0D, 0x83, 0x60, 0xF0,
  0x30, 0x1F, 0xC3, 0x3C, 0x61, 0x8C, 0x33, 0x0E, 0x63, 0x8F, 0xC1, 0x9C,
  0x30, 0xCC, 0x19, 0x83, 0x30, 0xC7, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0x88,
  0xE0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFE, 0x18, 0x61, 0x86, 0x38,
  0x73, 0x07, 0x30, 0x63, 0x06, 0x30, 0x66, 0x0E, 0x60, 0xC6, 0x38, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0C, 0x23, 0xF0, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF1, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0xF8, 0xFC, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x00, 0x0F, 0xE3, 0x8C, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0xF6,
  0x1E, 0xC0, 0xD8, 0x1B, 0x03, 0x30, 0xC7, 0xF8, 0x7F, 0x00, 0x1C, 0x38,
  0xC1, 0x86, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x30, 0xFF, 0x86, 0x0C, 0x30,
  0x63, 0x07, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x70, 0xE0, 0x1F, 0x83, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x87,
  0xE0, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0xF8, 0x70, 0x00, 0x1C, 0x71,
  0x8E, 0x19, 0xC1, 0x98, 0x3B, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x36, 0x06,
  0x30, 0x63, 0x06, 0x30, 0x61, 0x8E, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x7F, 0xFE, 0x1C, 0x0F, 0x1C,
  0x0F, 0x1C, 0x1E, 0x16, 0x1E, 0x36, 0x36, 0x36, 0x36, 0x36, 0x6C, 0x36,
  0x6C, 0x36, 0xCC, 0x66, 0xCC, 0x67, 0x8C, 0x67, 0x98, 0x63, 0x18, 0xC3,
  0x18, 0x1C, 0x18, 0xE0, 0xC7, 0x86, 0x2C, 0x23, 0x63, 0x19, 0x18, 0xCC,
  0xC6, 0x66, 0x33, 0x63, 0x0F, 0x18, 0x78, 0xC3, 0xC6, 0x0E, 0x60, 0x60,
  0x02, 0x01, 0xF8, 0x73, 0x98, 0x37, 0x06, 0xC0, 0xD8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x6E, 0x1C, 0xFF, 0x0F, 0x80, 0x1F, 0x83, 0xF8,
  0x63, 0x8C, 0x33, 0x8E, 0x61, 0x8C, 0x71, 0xFC, 0x3C, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x00, 0x02, 0x01, 0xF8, 0x73, 0x98, 0x37, 0x06,
  0xC0, 0xD8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6E, 0x18, 0xFF,
  0x0F, 0x80, 0x30, 0x07, 0x00, 0x70, 0x1F, 0x83, 0x38, 0x63, 0x0C, 0x73,
  0x8C, 0x61, 0x8F, 0xE1, 0xF8, 0x37, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x19,
  0xC3, 0x00, 0x1F, 0xCE, 0x63, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x32, 0x0C, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0x86, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x00,
  0x30, 0x73, 0x06, 0x30, 0x63, 0x06, 0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C,
  0xE0, 0xCC, 0x18, 0xC1, 0x8E, 0x38, 0x7F, 0x03, 0xE0, 0xC1, 0xF0, 0x6C,
  0x3B, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x30, 0xCC, 0x36, 0x05, 0x81, 0xC0,
  0x70, 0x18, 0x00, 0xC3, 0x87, 0xC3, 0x86, 0xC3, 0x8C, 0xC7, 0x8C, 0xC5,
  0x8C, 0xCD, 0x98, 0xCD, 0x98, 0xD9, 0xB0, 0xD9, 0xB0, 0xD1, 0xE0, 0xF1,
  0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0x18, 0x30, 0xC6, 0x0C, 0xC0,
  0xCC, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xB0, 0x31, 0x83,
  0x18, 0x61, 0x8C, 0x1C, 0xC3, 0xE1, 0xB1, 0x8C, 0xC6, 0xC3, 0x61, 0xE0,
  0xE0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x0F, 0xE3, 0xFC, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x07, 0xF9, 0xFF, 0x00, 0x1E, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x60,
  0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xF0, 0xCC, 0xC4, 0x66, 0x66, 0x66,
  0x23, 0x33, 0x1E, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60,
  0xC1, 0x82, 0x0C, 0x18, 0xF0, 0x06, 0x03, 0x80, 0xA0, 0x6C, 0x11, 0x0C,
  0x66, 0x1B, 0x83, 0xFF, 0xCC, 0x80, 0x1C, 0x9F, 0xD8, 0xEC, 0x7C, 0x36,
  0x1B, 0x0D, 0x8E, 0xC7, 0x7D, 0x1D, 0x80, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x13, 0x8F, 0xE3, 0x8C, 0xC3, 0x30, 0xD8, 0x36, 0x19, 0x86, 0x63, 0x9F,
  0xCD, 0xE0, 0x1F, 0x3E, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC,
  0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x1D, 0x8F, 0xE6, 0x39, 0x8E, 0xC3,
  0x30, 0xCC, 0x33, 0x1C, 0xC6, 0x3E, 0x87, 0x60, 0x1E, 0x3F, 0x63, 0x63,
  0xC6, 0xFC, 0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x03, 0xC0, 0xD0, 0x60, 0x18,
  0x0F, 0x87, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x0F, 0x03, 0x00, 0x0E, 0x47, 0xF3, 0x1C,
  0xC7, 0x61, 0x98, 0x66, 0x19, 0x8E, 0x63, 0x9F, 0xC3, 0xB0, 0x0C, 0x03,
  0x21, 0x8F, 0xC1, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x13, 0x8F, 0xE3,
  0x8C, 0xC3, 0x31, 0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0xCC, 0x30, 0x18,
  0xC2, 0x01, 0x98, 0xC6, 0x33, 0x18, 0xC6, 0x33, 0x00, 0x03, 0x03, 0x01,
  0x00, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0xF0, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0xCC,
  0x63, 0x30, 0xD8, 0x3C, 0x1F, 0x07, 0xE1, 0x98, 0x66, 0x19, 0xCC, 0x30,
  0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x00,
  0x17, 0x9C, 0x7F, 0x7C, 0xE7, 0x19, 0x8E, 0x33, 0x18, 0x6C, 0x31, 0x98,
  0x63, 0x30, 0xC6, 0x63, 0x0C, 0xC6, 0x1B, 0x0C, 0x60, 0x33, 0x8F, 0xF3,
  0x8C, 0xC3, 0x31, 0x9C, 0x66, 0x19, 0x86, 0x61, 0x98, 0xCC, 0x30, 0x1E,
  0x1F, 0x98, 0xCC, 0x7C, 0x3E, 0x1B, 0x0D, 0x86, 0xC6, 0x7F, 0x1F, 0x00,
  0x09, 0xC3, 0xF8, 0x71, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x31, 0x86, 0x31,
  0xC7, 0xF1, 0xBC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x1C, 0x9F,
  0xD8, 0xEC, 0x7C, 0x36, 0x1B, 0x0D, 0x8E, 0xC6, 0x7F, 0x1D, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x17, 0x3F, 0x38, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0x1E, 0x3F, 0x60, 0x60, 0x30, 0x3C, 0x0E, 0x06, 0x06,
  0xDC, 0xF8, 0x10, 0xC7, 0xFF, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x3C, 0xF0,
  0x71, 0xB0, 0xD8, 0x6C, 0x36, 0x36, 0x1B, 0x0D, 0x8E, 0xC6, 0x7F, 0x3D,
  0x80, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0x66, 0x61, 0x30, 0xB0, 0x58, 0x38,
  0x1C, 0x00, 0xC3, 0x1E, 0x38, 0xF1, 0xCD, 0x9E, 0x6C, 0xB3, 0x6D, 0xB3,
  0x6D, 0x9A, 0x78, 0xF3, 0xC7, 0x1C, 0x38, 0xE0, 0x18, 0xE3, 0x38, 0x66,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x33, 0x0C, 0x63, 0x8E, 0x00,
  0x18, 0x71, 0x86, 0x18, 0x61, 0x8C, 0x08, 0xC0, 0x98, 0x0D, 0x80, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0xF0, 0x0E, 0x00,
  0x3F, 0x3F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x70, 0x60, 0xFC, 0xFC, 0x07,
  0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x70, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x0E, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30,
  0xF0, 0xE0, 0xFC, 0xC7, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 5, 8, 2, -14 },
  { 16, 12, 14, 11, 0, -14 },
  { 37, 10, 16, 10, 0, -15 },
  { 57, 13, 14, 15, 1, -14 },
  { 80, 12, 15, 12, 0, -15 },
  { 103, 3, 5, 4, 2, -14 },
  { 105, 6, 17, 6, 1, -14 },
  { 118, 7, 17, 6, -2, -14 },
  { 133, 8, 8, 10, 2, -15 },
  { 141, 9, 10, 10, 1, -12 },
  { 153, 4, 5, 5, -1, -2 },
  { 156, 5, 2, 6, 0, -6 },
  { 158, 3, 3, 5, 0, -3 },
  { 160, 10, 14, 7, -1, -14 },
  { 178, 9, 15, 10, 1, -15 },
  { 195, 7, 14, 10, 2, -14 },
  { 208, 10, 14, 10, 0, -14 },
  { 226, 10, 14, 10, 0, -14 },
  { 244, 10, 14, 10, 0, -14 },
  { 262, 10, 14, 10, 0, -14 },
  { 280, 9, 14, 10, 1, -14 },
  { 296, 10, 14, 10, 1, -14 },
  { 314, 10, 15, 10, 0, -15 },
  { 333, 9, 14, 10, 1, -14 },
  { 349, 5, 11, 5, 0, -11 },
  { 356, 6, 14, 5, -1, -11 },
  { 367, 9, 10, 10, 1, -12 },
  { 379, 9, 6, 10, 1, -10 },
  { 386, 9, 10, 10, 1, -12 },
  { 398, 7, 14, 8, 1, -14 },
  { 411, 14, 16, 15, 1, -14 },
  { 439, 10, 14, 10, -1, -14 },
  { 457, 11, 14, 11, 0, -14 },
  { 477, 11, 14, 10, 1, -14 },
  { 497, 12, 14, 12, 0, -14 },
  { 518, 10, 14, 9, 0, -14 },
  { 536, 10, 14, 9, 0, -14 },
  { 554, 11, 14, 12, 1, -14 },
  { 574, 13, 14, 12, 0, -14 },
  { 597, 9, 14, 6, -1, -14 },
  { 613, 9, 18, 5, -3, -14 },
  { 634, 12, 14, 10, 0, -14 },
  { 655, 8, 14, 9, 0, -14 },
  { 669, 16, 14, 16, 0, -14 },
  { 697, 13, 14, 13, 0, -14 },
  { 720, 11, 15, 13, 1, -15 },
  { 741, 11, 14, 10, 0, -14 },
  { 761, 11, 18, 13, 1, -15 },
  { 786, 11, 14, 11, 0, -14 },
  { 806, 10, 14, 9, 0, -14 },
  { 824, 9, 14, 9, 2, -14 },
  { 840, 12, 14, 12, 1, -14 },
  { 861, 10, 14, 10, 2, -14 },
  { 879, 16, 14, 16, 2, -14 },
  { 907, 12, 14, 10, -1, -14 },
  { 928, 9, 14, 9, 2, -14 },
  { 944, 11, 14, 9, -1, -14 },
  { 964, 7, 17, 6, 0, -14 },
  { 979, 4, 14, 7, 2, -14 },
  { 986, 7, 17, 6, -1, -14 },
  { 1001, 10, 8, 10, 0, -14 },
  { 1011, 8, 1, 7, -2, 2 },
  { 1012, 3, 3, 6, 3, -15 },
  { 1014, 9, 11, 10, 1, -11 },
  { 1027, 10, 15, 11, 0, -15 },
  { 1046, 8, 11, 8, 1, -11 },
  { 1057, 10, 15, 11, 1, -15 },
  { 1076, 8, 11, 9, 1, -11 },
  { 1087, 10, 20, 6, -2, -15 },
  { 1112, 10, 16, 11, 0, -11 },
  { 1132, 10, 15, 11, 0, -15 },
  { 1151, 5, 15, 5, 0, -15 },
  { 1161, 8, 20, 5, -3, -15 },
  { 1181, 10, 15, 9, 0, -15 },
  { 1200, 6, 15, 5, 0, -15 },
  { 1212, 15, 11, 16, 0, -11 },
  { 1233, 10, 11, 11, 0, -11 },
  { 1247, 9, 11, 10, 1, -11 },
  { 1260, 11, 16, 11, -1, -11 },
  { 1282, 9, 16, 11, 1, -11 },
  { 1300, 8, 11, 7, 0, -11 },
  { 1311, 8, 11, 8, 0, -11 },
  { 1322, 6, 13, 6, 1, -13 },
  { 1332, 9, 11, 11, 1, -11 },
  { 1345, 9, 11, 9, 1, -11 },
  { 1358, 13, 11, 14, 1, -11 },
  { 1376, 11, 11, 9, -1, -11 },
  { 1392, 12, 16, 9, -2, -11 },
  { 1416, 8, 11, 8, 0, -11 },
  { 1427, 8, 17, 7, 0, -14 },
  { 1444, 2, 20, 10, 4, -15 },
  { 1449, 8, 17, 7, -1, -14 },
  { 1466, 9, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC20PT7B_H_
