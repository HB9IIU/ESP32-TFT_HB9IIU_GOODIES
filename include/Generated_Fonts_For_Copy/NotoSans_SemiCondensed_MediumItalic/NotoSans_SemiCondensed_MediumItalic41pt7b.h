#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x00, 0x3C, 0x7B, 0xE3, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x0E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x01, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x79, 0xC6, 0x0F, 0x38, 0x03, 0xC6, 0x00, 0x78, 0xC0, 0x0F, 0x18, 0x01,
  0xF7, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x67, 0x80, 0x0C, 0xF8, 0x01, 0x8F, 0x00,
  0x71, 0xE0, 0x0C, 0x78, 0xC1, 0x9F, 0x1F, 0x3F, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC1, 0xFE, 0x00, 0xE0,
  0xF3, 0xC0, 0x70, 0x38, 0xF0, 0x3C, 0x1E, 0x3C, 0x0E, 0x07, 0x0F, 0x07,
  0x03, 0xC3, 0xC3, 0xC0, 0xF0, 0xF0, 0xE0, 0x38, 0x38, 0x70, 0x0E, 0x0E,
  0x3C, 0x03, 0x83, 0x8E, 0x00, 0xE1, 0xE7, 0x1F, 0x38, 0x73, 0xCF, 0xEE,
  0x3C, 0xE7, 0xFF, 0xDE, 0x73, 0xCF, 0xFF, 0x3C, 0xE1, 0xDF, 0x8E, 0x78,
  0x71, 0x87, 0x9C, 0x1C, 0x03, 0xC7, 0x07, 0x00, 0xE3, 0xC1, 0xC0, 0x78,
  0xF0, 0xF0, 0x3C, 0x3C, 0x3C, 0x0E, 0x0E, 0x0E, 0x07, 0x83, 0x83, 0x83,
  0xC0, 0xE1, 0xE0, 0xE0, 0x3C, 0xF0, 0x78, 0x0F, 0xF8, 0x3C, 0x01, 0xFE,
  0x1E, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x3E, 0x00,
  0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x3E, 0x7C, 0xF0, 0x79, 0xF1, 0xF0, 0xF3, 0xC1,
  0xF3, 0xCF, 0x01, 0xEF, 0x9E, 0x03, 0xFE, 0x3C, 0x03, 0xF8, 0x78, 0x07,
  0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x3F, 0x83, 0xF0, 0xFF, 0x83, 0xFF, 0xEF,
  0x07, 0xFF, 0x9F, 0x03, 0xFC, 0x1F, 0x00, 0x3C, 0xF7, 0x9E, 0x79, 0xC7,
  0x1C, 0x73, 0x80, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x08, 0x1C, 0x06, 0x0E,
  0x07, 0xCE, 0x03, 0xFF, 0x06, 0x7F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xF8, 0x03, 0xDC, 0x03, 0xCF, 0x03, 0xE3, 0x80, 0xE1, 0xE0, 0x20, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x0F,
  0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFE, 0x0F, 0x87, 0x83, 0xC1, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x8F, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x3F, 0xE7, 0xFE, 0xF9,
  0xE7, 0x1E, 0x43, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x80,
  0xC0, 0x7C, 0x04, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0x83, 0xF0, 0x20, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x88, 0x01, 0xF0, 0xF0, 0x7F,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xDE, 0x00,
  0x3D, 0xC0, 0x07, 0xBC, 0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x80, 0x3F, 0x1C, 0x1F, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x10, 0x07, 0x9F,
  0xC0, 0xF7, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xF8, 0xFC, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x03, 0xC3, 0xE0,
  0x7D, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07,
  0xE3, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9F, 0x01, 0xE1, 0xF0, 0x7C, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF8,
  0xF0, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3,
  0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x83, 0xF1, 0xF8, 0xFE, 0x1F, 0xFB, 0xC1,
  0xFF, 0xF0, 0x1F, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x83, 0x07, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x03, 0xC3, 0xE1, 0xF0,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x0F, 0x87, 0xC7, 0xE1, 0xE0, 0x00, 0x40, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xF3, 0x83, 0xE4, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x1C, 0x07, 0xFC, 0x73,
  0xC1, 0xFF, 0x87, 0x38, 0x3E, 0x78, 0x77, 0x87, 0x87, 0x87, 0x70, 0x70,
  0x78, 0x77, 0x0E, 0x07, 0x07, 0xF0, 0xE0, 0x70, 0x7E, 0x1E, 0x0F, 0x07,
  0xE1, 0xC0, 0xF0, 0xFE, 0x1C, 0x0E, 0x0E, 0xE1, 0xC1, 0xE0, 0xEE, 0x1C,
  0x1E, 0x1E, 0xE1, 0xC3, 0xE1, 0xCE, 0x1E, 0x7E, 0x78, 0xE1, 0xFE, 0xFF,
  0x8E, 0x0F, 0xC7, 0xE0, 0xF0, 0x10, 0x18, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x01,
  0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0x07, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1,
  0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x07,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xC3, 0xF8, 0x1E,
  0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x0F, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x30,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x04, 0x03, 0xF8, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3E, 0x3F, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3E, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0x80, 0x3E,
  0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xF0, 0x78, 0x1F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0x81, 0xC0, 0xFC, 0x00, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xFF, 0x3C, 0x07, 0xFC, 0xF8, 0x0F, 0xF9,
  0xF0, 0x1F, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1F,
  0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xFC,
  0x03, 0xC0, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F,
  0x81, 0xE0, 0x07, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x1F, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0x70, 0x03, 0xFC, 0x0F, 0x70, 0x07, 0xBC, 0x0F, 0x78, 0x07, 0xBC,
  0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x1E, 0x78, 0x3C, 0xF0,
  0x1E, 0x38, 0x78, 0xF0, 0x1C, 0x38, 0x78, 0xF0, 0x3C, 0x38, 0xF0, 0xF0,
  0x3C, 0x38, 0xF0, 0xF0, 0x3C, 0x39, 0xE1, 0xE0, 0x3C, 0x39, 0xE1, 0xE0,
  0x38, 0x3F, 0xC1, 0xE0, 0x78, 0x3F, 0xC1, 0xE0, 0x78, 0x3F, 0x83, 0xE0,
  0x78, 0x3F, 0x83, 0xC0, 0x78, 0x3F, 0x03, 0xC0, 0xF0, 0x3F, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0,
  0xF8, 0x00, 0xF0, 0x7F, 0x00, 0x3C, 0x1F, 0xC0, 0x1E, 0x07, 0xF0, 0x07,
  0x81, 0xFC, 0x01, 0xE0, 0x77, 0x80, 0x78, 0x3D, 0xE0, 0x1E, 0x0F, 0x78,
  0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x1E,
  0x1E, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78,
  0x1E, 0x0F, 0x1E, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x1E,
  0xF0, 0x3C, 0x07, 0xBC, 0x1E, 0x01, 0xEF, 0x07, 0x80, 0x7B, 0x81, 0xE0,
  0x0F, 0xE0, 0x78, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0x83,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x7F,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x8F, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07,
  0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0,
  0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x01,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x8F,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x3E,
  0x0F, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xF1,
  0xE0, 0x0F, 0x0F, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x3E, 0x01,
  0xE1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0xE0, 0xF8, 0x02, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x0C, 0x01, 0xF0,
  0xF8, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x40, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0x1F,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x78,
  0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1E, 0xF0,
  0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0,
  0x0F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0,
  0x3D, 0xC0, 0xF0, 0xF0, 0x39, 0xC0, 0xF0, 0xF0, 0x79, 0xC1, 0xE0, 0xF0,
  0x79, 0xC1, 0xE0, 0xF0, 0xF1, 0xC3, 0xE0, 0xF0, 0xF1, 0xC3, 0xC0, 0xF0,
  0xE1, 0xC3, 0xC0, 0xF1, 0xE1, 0xC7, 0x80, 0xF1, 0xC1, 0xC7, 0x80, 0xF3,
  0xC1, 0xCF, 0x00, 0xF3, 0xC1, 0xCF, 0x00, 0xF7, 0x81, 0xCF, 0x00, 0xF7,
  0x81, 0xDE, 0x00, 0xF7, 0x01, 0xDE, 0x00, 0xFF, 0x01, 0xDC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0xC0,
  0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0,
  0x1E, 0x7C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1,
  0xE0, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xF0,
  0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x80, 0x3C, 0x70, 0x07,
  0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0xC1, 0xC0, 0x38, 0x78,
  0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x0E, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0xF8, 0xF1, 0xE1, 0xE1, 0xC1, 0xC0, 0x00, 0x40, 0x00, 0x7F, 0x3C,
  0x1F, 0xF7, 0x87, 0xFE, 0xE1, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x01, 0xF3,
  0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E,
  0x07, 0xE3, 0xC1, 0xF8, 0x7C, 0x7F, 0x0F, 0xFD, 0xE0, 0xFF, 0x3C, 0x0F,
  0xC7, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x04, 0x01,
  0xE7, 0xF0, 0x3D, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x3E, 0x3F, 0x07, 0xC7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E,
  0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x7F, 0x1F, 0x8F, 0xFF, 0xE1, 0xCF,
  0xF8, 0x38, 0xFE, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0x04, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x30, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x41, 0xE0, 0x1F, 0xCF, 0x01, 0xFF, 0x78, 0x1F, 0xFB, 0x81, 0xF0, 0xFC,
  0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x1F,
  0x81, 0xF1, 0xFC, 0x0F, 0xFD, 0xE0, 0x3F, 0xEF, 0x00, 0xFC, 0x70, 0x00,
  0x00, 0x20, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xE2, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF3, 0xC0, 0x7F, 0xDE, 0x07,
  0xFE, 0xE0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC1,
  0xE0, 0x7E, 0x0F, 0x07, 0xE0, 0x7C, 0x7F, 0x03, 0xFF, 0x78, 0x0F, 0xF3,
  0xC0, 0x3F, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x0C, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x04, 0x01, 0xE7, 0xF0, 0x3D, 0xFF, 0x07, 0xFF, 0xE0, 0xFE,
  0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x03, 0xE7, 0xC0,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x1F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC0, 0x01, 0x00, 0xF0, 0x7C,
  0x1F, 0x07, 0x80, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00,
  0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xE7,
  0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF8, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0,
  0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x80, 0x3C, 0xFE,
  0x1F, 0xC0, 0xE7, 0xF8, 0xFF, 0x83, 0xBF, 0xF7, 0xFE, 0x0F, 0xC3, 0xFC,
  0x7C, 0x7E, 0x0F, 0xC1, 0xF1, 0xF0, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0x1E,
  0x1E, 0x03, 0xC0, 0x78, 0xF8, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x07, 0x8F,
  0x01, 0xE0, 0x1E, 0x3C, 0x07, 0x80, 0xF8, 0xF0, 0x1E, 0x03, 0xC7, 0xC0,
  0x78, 0x0F, 0x1E, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x78, 0xF0, 0x1F, 0x01,
  0xE3, 0xC0, 0x78, 0x0F, 0x8F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x06, 0x01,
  0xE7, 0xF0, 0x39, 0xFF, 0x07, 0x7F, 0xF1, 0xFE, 0x3E, 0x3F, 0x07, 0xC7,
  0xC0, 0x78, 0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C,
  0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0xF8, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0xC7, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x1E, 0x7F, 0x00,
  0xE7, 0xFC, 0x07, 0x7F, 0xE0, 0x3F, 0x0F, 0x83, 0xF0, 0x3C, 0x1F, 0x01,
  0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x3E,
  0x1E, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0x1F, 0x83, 0xDF,
  0xF8, 0x1E, 0xFF, 0x80, 0xF3, 0xF8, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0x1C, 0x1F, 0xF7, 0x87, 0xFE, 0xE1, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F,
  0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x1F, 0x1E, 0x07, 0xE3, 0xC1, 0xF8, 0x7C, 0x7F, 0x0F, 0xFD, 0xE0, 0xFF,
  0x3C, 0x0F, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x1E, 0x7C, 0x39, 0xF8, 0x77, 0xF0,
  0xEF, 0xE3, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x60, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x06, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x80, 0x7C, 0xE0, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x0F, 0xC3, 0xE3, 0xF8,
  0x7F, 0xEF, 0x07, 0xF9, 0xE0, 0x7E, 0x38, 0x00, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0x70, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1,
  0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79,
  0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x1F,
  0x01, 0xFF, 0x01, 0xF0, 0x1E, 0x70, 0x3F, 0x03, 0xC7, 0x03, 0xF0, 0x3C,
  0x70, 0x3F, 0x07, 0xC7, 0x07, 0x70, 0x78, 0x70, 0x77, 0x07, 0x87, 0x0F,
  0x70, 0xF0, 0x70, 0xE7, 0x0F, 0x07, 0x1E, 0x71, 0xE0, 0x71, 0xC7, 0x1E,
  0x07, 0x1C, 0x73, 0xC0, 0x73, 0xC7, 0x3C, 0x07, 0x38, 0x73, 0xC0, 0x77,
  0x87, 0x78, 0x07, 0x70, 0x77, 0x80, 0x77, 0x07, 0x70, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x1F, 0x00,
  0xF8, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x9F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x07,
  0x83, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1,
  0xE0, 0x01, 0xE3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0xE7,
  0x80, 0x00, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x9F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFE,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x5F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0x80, 0x3F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 11, 1, -29 },
  { 38, 13, 10, 16, 4, -29 },
  { 55, 23, 29, 23, 1, -29 },
  { 139, 19, 33, 20, 1, -31 },
  { 218, 26, 30, 31, 3, -30 },
  { 316, 23, 30, 25, 1, -30 },
  { 403, 6, 10, 9, 4, -29 },
  { 411, 14, 35, 12, 1, -29 },
  { 473, 13, 35, 12, -3, -29 },
  { 530, 17, 17, 20, 4, -31 },
  { 567, 18, 19, 21, 2, -24 },
  { 610, 8, 10, 10, -2, -5 },
  { 620, 10, 4, 12, 1, -13 },
  { 625, 5, 5, 10, 1, -5 },
  { 629, 20, 29, 15, -2, -29 },
  { 702, 18, 30, 20, 2, -30 },
  { 770, 12, 29, 20, 5, -29 },
  { 814, 21, 30, 20, -1, -30 },
  { 893, 20, 30, 20, 0, -30 },
  { 968, 20, 29, 20, 0, -29 },
  { 1041, 19, 29, 20, 1, -29 },
  { 1110, 19, 30, 20, 2, -30 },
  { 1182, 20, 29, 20, 2, -29 },
  { 1255, 19, 30, 20, 1, -30 },
  { 1327, 19, 30, 20, 1, -30 },
  { 1399, 9, 23, 10, 0, -23 },
  { 1425, 11, 28, 10, -2, -23 },
  { 1464, 18, 20, 21, 2, -25 },
  { 1509, 18, 11, 21, 2, -20 },
  { 1534, 18, 20, 21, 2, -25 },
  { 1579, 15, 30, 16, 2, -30 },
  { 1636, 28, 33, 31, 2, -29 },
  { 1752, 21, 29, 21, -2, -29 },
  { 1829, 21, 29, 22, 1, -29 },
  { 1906, 22, 30, 21, 2, -30 },
  { 1989, 23, 29, 25, 1, -29 },
  { 2073, 20, 29, 19, 1, -29 },
  { 2146, 20, 29, 18, 1, -29 },
  { 2219, 23, 30, 25, 2, -30 },
  { 2306, 25, 29, 25, 1, -29 },
  { 2397, 17, 29, 13, -1, -29 },
  { 2459, 17, 37, 11, -6, -29 },
  { 2538, 24, 29, 21, 1, -29 },
  { 2625, 14, 29, 18, 1, -29 },
  { 2676, 32, 29, 32, 1, -29 },
  { 2792, 26, 29, 27, 1, -29 },
  { 2887, 23, 30, 26, 2, -30 },
  { 2974, 21, 29, 21, 1, -29 },
  { 3051, 23, 37, 26, 2, -30 },
  { 3158, 21, 29, 22, 1, -29 },
  { 3235, 20, 30, 19, 0, -30 },
  { 3310, 19, 29, 19, 3, -29 },
  { 3379, 24, 29, 25, 2, -29 },
  { 3466, 21, 29, 21, 4, -29 },
  { 3543, 32, 29, 33, 4, -29 },
  { 3659, 25, 29, 20, -2, -29 },
  { 3750, 19, 29, 19, 4, -29 },
  { 3819, 22, 29, 19, -1, -29 },
  { 3899, 16, 36, 12, -1, -29 },
  { 3971, 8, 29, 15, 4, -29 },
  { 4000, 16, 36, 12, -3, -29 },
  { 4072, 19, 17, 21, 1, -29 },
  { 4113, 16, 2, 15, -4, 4 },
  { 4117, 7, 6, 12, 6, -31 },
  { 4123, 19, 23, 21, 2, -23 },
  { 4178, 19, 31, 22, 1, -31 },
  { 4252, 16, 23, 17, 2, -23 },
  { 4298, 21, 31, 22, 2, -31 },
  { 4380, 16, 23, 19, 2, -23 },
  { 4426, 22, 41, 12, -5, -31 },
  { 4539, 21, 33, 22, 0, -23 },
  { 4626, 19, 31, 22, 1, -31 },
  { 4700, 10, 31, 10, 1, -31 },
  { 4739, 16, 41, 10, -5, -31 },
  { 4821, 20, 31, 19, 1, -31 },
  { 4899, 10, 31, 10, 1, -31 },
  { 4938, 30, 23, 32, 1, -23 },
  { 5025, 19, 23, 22, 1, -23 },
  { 5080, 18, 22, 21, 2, -22 },
  { 5130, 21, 33, 22, -1, -23 },
  { 5217, 19, 33, 22, 2, -23 },
  { 5296, 15, 23, 15, 1, -23 },
  { 5340, 16, 23, 16, 0, -23 },
  { 5386, 12, 27, 13, 2, -27 },
  { 5427, 19, 22, 22, 2, -22 },
  { 5480, 18, 22, 18, 2, -22 },
  { 5530, 28, 22, 28, 2, -22 },
  { 5607, 22, 22, 18, -2, -22 },
  { 5668, 24, 32, 18, -4, -22 },
  { 5764, 18, 22, 16, -1, -22 },
  { 5814, 16, 35, 14, 0, -29 },
  { 5884, 3, 41, 20, 9, -31 },
  { 5900, 16, 35, 14, -2, -29 },
  { 5970, 18, 5, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC41PT7B_H_
