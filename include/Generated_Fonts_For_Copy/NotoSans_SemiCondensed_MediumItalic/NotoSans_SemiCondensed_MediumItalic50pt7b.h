#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x06,
  0x00, 0x00, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x70, 0x78,
  0xF0, 0x78, 0xF0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x07,
  0x83, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0x7C, 0x07, 0xC7, 0x0C, 0x07, 0xC7, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0x8E,
  0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0xEC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3B, 0xF0, 0x00, 0x39,
  0xF0, 0x00, 0x30, 0xF0, 0x00, 0x70, 0xF8, 0x00, 0x70, 0xF0, 0x00, 0x71,
  0xF0, 0x80, 0x71, 0xF0, 0xE0, 0x63, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0x3C, 0x03, 0xFF, 0x00,
  0x1E, 0x03, 0xF7, 0xC0, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0xF8, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x07, 0x80, 0x3C, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x87, 0x80, 0x0F, 0x07,
  0x83, 0xC0, 0x0F, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE3, 0xE0, 0x03, 0xC0,
  0xF1, 0xE1, 0xE1, 0xE0, 0xF1, 0xE3, 0xFC, 0xF0, 0x79, 0xF3, 0xFF, 0x7C,
  0x78, 0xF3, 0xFF, 0x9F, 0xFC, 0xF3, 0xE3, 0xCF, 0xFC, 0xF9, 0xE1, 0xF3,
  0xFC, 0x79, 0xF0, 0x78, 0xFC, 0x78, 0xF0, 0x7C, 0x00, 0x7C, 0x78, 0x3E,
  0x00, 0x3C, 0x7C, 0x1E, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3E, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC1,
  0xE0, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x78,
  0x78, 0x07, 0x80, 0x3E, 0x7C, 0x07, 0x80, 0x1F, 0xFC, 0x07, 0xC0, 0x07,
  0xFC, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xF0, 0x1F, 0x1F, 0x9F, 0x03, 0xE3,
  0xF0, 0xF8, 0x3E, 0x7E, 0x0F, 0xC7, 0xC7, 0xC0, 0x7C, 0x7C, 0x7C, 0x07,
  0xEF, 0x8F, 0x80, 0x3F, 0xF8, 0xF8, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xE0,
  0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0x1F,
  0x80, 0xFF, 0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7,
  0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x40, 0x78, 0x06, 0x07,
  0x80, 0x78, 0x78, 0x0F, 0xE7, 0x00, 0xFF, 0xF3, 0xF3, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x7B, 0x80, 0x1F, 0x3C, 0x03,
  0xF3, 0xC0, 0x7E, 0x1E, 0x03, 0xC1, 0xE0, 0x1C, 0x1F, 0x00, 0x81, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xC3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFF,
  0x3F, 0xBE, 0xFE, 0x7C, 0xF1, 0xF1, 0xC3, 0xE1, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0x80, 0xFC, 0x03, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xF0, 0x7F, 0x01, 0xC0, 0x3F, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x80, 0x03, 0xF0, 0xF0, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0xF0,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x06, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xE0,
  0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x40, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x0F, 0x9F,
  0xF0, 0x1F, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0xFF, 0xDF, 0xE1, 0xFE, 0x07,
  0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x1F, 0xC7, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7E, 0x03,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F,
  0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x1F, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xF7, 0xC0, 0xFF, 0xDF, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x40, 0x3F, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x80, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x1F, 0xC4, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x01, 0xFE, 0x07, 0x87, 0x80, 0xFF,
  0xF0, 0xF1, 0xE0, 0x3F, 0xFC, 0x1E, 0x3C, 0x0F, 0x87, 0x83, 0xCF, 0x03,
  0xC0, 0xF0, 0x79, 0xE0, 0xF8, 0x1E, 0x0F, 0x78, 0x1E, 0x07, 0x81, 0xEF,
  0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xF0, 0x1E, 0x07, 0xBC, 0x3C, 0x03, 0xC0,
  0xFF, 0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xF0, 0x1E, 0x07, 0xBC, 0x1E, 0x03,
  0xC0, 0xF7, 0x83, 0xC0, 0xF8, 0x3C, 0xF0, 0x78, 0x1E, 0x07, 0x9E, 0x0F,
  0x07, 0xC1, 0xE3, 0xC1, 0xE1, 0xFC, 0x7C, 0x78, 0x3F, 0xF7, 0xFF, 0x0F,
  0x03, 0xFE, 0x7F, 0xC1, 0xE0, 0x3F, 0x8F, 0xF0, 0x1E, 0x00, 0x80, 0x30,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0xFE,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x1F, 0xC1, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0x0F, 0x80, 0xFE, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x02, 0x00, 0xFE, 0x03, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xE0, 0x7C, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x8F, 0xE0, 0x3F,
  0xC0, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0xFC, 0x03, 0xFF, 0x8F,
  0x80, 0x3F, 0xF8, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xDE, 0x00, 0x1F, 0xF8, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x0F, 0x78, 0x00,
  0xFB, 0xE0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xDF, 0x00,
  0xFB, 0xE0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0x80,
  0x78, 0xF8, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x1F, 0x1E, 0x03, 0xC7, 0xC0,
  0x3E, 0x3C, 0x0F, 0x8F, 0x80, 0x78, 0x78, 0x1E, 0x1F, 0x01, 0xF0, 0xF0,
  0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0xF0, 0xF8, 0x07, 0xC3, 0xC3, 0xE1, 0xF0,
  0x0F, 0x87, 0x87, 0x83, 0xE0, 0x1E, 0x0F, 0x9F, 0x07, 0xC0, 0x7C, 0x1F,
  0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0x01, 0xF0, 0x3D, 0xE0, 0x7C,
  0x03, 0xC0, 0x7F, 0xC0, 0xF8, 0x07, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0x01,
  0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F,
  0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x3E,
  0x01, 0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x3E,
  0x03, 0xDF, 0x00, 0x3C, 0x03, 0xDF, 0x00, 0x7C, 0x07, 0xCF, 0x00, 0x7C,
  0x07, 0xCF, 0x80, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0x07, 0xCF, 0x80, 0xF8,
  0x07, 0x87, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8,
  0x0F, 0x83, 0xC0, 0xF8, 0x0F, 0x83, 0xE1, 0xF0, 0x0F, 0x03, 0xE1, 0xF0,
  0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x01, 0xF1, 0xE0,
  0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x00, 0xF3, 0xE0, 0x3E, 0x00, 0xFB, 0xE0,
  0x3E, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0xFB, 0xC0, 0x3E, 0x00, 0x7F, 0xC0,
  0x7C, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x7F,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0x80, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x7E, 0x03, 0xF0, 0x06,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0xC0, 0x07, 0xE0, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x1F, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x03,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xC0, 0x0F,
  0x9F, 0x00, 0x3F, 0x80, 0x1F, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x7C, 0x01,
  0xFE, 0x00, 0xF8, 0xF8, 0x07, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x78, 0x07,
  0xC3, 0xE0, 0x1E, 0xF0, 0x1F, 0x87, 0xC0, 0x7D, 0xE0, 0x3E, 0x0F, 0x80,
  0xF3, 0xC0, 0x7C, 0x1F, 0x03, 0xE7, 0x81, 0xF0, 0x3E, 0x07, 0x8F, 0x03,
  0xE0, 0x7C, 0x1F, 0x1E, 0x0F, 0x80, 0xF8, 0x3C, 0x3C, 0x1F, 0x01, 0xF0,
  0x78, 0x78, 0x3E, 0x03, 0xE1, 0xF0, 0xF0, 0xF8, 0x07, 0xC3, 0xC1, 0xE1,
  0xF0, 0x0F, 0x8F, 0x83, 0xC7, 0xC0, 0x1F, 0x1E, 0x07, 0x8F, 0x80, 0x3E,
  0x7C, 0x0F, 0x1E, 0x00, 0x7C, 0xF0, 0x1E, 0x7C, 0x00, 0xFB, 0xE0, 0x3C,
  0xF8, 0x01, 0xF7, 0xC0, 0x7B, 0xE0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x07,
  0xFE, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x1E, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x7C, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F,
  0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0xF0, 0x00,
  0xF3, 0xE0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F, 0x87,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xFE, 0x1F, 0x01, 0xFF, 0x9E, 0x03,
  0xFF, 0x9E, 0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFB, 0xC0, 0x3F, 0xF3, 0xC0, 0x1F,
  0xC3, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC7, 0xF0, 0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07,
  0xBF, 0xFE, 0x07, 0xF8, 0x7E, 0x0F, 0xF0, 0x3E, 0x0F, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFB, 0xFF, 0xC0, 0xF1, 0xFF, 0x80, 0xF0, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xE0, 0x41, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x06, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x03, 0xF8, 0x7C, 0x01, 0xFF, 0xBE, 0x00, 0xFF, 0xEF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F,
  0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0x00, 0x3F, 0xF3, 0xC0,
  0x07, 0xF0, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC1, 0xF1, 0xF8, 0x0F, 0x1F, 0x00,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x07, 0xE7, 0xC7,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x01, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x84, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x1F, 0xF9,
  0xE0, 0x1F, 0xFE, 0x78, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xF8,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0xFB, 0xE0,
  0x1F, 0xFE, 0xF0, 0x03, 0xFF, 0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x30, 0x03, 0xF0, 0x0F, 0x83, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0xC0,
  0x7C, 0xFF, 0xC0, 0xFB, 0xFF, 0x81, 0xEF, 0xFF, 0x83, 0xFC, 0x3F, 0x0F,
  0xF0, 0x3E, 0x1F, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8,
  0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x9F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0,
  0xFC, 0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x87,
  0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0x87, 0xF0, 0x1F, 0xC0, 0x78, 0xFF, 0x87, 0xFE,
  0x07, 0x9F, 0xFC, 0xFF, 0xF0, 0x7B, 0xFF, 0xDF, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC1, 0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0xFC,
  0x07, 0xF0, 0x1F, 0x0F, 0x80, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x8F, 0xF0, 0x1E,
  0x3F, 0xF0, 0x3C, 0xFF, 0xE0, 0x7B, 0xFF, 0xE1, 0xFF, 0x0F, 0xC3, 0xFC,
  0x0F, 0x87, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x00,
  0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x1E, 0x3F, 0xE0,
  0x03, 0xCF, 0xFE, 0x00, 0x7B, 0xFF, 0xE0, 0x0F, 0xF0, 0xFC, 0x03, 0xFC,
  0x0F, 0x80, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7B,
  0xFF, 0xE0, 0x1F, 0x7F, 0xF8, 0x03, 0xE7, 0xFE, 0x00, 0x7C, 0x7F, 0x00,
  0x0F, 0x81, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0x01, 0xFF, 0x9E, 0x03,
  0xFF, 0x9E, 0x07, 0xFF, 0xFE, 0x0F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x1F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFB, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F,
  0xC7, 0xC0, 0x02, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0xF1, 0xFC, 0x1E, 0x7F, 0x03, 0xDF, 0xE0,
  0xFF, 0xEC, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x80, 0xC1, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x88,
  0x01, 0xF8, 0xC0, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x08, 0x00, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x0F, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFB, 0xE0, 0x7F, 0xFB, 0xC0,
  0x7F, 0xE3, 0xC0, 0x1F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x03,
  0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xFC, 0x07,
  0xEF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0xFF, 0x01, 0xF3, 0xE0, 0x7F, 0x81,
  0xF1, 0xF0, 0x7B, 0xC0, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0x7C, 0x1E, 0xF0,
  0x7C, 0x3E, 0x1E, 0x78, 0x3C, 0x1F, 0x0F, 0x3C, 0x3E, 0x0F, 0x8F, 0x1E,
  0x1F, 0x07, 0xC7, 0x8F, 0x1F, 0x03, 0xE7, 0xC7, 0x8F, 0x81, 0xF3, 0xC3,
  0xCF, 0x80, 0xF9, 0xE1, 0xE7, 0xC0, 0x7D, 0xE0, 0xF3, 0xC0, 0x3E, 0xF0,
  0x7B, 0xE0, 0x1F, 0xF0, 0x3D, 0xE0, 0x0F, 0xF8, 0x1E, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C,
  0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xF0, 0x1F, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x8F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80,
  0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x7F, 0xE8, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 16, 13, 20, 5, -36 },
  { 88, 28, 36, 29, 1, -36 },
  { 214, 24, 41, 25, 1, -38 },
  { 337, 33, 37, 38, 3, -36 },
  { 490, 28, 37, 30, 1, -36 },
  { 620, 7, 13, 11, 5, -36 },
  { 632, 16, 44, 14, 2, -36 },
  { 720, 17, 44, 14, -4, -36 },
  { 814, 20, 21, 24, 5, -38 },
  { 867, 22, 24, 26, 3, -30 },
  { 933, 10, 13, 12, -2, -6 },
  { 950, 13, 5, 15, 1, -16 },
  { 959, 6, 7, 12, 1, -6 },
  { 965, 24, 36, 18, -2, -36 },
  { 1073, 22, 37, 25, 2, -36 },
  { 1175, 15, 36, 25, 6, -36 },
  { 1243, 25, 36, 25, -1, -36 },
  { 1356, 24, 37, 25, 0, -36 },
  { 1467, 24, 36, 25, 0, -36 },
  { 1575, 24, 37, 25, 1, -36 },
  { 1686, 23, 37, 25, 2, -36 },
  { 1793, 23, 36, 25, 3, -36 },
  { 1897, 24, 37, 25, 1, -36 },
  { 2008, 23, 37, 25, 1, -36 },
  { 2115, 10, 28, 12, 1, -27 },
  { 2150, 15, 34, 12, -3, -27 },
  { 2214, 22, 24, 26, 3, -30 },
  { 2280, 22, 14, 26, 3, -25 },
  { 2319, 22, 24, 26, 3, -30 },
  { 2385, 18, 37, 19, 3, -36 },
  { 2469, 35, 40, 38, 2, -36 },
  { 2644, 26, 36, 26, -3, -36 },
  { 2761, 26, 36, 27, 1, -36 },
  { 2878, 26, 37, 26, 3, -36 },
  { 2999, 28, 36, 30, 1, -36 },
  { 3125, 24, 36, 23, 1, -36 },
  { 3233, 24, 36, 22, 1, -36 },
  { 3341, 28, 37, 31, 3, -36 },
  { 3471, 30, 36, 31, 1, -36 },
  { 3606, 21, 36, 16, -2, -36 },
  { 3701, 22, 46, 13, -8, -36 },
  { 3828, 29, 36, 26, 1, -36 },
  { 3959, 18, 36, 22, 1, -36 },
  { 4040, 39, 36, 39, 1, -36 },
  { 4216, 32, 36, 33, 1, -36 },
  { 4360, 28, 37, 32, 3, -36 },
  { 4490, 26, 36, 26, 1, -36 },
  { 4607, 28, 45, 32, 3, -36 },
  { 4765, 25, 36, 27, 1, -36 },
  { 4878, 24, 37, 23, 0, -36 },
  { 4989, 23, 36, 23, 4, -36 },
  { 5093, 28, 37, 30, 3, -36 },
  { 5223, 26, 36, 26, 4, -36 },
  { 5340, 39, 36, 40, 5, -36 },
  { 5516, 32, 36, 25, -3, -36 },
  { 5660, 24, 36, 24, 4, -36 },
  { 5768, 27, 36, 23, -1, -36 },
  { 5890, 19, 44, 15, -1, -36 },
  { 5995, 10, 36, 18, 5, -36 },
  { 6040, 20, 44, 15, -4, -36 },
  { 6150, 23, 22, 25, 1, -36 },
  { 6214, 19, 4, 18, -5, 4 },
  { 6224, 9, 8, 14, 7, -38 },
  { 6233, 24, 28, 26, 2, -27 },
  { 6317, 24, 39, 26, 1, -38 },
  { 6434, 20, 28, 21, 2, -27 },
  { 6504, 26, 39, 26, 2, -38 },
  { 6631, 20, 28, 24, 2, -27 },
  { 6701, 27, 50, 15, -6, -38 },
  { 6870, 26, 39, 26, 0, -27 },
  { 6997, 23, 38, 26, 1, -38 },
  { 7107, 13, 37, 12, 1, -37 },
  { 7168, 20, 49, 12, -6, -37 },
  { 7291, 24, 38, 23, 1, -38 },
  { 7405, 13, 38, 12, 1, -38 },
  { 7467, 36, 27, 40, 1, -27 },
  { 7589, 23, 28, 26, 1, -28 },
  { 7670, 22, 27, 26, 2, -27 },
  { 7745, 27, 39, 26, -2, -27 },
  { 7877, 24, 39, 26, 2, -27 },
  { 7994, 19, 27, 18, 1, -27 },
  { 8059, 20, 28, 20, 0, -27 },
  { 8129, 15, 34, 16, 2, -33 },
  { 8193, 24, 28, 26, 2, -27 },
  { 8277, 21, 27, 22, 3, -27 },
  { 8348, 33, 27, 34, 3, -27 },
  { 8460, 26, 27, 22, -2, -27 },
  { 8548, 28, 39, 22, -4, -27 },
  { 8685, 21, 27, 20, -1, -27 },
  { 8756, 19, 44, 17, 1, -36 },
  { 8861, 5, 50, 24, 10, -38 },
  { 8893, 19, 44, 17, -2, -36 },
  { 8998, 22, 7, 26, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC50PT7B_H_
