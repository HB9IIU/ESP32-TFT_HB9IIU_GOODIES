#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x37, 0x6F, 0xA0, 0x69, 0xBC, 0x4D, 0xBE, 0x75,
  0x80, 0x66, 0x4B, 0xF0, 0xC0, 0x6A, 0x49, 0x00, 0x24, 0x95, 0x80, 0xDD,
  0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xDE, 0x76, 0x80,
  0x64, 0xAE, 0x65, 0x1E, 0x2D, 0xF2, 0x69, 0x9E, 0x74, 0xEA, 0x60, 0x72,
  0x24, 0xC0, 0x6D, 0xDE, 0x77, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xFC,
  0xC7, 0x00, 0x65, 0x28, 0x3B, 0xF7, 0xF8, 0x38, 0x2D, 0xFA, 0x75, 0x69,
  0xE0, 0x74, 0x88, 0x60, 0x75, 0x59, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68,
  0x80, 0x74, 0xB9, 0x70, 0x55, 0x79, 0x90, 0x69, 0x4C, 0x24, 0xA5, 0x80,
  0x56, 0x4A, 0xA0, 0x49, 0x4E, 0x4D, 0x25, 0xAA, 0xA8, 0x4A, 0x9D, 0x69,
  0x00, 0x75, 0x99, 0x60, 0x75, 0x68, 0x80, 0x75, 0x99, 0x62, 0x65, 0x6A,
  0xA0, 0x69, 0x1E, 0xF2, 0x48, 0x55, 0x99, 0x60, 0xB7, 0x48, 0xAF, 0x7D,
  0x6A, 0x00, 0x56, 0x46, 0xA0, 0xBA, 0x48, 0x72, 0x44, 0xE0, 0x6A, 0x49,
  0x00, 0xF8, 0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80, 0x7A, 0xAE, 0x4D, 0xDE,
  0x72, 0x60, 0x17, 0xAA, 0xE0, 0x77, 0x70, 0x36, 0x24, 0x44, 0x80, 0x7A,
  0xAE, 0x2C, 0x4D, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x47, 0xCC, 0xA0,
  0x5A, 0x80, 0x7B, 0x6B, 0x50, 0x6E, 0xD0, 0x76, 0xF0, 0x6E, 0xF9, 0x00,
  0x7A, 0xAE, 0x22, 0x6A, 0x40, 0x71, 0x60, 0x76, 0xC0, 0x5A, 0xAE, 0xB7,
  0x20, 0xAD, 0x75, 0x20, 0xA9, 0x50, 0x55, 0x62, 0x4C, 0x69, 0x60, 0x29,
  0x49, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 1, -5 },
  { 17, 3, 6, 2, 0, -5 },
  { 20, 3, 6, 2, -1, -5 },
  { 23, 3, 3, 3, 1, -5 },
  { 25, 3, 3, 4, 0, -4 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 2, 5, 3, 1, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 4, 5, 3, 0, -5 },
  { 47, 4, 5, 3, 0, -5 },
  { 50, 3, 5, 3, 0, -5 },
  { 52, 3, 5, 3, 0, -5 },
  { 54, 2, 4, 2, 0, -4 },
  { 55, 2, 5, 2, 0, -4 },
  { 57, 3, 3, 4, 0, -4 },
  { 59, 3, 2, 4, 0, -3 },
  { 60, 3, 3, 4, 0, -4 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 5, 6, 5, 0, -5 },
  { 68, 3, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 3, 0, -5 },
  { 82, 4, 5, 3, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 3, 5, 2, 0, -5 },
  { 93, 3, 6, 2, -1, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 6, 5, 5, 0, -5 },
  { 105, 5, 5, 5, 0, -5 },
  { 109, 4, 5, 5, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 6, 5, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 3, 5, 3, 1, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 5, 5, 6, 1, -5 },
  { 134, 4, 5, 3, 0, -5 },
  { 137, 3, 5, 3, 1, -5 },
  { 139, 4, 5, 3, 0, -5 },
  { 142, 3, 6, 2, 0, -5 },
  { 145, 1, 5, 3, 1, -5 },
  { 146, 2, 6, 2, 0, -5 },
  { 148, 3, 3, 4, 0, -5 },
  { 150, 3, 1, 3, -1, 0 },
  { 151, 1, 1, 2, 1, -5 },
  { 152, 4, 4, 4, 0, -4 },
  { 154, 3, 5, 4, 0, -5 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 4, 7, 2, -1, -5 },
  { 167, 4, 6, 4, 0, -4 },
  { 170, 3, 5, 4, 0, -5 },
  { 172, 2, 5, 2, 0, -5 },
  { 174, 3, 7, 2, -1, -5 },
  { 177, 4, 5, 3, 0, -5 },
  { 180, 2, 5, 2, 0, -5 },
  { 182, 5, 4, 6, 0, -4 },
  { 185, 3, 4, 4, 0, -4 },
  { 187, 3, 4, 4, 0, -4 },
  { 189, 3, 6, 4, 0, -4 },
  { 192, 4, 6, 4, 0, -4 },
  { 195, 3, 4, 3, 0, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 2, 5, 2, 0, -5 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 5, 4, 5, 0, -4 },
  { 208, 3, 4, 3, 0, -4 },
  { 210, 4, 6, 3, -1, -4 },
  { 213, 3, 4, 3, 0, -4 },
  { 215, 3, 6, 2, 0, -5 },
  { 218, 1, 7, 3, 1, -5 },
  { 219, 2, 6, 2, 0, -5 },
  { 221, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC7PT7B_H_
