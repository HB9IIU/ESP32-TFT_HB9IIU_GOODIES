#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x3E,
  0x1F, 0xBF, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F,
  0x8F, 0x07, 0x87, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x77, 0xE0, 0x3F, 0x3C,
  0x30, 0x1F, 0x8E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x7C,
  0x38, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xF9, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0x7F, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x71, 0xF8, 0x00, 0x1C, 0x7E, 0x00,
  0x0E, 0x1F, 0x80, 0x03, 0x87, 0xE0, 0x00, 0xE1, 0xF0, 0x80, 0x38, 0xFC,
  0x38, 0x0E, 0x7F, 0x0F, 0xE7, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x7F, 0x80, 0x03,
  0xE0, 0x3F, 0xF8, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0x1F, 0x01, 0xF3, 0xE0,
  0x03, 0xC0, 0x7C, 0x3E, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0xF8, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x83, 0xC0, 0x0F, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x87, 0x80, 0x07, 0x81, 0xF1,
  0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x3F, 0x1E, 0x0F, 0x8F, 0x1F, 0xF3, 0xC1,
  0xE3, 0xE7, 0xFF, 0x78, 0x7C, 0x78, 0xFF, 0xFF, 0x9F, 0x1F, 0x3E, 0x3F,
  0xFF, 0xE7, 0xCF, 0x87, 0xDF, 0xF8, 0xF1, 0xF0, 0x79, 0xFE, 0x3E, 0x7C,
  0x0F, 0x0F, 0x0F, 0x8F, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x7C,
  0x3C, 0x0F, 0x80, 0x1F, 0x0F, 0x81, 0xF0, 0x03, 0xC1, 0xF0, 0x3E, 0x00,
  0xF8, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x3E,
  0x01, 0xF0, 0x1E, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x78,
  0x3E, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x01, 0xFF, 0xF0, 0x1E, 0x00,
  0x1F, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xC3, 0xFB, 0xF0, 0x1F, 0x0F, 0xC7, 0xF0,
  0x7E, 0x3F, 0x07, 0xE0, 0xF8, 0x7C, 0x07, 0xE3, 0xF1, 0xF8, 0x0F, 0xC7,
  0xC3, 0xE0, 0x0F, 0xDF, 0x8F, 0xC0, 0x1F, 0xFE, 0x1F, 0x80, 0x1F, 0xF8,
  0x3F, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xFE, 0x03, 0xFC, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0xE1, 0xFC, 0x07,
  0xFF, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x04, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3F, 0x1E, 0x00, 0x7F,
  0xBC, 0x01, 0xFF, 0xF9, 0xFC, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x83, 0xC0, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0xCF,
  0x00, 0x3F, 0x1E, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0xE0, 0x7C,
  0x00, 0x80, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xF3, 0xF8, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0x3F, 0x3F, 0x1F,
  0x0E, 0x0F, 0x82, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xF8, 0x07, 0xE0, 0x06, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x38, 0x03, 0xF0, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x10, 0x00, 0x1F, 0x83, 0x80, 0x0F, 0xF0, 0x7E, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF8,
  0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1E, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x80, 0x01, 0xF8, 0x30, 0x01, 0xFE, 0x0F, 0x81, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x20, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x3F, 0xF0, 0x0F, 0xDF,
  0xFE, 0x03, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFE, 0x1F,
  0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x3F, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F,
  0x00, 0xFF, 0x1F, 0x83, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBE, 0x0F,
  0xFF, 0x7E, 0x07, 0xFC, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xE0,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xE0, 0x7F,
  0x18, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x7C, 0x01,
  0xFF, 0xE1, 0xF0, 0xF0, 0x0F, 0xFF, 0x81, 0xE3, 0xE0, 0x3F, 0xFF, 0x03,
  0xC7, 0x80, 0xFC, 0x3E, 0x07, 0x9F, 0x03, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F,
  0x80, 0xF0, 0x1E, 0x78, 0x1E, 0x01, 0xE0, 0x3D, 0xF0, 0x7C, 0x07, 0xC0,
  0xFB, 0xE0, 0xF0, 0x0F, 0x81, 0xE7, 0x81, 0xE0, 0x1E, 0x03, 0xCF, 0x07,
  0xC0, 0x3C, 0x07, 0x9E, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x1E, 0x01, 0xF0,
  0x3C, 0xF8, 0x3C, 0x03, 0xC0, 0x79, 0xF0, 0x78, 0x0F, 0x81, 0xF3, 0xE0,
  0xF0, 0x1F, 0x03, 0xC7, 0xC1, 0xE0, 0x7E, 0x0F, 0x8F, 0x83, 0xE1, 0xFC,
  0x3E, 0x1F, 0x07, 0xFF, 0xBF, 0xF8, 0x3E, 0x07, 0xFE, 0x7F, 0xE0, 0x3C,
  0x07, 0xF8, 0x7F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x18, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0xFC, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x7E,
  0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x83, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xF0, 0x07, 0xF8, 0x01,
  0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x7F, 0xE7, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7F, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0xFF, 0x00,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0x00,
  0x7F, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x23, 0xF0, 0x07, 0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0x1F, 0x80, 0x1F,
  0xFE, 0x3F, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x00,
  0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x08, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x03, 0xE3,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x1F, 0x7E, 0x01,
  0xF9, 0xE0, 0x07, 0xCF, 0xC0, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x3C, 0x3F, 0x00, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x7C, 0x3F, 0x00,
  0x7C, 0x3E, 0x0F, 0x07, 0xE0, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x03, 0xE0,
  0x78, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE3,
  0xC0, 0xFC, 0x03, 0xF0, 0x3C, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xDE, 0x03,
  0xE0, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0x80,
  0x3E, 0x03, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x7C, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x7C,
  0x03, 0xFF, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x00,
  0x7E, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x7D, 0xF8, 0x01, 0xF0, 0x0F, 0x9F,
  0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x3E, 0x7E, 0x01, 0xF8, 0x07,
  0xC7, 0xC0, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x07, 0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xE0, 0x1F,
  0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x01, 0xF9, 0xF0,
  0x0F, 0x80, 0x1F, 0x7E, 0x03, 0xF0, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x7D,
  0xF0, 0x0F, 0x80, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x3E, 0x00,
  0x1F, 0xF8, 0x0F, 0xC0, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x3E,
  0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFE, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x07,
  0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7C,
  0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x1F,
  0x00, 0xFE, 0x00, 0x60, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x3F, 0x83, 0xC0,
  0x0F, 0xE0, 0x7F, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xEF, 0xC0, 0x07,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x3E,
  0x01, 0xF7, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F,
  0x9F, 0x01, 0xF8, 0x1F, 0x01, 0xF3, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x7C,
  0x0F, 0xC0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0x7E,
  0x01, 0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x0F,
  0x9F, 0x80, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xC0, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE7, 0xC0,
  0x03, 0xF1, 0xF0, 0x01, 0xFC, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC7,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3F, 0x1F,
  0x87, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0x80, 0x00, 0x3F, 0x83, 0xC0,
  0x3F, 0xF1, 0xF0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xDF, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xC3, 0xF0,
  0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xFE, 0x07, 0xFF, 0xEF, 0x80,
  0xFF, 0xF3, 0xC0, 0x3F, 0xF8, 0xF0, 0x03, 0xF8, 0x7C, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0xF8, 0xFF, 0x80, 0x3E,
  0x7F, 0xF0, 0x1F, 0xBF, 0xFE, 0x07, 0xDF, 0xFF, 0x81, 0xFF, 0x07, 0xF0,
  0x7F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x81,
  0xFC, 0x1F, 0xF0, 0xFE, 0x07, 0xBF, 0xFF, 0x83, 0xE7, 0xFF, 0xC0, 0xF9,
  0xFF, 0xC0, 0x3C, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xC0, 0x40, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x81, 0xFE, 0x1E, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x7C, 0x00, 0x7F,
  0xE3, 0xE0, 0x07, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x80, 0x3F, 0x8F, 0xFC, 0x01, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0x9E, 0x00,
  0x3F, 0xF8, 0xF0, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0x8F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00,
  0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x20, 0xFE,
  0x03, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x37, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0xF0, 0x03, 0xFF, 0x1F, 0x00, 0x7F, 0xF9, 0xF0,
  0x0F, 0xFF, 0xDF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x7B, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xF7, 0xC0, 0x0F, 0xFE, 0x7C, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0x40,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x03, 0xF0, 0x0E, 0x00,
  0x7E, 0x00, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0xF8, 0xFF, 0xC0, 0x3E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE,
  0x07, 0xDF, 0xFF, 0x81, 0xFF, 0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x1F, 0xC0,
  0x3F, 0x0F, 0xE0, 0x0F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0x00, 0x0F,
  0xE3, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x03, 0xF8, 0x03,
  0xC3, 0xFE, 0x0F, 0xFC, 0x03, 0xCF, 0xFF, 0x1F, 0xFE, 0x07, 0xDF, 0xFF,
  0x3F, 0xFF, 0x07, 0xDF, 0x7F, 0xFE, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE1, 0xFC, 0x00, 0xF0, 0xFF, 0xC0, 0x3C, 0xFF, 0xF8, 0x1F, 0x7F,
  0xFE, 0x07, 0xDF, 0xFF, 0x81, 0xFF, 0x07, 0xF0, 0x7F, 0x80, 0xFC, 0x3F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7C, 0x3F, 0x80, 0x03, 0xC3, 0xFE, 0x00, 0x1E, 0x3F, 0xF8, 0x01, 0xF3,
  0xFF, 0xE0, 0x0F, 0xBE, 0xFF, 0x00, 0x7F, 0xC1, 0xF8, 0x03, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xC3, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0x7F, 0xFC, 0x01, 0xF9, 0xFF, 0x80, 0x0F, 0x87, 0xF8, 0x00,
  0x7C, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x83, 0xC0, 0x3F, 0xF1, 0xF0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xDF,
  0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0,
  0x3F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xBE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xC0, 0x3F, 0xF9, 0xF0, 0x03, 0xF8, 0x7C,
  0x00, 0x10, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x1E, 0x1F,
  0xC0, 0xF3, 0xFC, 0x0F, 0x9F, 0xE0, 0x7D, 0xFF, 0x03, 0xFF, 0x08, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xF1, 0xF8, 0x3F, 0x00, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x80, 0x0F, 0xC3, 0xC0,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x20, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x04, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x07, 0xF8, 0x1F, 0x87, 0xBE, 0x07, 0xFF, 0xEF, 0x81, 0xFF, 0xF3,
  0xC0, 0x3F, 0xF8, 0xF0, 0x07, 0xF8, 0x7C, 0x00, 0x10, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3C,
  0xFC, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x0F, 0xBF, 0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF0, 0x07, 0xCF,
  0xC0, 0x7F, 0x80, 0x7E, 0x7E, 0x03, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0xE0,
  0x3F, 0x1F, 0x81, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0x78, 0x0F, 0x87, 0xE0,
  0xFB, 0xC0, 0xFC, 0x1F, 0x07, 0x9E, 0x07, 0xC0, 0xF8, 0x7C, 0xF0, 0x7E,
  0x07, 0xC3, 0xE7, 0x83, 0xE0, 0x3E, 0x1E, 0x3C, 0x3F, 0x01, 0xF1, 0xF1,
  0xF1, 0xF0, 0x0F, 0x8F, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x7C, 0xFC, 0x03,
  0xE7, 0x83, 0xE7, 0xC0, 0x1F, 0x7C, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0xFB,
  0xE0, 0x07, 0xDE, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x3D, 0xF0, 0x01, 0xEF,
  0x01, 0xEF, 0x80, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xCF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x43, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x80, 0x07, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 17, 14, 21, 6, -39 },
  { 101, 31, 39, 31, 1, -39 },
  { 253, 26, 45, 27, 1, -42 },
  { 400, 35, 41, 41, 4, -40 },
  { 580, 31, 41, 33, 1, -40 },
  { 739, 8, 14, 12, 6, -39 },
  { 753, 18, 48, 16, 2, -39 },
  { 861, 18, 49, 16, -4, -40 },
  { 972, 23, 24, 27, 5, -42 },
  { 1041, 24, 27, 29, 3, -33 },
  { 1122, 12, 13, 14, -3, -6 },
  { 1142, 14, 5, 16, 1, -17 },
  { 1151, 7, 8, 14, 1, -7 },
  { 1158, 27, 39, 20, -3, -39 },
  { 1290, 25, 41, 27, 2, -40 },
  { 1419, 17, 39, 27, 6, -39 },
  { 1502, 28, 40, 27, -1, -40 },
  { 1642, 27, 41, 27, 0, -40 },
  { 1781, 27, 39, 27, 0, -39 },
  { 1913, 26, 40, 27, 1, -39 },
  { 2043, 26, 41, 27, 2, -40 },
  { 2177, 26, 39, 27, 3, -39 },
  { 2304, 26, 41, 27, 1, -40 },
  { 2438, 24, 41, 27, 2, -40 },
  { 2561, 12, 31, 14, 1, -30 },
  { 2608, 16, 37, 14, -3, -30 },
  { 2682, 24, 27, 29, 3, -33 },
  { 2763, 24, 15, 29, 3, -27 },
  { 2808, 24, 27, 29, 3, -33 },
  { 2889, 20, 41, 21, 3, -40 },
  { 2992, 39, 44, 42, 2, -39 },
  { 3207, 29, 39, 29, -3, -39 },
  { 3349, 29, 39, 30, 1, -39 },
  { 3491, 29, 41, 29, 3, -40 },
  { 3640, 31, 39, 33, 1, -39 },
  { 3792, 27, 39, 26, 1, -39 },
  { 3924, 27, 39, 24, 1, -39 },
  { 4056, 31, 41, 34, 3, -40 },
  { 4215, 34, 39, 34, 1, -39 },
  { 4381, 23, 39, 17, -2, -39 },
  { 4494, 23, 50, 14, -8, -39 },
  { 4638, 32, 39, 29, 1, -39 },
  { 4794, 20, 39, 24, 1, -39 },
  { 4892, 43, 39, 43, 1, -39 },
  { 5102, 35, 39, 36, 1, -39 },
  { 5273, 31, 41, 35, 3, -40 },
  { 5432, 28, 39, 29, 1, -39 },
  { 5569, 31, 49, 35, 3, -40 },
  { 5759, 28, 39, 29, 1, -39 },
  { 5896, 27, 41, 26, 0, -40 },
  { 6035, 24, 39, 25, 5, -39 },
  { 6152, 31, 40, 34, 3, -39 },
  { 6307, 28, 39, 28, 5, -39 },
  { 6444, 43, 39, 44, 5, -39 },
  { 6654, 34, 39, 27, -3, -39 },
  { 6820, 26, 39, 26, 5, -39 },
  { 6947, 29, 39, 26, -1, -39 },
  { 7089, 21, 48, 16, -1, -39 },
  { 7215, 10, 39, 20, 6, -39 },
  { 7264, 21, 48, 16, -4, -39 },
  { 7390, 26, 23, 28, 1, -39 },
  { 7465, 21, 3, 20, -5, 5 },
  { 7473, 9, 9, 15, 8, -42 },
  { 7484, 26, 31, 29, 2, -30 },
  { 7585, 26, 43, 29, 1, -42 },
  { 7725, 22, 31, 23, 2, -30 },
  { 7811, 29, 43, 29, 2, -42 },
  { 7967, 23, 31, 26, 2, -30 },
  { 8057, 29, 55, 17, -6, -42 },
  { 8257, 28, 43, 29, 0, -30 },
  { 8408, 26, 42, 29, 1, -42 },
  { 8545, 14, 41, 13, 1, -41 },
  { 8617, 22, 54, 14, -7, -41 },
  { 8766, 27, 42, 26, 1, -42 },
  { 8908, 14, 42, 13, 1, -42 },
  { 8982, 40, 30, 44, 1, -30 },
  { 9132, 26, 30, 29, 1, -30 },
  { 9230, 24, 31, 28, 2, -30 },
  { 9323, 29, 43, 29, -2, -30 },
  { 9479, 26, 43, 29, 2, -30 },
  { 9619, 21, 30, 20, 1, -30 },
  { 9698, 22, 31, 22, 0, -30 },
  { 9784, 16, 37, 17, 3, -36 },
  { 9858, 26, 31, 29, 2, -30 },
  { 9959, 24, 30, 24, 3, -30 },
  { 10049, 37, 30, 37, 3, -30 },
  { 10188, 29, 30, 25, -2, -30 },
  { 10297, 32, 43, 24, -5, -30 },
  { 10469, 23, 30, 22, -1, -30 },
  { 10556, 21, 48, 19, 1, -39 },
  { 10682, 5, 55, 27, 11, -42 },
  { 10717, 21, 48, 19, -3, -39 },
  { 10843, 24, 7, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC55PT7B_H_
