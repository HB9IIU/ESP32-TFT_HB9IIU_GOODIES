#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x20, 0x00, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3,
  0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0,
  0xE3, 0xC3, 0xC7, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00,
  0x0F, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xCE, 0x18, 0x1F, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x7C, 0x70, 0x00, 0xF8,
  0xC0, 0x01, 0xF3, 0x80, 0x03, 0xF7, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x06, 0xFC, 0x00, 0x0C, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x71, 0xF0,
  0x00, 0xE3, 0xE0, 0x01, 0x87, 0x84, 0x07, 0x1F, 0x0C, 0x0E, 0x7E, 0x1F,
  0x9F, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0xFF, 0xE0, 0x0F, 0x01, 0xE3, 0xC0, 0x3C,
  0x07, 0x87, 0x80, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x07, 0x80,
  0x78, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x01, 0xC0, 0xF0, 0xF0, 0x07,
  0x81, 0xE1, 0xE0, 0x0F, 0x03, 0xC7, 0x80, 0x1E, 0x0F, 0x1E, 0x00, 0x3C,
  0x1E, 0x3C, 0x7C, 0x78, 0x3C, 0xF1, 0xFE, 0xF0, 0xF3, 0xC7, 0xFD, 0xE3,
  0xE7, 0x9F, 0x7D, 0xFF, 0x9E, 0x7C, 0x7B, 0xFE, 0x7C, 0xF0, 0xF3, 0xF8,
  0xF3, 0xC1, 0xE3, 0xC3, 0xC7, 0x83, 0xC0, 0x0F, 0x8F, 0x07, 0x80, 0x1E,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x3C, 0x03, 0xC1,
  0xE0, 0xF0, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0x1E, 0x1E, 0x03, 0xC0, 0x3C, 0x78, 0x0F, 0x00, 0x7F,
  0xF0, 0x3C, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8,
  0x0F, 0x8F, 0xFF, 0x01, 0xE3, 0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x0F, 0x1F,
  0x03, 0xE3, 0xE3, 0xE0, 0x7E, 0x78, 0xF8, 0x07, 0xDF, 0x1F, 0x00, 0x7F,
  0xC3, 0xE0, 0x0F, 0xF0, 0x7C, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x07, 0xF0, 0x3F, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x3E,
  0x07, 0xFF, 0xC7, 0xE0, 0x3F, 0xE0, 0x7E, 0x00, 0x3E, 0x79, 0xF3, 0xE7,
  0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0xC0, 0xE0, 0x3E,
  0x3C, 0x07, 0xF7, 0x80, 0xFF, 0xE1, 0xE7, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x01, 0xF1, 0xE0, 0x7C,
  0x3C, 0x07, 0x87, 0xC0, 0x60, 0x78, 0x04, 0x0F, 0x00, 0x01, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF,
  0xFF, 0xE2, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x03, 0xF0, 0x7C, 0x3F, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x03, 0xCF, 0xC0, 0x1E, 0x7C, 0x00,
  0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0xC1,
  0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7,
  0xFF, 0xBF, 0x3E, 0xF8, 0xF9, 0x83, 0xC4, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xE0, 0x3F, 0x00, 0xC0, 0x1F, 0x00, 0x80,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F,
  0xE0, 0x38, 0x0F, 0xC0, 0x40, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x10, 0x00, 0x7C,
  0x38, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xE0, 0x03,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x08, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x08, 0x00, 0xFC, 0x1C, 0x03, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0x98, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x03, 0xE7, 0xF8,
  0x0F, 0x7F, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0x87, 0xF0, 0x3F, 0x1F,
  0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xFD,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x3F,
  0xDF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFB,
  0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x01, 0xF8, 0x7C, 0x0F,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x0F, 0xE3, 0xC0,
  0x04, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x08, 0x07, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x02, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xF7, 0xF9, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xC0, 0x3F, 0xC0, 0xE1, 0xE0, 0x3F, 0xFC, 0x3C, 0x78, 0x1F, 0xFE,
  0x0F, 0x3C, 0x0F, 0x87, 0x83, 0xCF, 0x07, 0xC1, 0xE0, 0xF3, 0x81, 0xE0,
  0x70, 0x3D, 0xE0, 0xF0, 0x3C, 0x0F, 0x78, 0x78, 0x0F, 0x03, 0x9C, 0x1E,
  0x03, 0xC1, 0xEF, 0x07, 0x80, 0xE0, 0x7B, 0xC1, 0xC0, 0x78, 0x1E, 0xF0,
  0xF0, 0x1E, 0x07, 0x3C, 0x3C, 0x0F, 0x83, 0xCF, 0x0F, 0x03, 0xC0, 0xF3,
  0xC3, 0xC1, 0xF0, 0x78, 0xF0, 0xF8, 0x7C, 0x3E, 0x3C, 0x1F, 0x7F, 0xDF,
  0x0F, 0x07, 0xFC, 0xFF, 0x83, 0xC0, 0xFE, 0x3F, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x80, 0x00, 0xFE,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x07,
  0x80, 0x3E, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3E, 0x03, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x78, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x30, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x03, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x07, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF8, 0x3E,
  0x00, 0xFE, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0x01,
  0xFC, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x9F, 0x00, 0x7F, 0xE3, 0xE0, 0x0F, 0xFC, 0x7C, 0x03, 0xFF, 0x8F, 0x80,
  0x7F, 0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xC1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xBC, 0x07, 0xDE, 0x00, 0x7D,
  0xE0, 0x3E, 0xF0, 0x03, 0xDF, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0x3C,
  0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xE0,
  0x3E, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x07,
  0xC7, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x07, 0xC7, 0x83, 0xE3, 0xE0, 0x3E,
  0x3E, 0x1E, 0x1F, 0x01, 0xF0, 0xF1, 0xF0, 0xF8, 0x0F, 0x07, 0x8F, 0x07,
  0xC0, 0x78, 0x3C, 0xF8, 0x3C, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0x3E, 0x0F,
  0x7C, 0x1F, 0x01, 0xE0, 0x7B, 0xC0, 0xF8, 0x0F, 0x03, 0xFE, 0x07, 0xC0,
  0xF8, 0x1F, 0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xF0,
  0x1F, 0x01, 0xE0, 0x3F, 0x80, 0xF8, 0x0F, 0x01, 0xF8, 0x07, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xF0, 0x00, 0xF0, 0x1F, 0xE0, 0x03,
  0xE0, 0x3F, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0x1E,
  0x01, 0xFF, 0x00, 0x3C, 0x07, 0xDE, 0x00, 0xF8, 0x0F, 0xBE, 0x01, 0xF0,
  0x1E, 0x7C, 0x03, 0xE0, 0x3C, 0x78, 0x07, 0x80, 0x78, 0xF8, 0x1F, 0x01,
  0xF1, 0xF0, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x07, 0xC3, 0xC0, 0xF8, 0x0F,
  0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x0F, 0x80, 0xF8,
  0x1F, 0x1F, 0x01, 0xF0, 0x3E, 0x3C, 0x03, 0xC0, 0x3C, 0x78, 0x0F, 0x80,
  0x79, 0xF0, 0x1F, 0x00, 0xFB, 0xE0, 0x3E, 0x01, 0xF7, 0xC0, 0x78, 0x01,
  0xEF, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xC0, 0x07,
  0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFE, 0x0F, 0x83, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x7E, 0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7E, 0x03, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x18, 0x00, 0xFC,
  0x3C, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3,
  0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xC0, 0x0F, 0xBC, 0x00, 0x7E, 0x00, 0x7D, 0xE0, 0x07, 0xF0,
  0x03, 0xEF, 0x00, 0x3F, 0x80, 0x3E, 0x78, 0x01, 0xFC, 0x01, 0xF3, 0xC0,
  0x1F, 0xE0, 0x1F, 0x1E, 0x00, 0xFF, 0x00, 0xF8, 0xF0, 0x0F, 0x78, 0x07,
  0x87, 0x80, 0x7B, 0xC0, 0x7C, 0x3C, 0x07, 0xDE, 0x03, 0xE1, 0xE0, 0x3C,
  0xF0, 0x3E, 0x0F, 0x01, 0xE7, 0x81, 0xF0, 0x78, 0x1E, 0x3C, 0x1F, 0x03,
  0xC0, 0xF1, 0xE0, 0xF8, 0x1E, 0x0F, 0x8F, 0x07, 0x80, 0xF0, 0x78, 0x78,
  0x7C, 0x07, 0x87, 0xC3, 0xC3, 0xE0, 0x3C, 0x3C, 0x1E, 0x3E, 0x01, 0xE1,
  0xE0, 0xF1, 0xF0, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x3C, 0xF8,
  0x03, 0xCF, 0x81, 0xE7, 0x80, 0x1E, 0x78, 0x0F, 0x7C, 0x00, 0xF7, 0xC0,
  0x7B, 0xE0, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x0F, 0x01,
  0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x7C,
  0x00, 0xF1, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x40, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xE0,
  0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xFC, 0x7C, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x00, 0xFE, 0x1E, 0x07, 0xFE, 0x78, 0x1F, 0xFE, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFC, 0x3F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x0F,
  0x80, 0xFC, 0x1F, 0x87, 0xF8, 0x1F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F,
  0xE7, 0x80, 0x3F, 0x8F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F,
  0x80, 0x3E, 0xFF, 0xC0, 0x7B, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFC, 0x3F,
  0x07, 0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xF8, 0x3F, 0x83,
  0xF0, 0xFF, 0xFF, 0xC1, 0xEF, 0xFF, 0x03, 0xCF, 0xFC, 0x07, 0x8F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC,
  0x08, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x0C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x8F, 0x80, 0x7F, 0xE7, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7F,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0xFB, 0xC0, 0x3F, 0xF9,
  0xE0, 0x0F, 0xF9, 0xE0, 0x03, 0xF8, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x1F, 0x3F,
  0x01, 0xE3, 0xE0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x1F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x30, 0x7F, 0xBF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x87, 0x80, 0x7F, 0xE7, 0x80, 0x7F, 0xFB, 0xC0, 0x7F, 0xFD, 0xE0,
  0x3F, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x7F, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFB, 0xE0, 0x0F, 0xF9, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0xC0, 0x1F, 0x80, 0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x7F, 0x01, 0xF7, 0xFE, 0x07, 0xBF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0x07, 0xC3, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F,
  0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01,
  0xF0, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F,
  0x8F, 0xC0, 0x1E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xDF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x07, 0x87, 0xE0, 0x3F, 0x80, 0xF3, 0xFE, 0x1F, 0xF8,
  0x1E, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF, 0x0F, 0xF8,
  0x7E, 0x1F, 0xC0, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0xF8, 0x7C, 0x03,
  0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0x78, 0x7C,
  0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x80, 0x7C,
  0x7C, 0x01, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x01, 0xF1, 0xF0, 0x07,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF0,
  0x07, 0xC0, 0x3E, 0x3E, 0x00, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0xF0,
  0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x87, 0xF0,
  0x1E, 0x7F, 0xE0, 0x7B, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF0, 0x7C, 0x3F,
  0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x80,
  0xF8, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0,
  0x0F, 0xCF, 0x80, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x3C, 0xFF,
  0xC0, 0x0F, 0x7F, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0x80, 0x7F,
  0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xC0,
  0x1F, 0x7F, 0xE0, 0x07, 0xCF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1E, 0x07, 0xFE,
  0x78, 0x1F, 0xFE, 0xF0, 0x7F, 0xFD, 0xE0, 0xFC, 0x3F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0,
  0x1F, 0x87, 0xC0, 0x7F, 0x0F, 0x80, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFB, 0xE0, 0x3F, 0xE7, 0x80, 0x3F, 0x9F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x87, 0xC1,
  0xE7, 0xF0, 0x7B, 0xFC, 0x3E, 0xFE, 0x0F, 0xFC, 0x83, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x0C, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0x80, 0x7E,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xFF, 0xBF,
  0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80,
  0x3C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0xC3, 0xF0, 0xFF, 0x0F, 0xFF,
  0xBC, 0x1F, 0xFD, 0xF0, 0x7F, 0xE7, 0x80, 0xFF, 0x1E, 0x00, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0xF8, 0x07,
  0x8F, 0x80, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00,
  0x7B, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0,
  0x0F, 0xC0, 0x3E, 0xF0, 0x1F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8,
  0x1D, 0xC0, 0xF8, 0xF8, 0x3D, 0xC0, 0xF8, 0xF8, 0x3D, 0xC0, 0xF0, 0xF8,
  0x79, 0xC1, 0xF0, 0xF8, 0x79, 0xC1, 0xE0, 0xF8, 0xF1, 0xC3, 0xE0, 0xF8,
  0xF1, 0xC3, 0xE0, 0xF8, 0xF1, 0xC7, 0xC0, 0xF9, 0xE1, 0xC7, 0xC0, 0xF9,
  0xE1, 0xC7, 0x80, 0xFB, 0xC1, 0xCF, 0x80, 0xF3, 0xC1, 0xCF, 0x00, 0xF3,
  0x81, 0xCF, 0x00, 0xF7, 0x81, 0xDF, 0x00, 0xF7, 0x81, 0xDE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x40, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -34 },
  { 54, 15, 12, 19, 5, -34 },
  { 77, 27, 34, 27, 1, -34 },
  { 192, 23, 39, 24, 1, -36 },
  { 305, 31, 35, 36, 3, -35 },
  { 441, 27, 35, 29, 1, -35 },
  { 560, 7, 12, 11, 5, -34 },
  { 571, 16, 42, 14, 1, -34 },
  { 655, 16, 43, 14, -4, -35 },
  { 741, 19, 21, 23, 5, -37 },
  { 791, 21, 23, 25, 3, -28 },
  { 852, 10, 12, 12, -2, -6 },
  { 867, 12, 4, 14, 1, -15 },
  { 873, 6, 7, 12, 1, -6 },
  { 879, 23, 34, 18, -2, -34 },
  { 977, 21, 35, 24, 2, -35 },
  { 1069, 14, 34, 24, 6, -34 },
  { 1129, 24, 35, 24, -1, -35 },
  { 1234, 23, 35, 24, 0, -35 },
  { 1335, 23, 34, 24, 0, -34 },
  { 1433, 23, 34, 24, 1, -34 },
  { 1531, 22, 35, 24, 2, -35 },
  { 1628, 22, 34, 24, 3, -34 },
  { 1722, 23, 35, 24, 1, -35 },
  { 1823, 22, 35, 24, 1, -35 },
  { 1920, 10, 27, 12, 1, -26 },
  { 1954, 13, 32, 12, -2, -26 },
  { 2006, 21, 23, 25, 3, -29 },
  { 2067, 21, 14, 25, 3, -24 },
  { 2104, 21, 23, 25, 3, -29 },
  { 2165, 17, 36, 19, 3, -35 },
  { 2242, 34, 38, 36, 2, -34 },
  { 2404, 25, 34, 25, -3, -34 },
  { 2511, 25, 34, 26, 1, -34 },
  { 2618, 25, 35, 25, 3, -35 },
  { 2728, 27, 34, 29, 1, -34 },
  { 2843, 23, 34, 23, 1, -34 },
  { 2941, 23, 34, 21, 1, -34 },
  { 3039, 27, 35, 30, 3, -35 },
  { 3158, 29, 34, 30, 1, -34 },
  { 3282, 20, 34, 15, -2, -34 },
  { 3367, 20, 43, 13, -7, -34 },
  { 3475, 28, 34, 25, 1, -34 },
  { 3594, 17, 34, 21, 1, -34 },
  { 3667, 37, 34, 38, 1, -34 },
  { 3825, 31, 34, 31, 1, -34 },
  { 3957, 27, 35, 31, 3, -35 },
  { 4076, 24, 34, 25, 1, -34 },
  { 4178, 27, 43, 31, 3, -35 },
  { 4324, 24, 34, 25, 1, -34 },
  { 4426, 23, 35, 22, 0, -35 },
  { 4527, 22, 34, 22, 4, -34 },
  { 4621, 27, 34, 29, 3, -34 },
  { 4736, 25, 34, 25, 4, -34 },
  { 4843, 37, 34, 38, 5, -34 },
  { 5001, 30, 34, 24, -3, -34 },
  { 5129, 23, 34, 23, 4, -34 },
  { 5227, 26, 34, 22, -1, -34 },
  { 5338, 19, 42, 14, -1, -34 },
  { 5438, 9, 34, 18, 5, -34 },
  { 5477, 18, 42, 14, -3, -34 },
  { 5572, 22, 20, 24, 1, -34 },
  { 5627, 18, 3, 18, -4, 4 },
  { 5634, 8, 8, 13, 7, -37 },
  { 5642, 23, 26, 25, 2, -26 },
  { 5717, 23, 36, 25, 1, -36 },
  { 5821, 19, 26, 20, 2, -26 },
  { 5883, 25, 36, 25, 2, -36 },
  { 5996, 20, 26, 23, 2, -26 },
  { 6061, 25, 49, 14, -5, -37 },
  { 6215, 25, 38, 25, 0, -26 },
  { 6334, 22, 36, 25, 1, -36 },
  { 6433, 12, 36, 12, 1, -36 },
  { 6487, 19, 48, 12, -6, -36 },
  { 6601, 23, 36, 22, 1, -36 },
  { 6705, 12, 36, 12, 1, -36 },
  { 6759, 35, 26, 38, 1, -26 },
  { 6873, 22, 26, 25, 1, -26 },
  { 6945, 21, 26, 25, 2, -26 },
  { 7014, 26, 37, 25, -2, -26 },
  { 7135, 23, 38, 25, 2, -26 },
  { 7245, 18, 26, 17, 1, -26 },
  { 7304, 19, 26, 19, 0, -26 },
  { 7366, 15, 32, 15, 2, -32 },
  { 7426, 22, 26, 25, 2, -26 },
  { 7498, 20, 26, 21, 3, -26 },
  { 7563, 32, 26, 33, 3, -26 },
  { 7667, 25, 26, 22, -2, -26 },
  { 7749, 27, 38, 21, -4, -26 },
  { 7878, 21, 26, 19, -1, -26 },
  { 7947, 18, 42, 17, 1, -34 },
  { 8042, 4, 48, 23, 10, -37 },
  { 8066, 18, 42, 17, -2, -34 },
  { 8161, 21, 6, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC48PT7B_H_
