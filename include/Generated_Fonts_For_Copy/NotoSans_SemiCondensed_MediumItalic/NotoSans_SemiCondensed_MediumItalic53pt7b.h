#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x3F, 0x1F,
  0x9F, 0x8F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF9, 0xF0,
  0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x03, 0xC7, 0x81, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF9, 0xC3, 0x01, 0xF0,
  0xE0, 0x80, 0xF8, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x3E, 0x38, 0x00, 0x1F,
  0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0xEE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x0E, 0x7E,
  0x00, 0x0E, 0x3F, 0x00, 0x07, 0x0F, 0x80, 0x03, 0x87, 0xC0, 0x01, 0xC7,
  0xE0, 0x01, 0xC3, 0xE1, 0x80, 0xE3, 0xF0, 0xF8, 0x73, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0xFF,
  0xC0, 0x03, 0xC0, 0x3F, 0xF8, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x1E, 0x01,
  0xF1, 0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x0F, 0x83, 0xC0, 0x3C,
  0x01, 0xE0, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE0,
  0x78, 0x01, 0xE0, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x87, 0xC0, 0x07, 0x81,
  0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x3E, 0x07, 0x8F, 0x80, 0x07,
  0xC1, 0xF1, 0xE1, 0xF8, 0xF8, 0x3C, 0x78, 0xFF, 0x9F, 0x0F, 0x9F, 0x3F,
  0xF9, 0xE1, 0xE3, 0xCF, 0xFF, 0x3F, 0xFC, 0xF1, 0xF1, 0xF7, 0xFF, 0x3E,
  0x7C, 0x3E, 0x7F, 0xC7, 0x8F, 0x07, 0xC7, 0xF1, 0xE3, 0xE0, 0xF8, 0x00,
  0x7C, 0x7C, 0x1F, 0x00, 0x0F, 0x0F, 0x03, 0xE0, 0x03, 0xC1, 0xE0, 0x78,
  0x00, 0xF8, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x7C, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0x3C, 0x07, 0x81, 0xE0, 0x0F, 0x00,
  0xF0, 0x7C, 0x03, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x03, 0xE3, 0xE0, 0x1F,
  0x00, 0x7E, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0xC0,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE7,
  0xF0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F,
  0x0F, 0xFF, 0x80, 0xF8, 0x7F, 0x3E, 0x03, 0xE3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7C, 0x7E, 0x07, 0xE3, 0xF1, 0xF0, 0x0F, 0xCF, 0x8F, 0xC0,
  0x3F, 0x7C, 0x3F, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0xFF, 0x83, 0xE0, 0x03,
  0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFF,
  0x01, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0,
  0x1F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x40, 0x3C,
  0x01, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0xCE, 0x00, 0xFF, 0xF8, 0x7C,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFC, 0x7C, 0x0F,
  0xF0, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0x80, 0x3F, 0x1F, 0x01, 0xFC, 0x3C,
  0x03, 0xE0, 0xF8, 0x07, 0x03, 0xE0, 0x08, 0x0F, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0x83, 0xE0, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x7F, 0x7C, 0xFF, 0x3E, 0x3E, 0x3F, 0x0E, 0x1F, 0x06, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC,
  0x01, 0xE0, 0x1F, 0x80, 0x18, 0x01, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x38, 0x07, 0xE0,
  0x08, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0xC0, 0x03, 0xF8, 0x3E, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE1, 0x00, 0x07, 0xF0, 0xC0, 0x07, 0xF0, 0x78, 0x0F,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x30, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x7F, 0xC0, 0x3E, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x1F, 0xF8, 0xFE, 0x0F, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0,
  0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F,
  0x81, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xF0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x1F,
  0x80, 0x7F, 0x1F, 0x80, 0xFF, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xBE, 0x07, 0xFF, 0x7E, 0x01, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xC0,
  0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x80, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF0, 0xFE, 0x30, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0xFF,
  0xE0, 0xF0, 0xF0, 0x1F, 0xFF, 0x07, 0x8F, 0x01, 0xFF, 0xF8, 0x3C, 0x78,
  0x1F, 0x87, 0xC1, 0xE7, 0x81, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x01, 0xE0,
  0x79, 0xE0, 0xF8, 0x0F, 0x03, 0xDE, 0x07, 0x80, 0xF8, 0x1E, 0xF0, 0x7C,
  0x07, 0x80, 0xF7, 0x83, 0xC0, 0x3C, 0x07, 0xBC, 0x1E, 0x01, 0xE0, 0x7B,
  0xE0, 0xF0, 0x1F, 0x03, 0xDE, 0x0F, 0x80, 0xF0, 0x1E, 0xF0, 0x7C, 0x07,
  0x81, 0xE7, 0x83, 0xE0, 0x7C, 0x0F, 0x3C, 0x1F, 0x07, 0xE0, 0xF1, 0xE0,
  0xF8, 0x3F, 0x0F, 0x8F, 0x03, 0xE7, 0xBC, 0xF8, 0x7C, 0x1F, 0xF9, 0xFF,
  0x83, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0x01, 0xF8, 0x3F, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x60, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xFE, 0x01,
  0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xC0, 0x1F, 0xC0, 0x0C,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x03, 0xFE,
  0x1F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFE,
  0x03, 0xE0, 0x07, 0xF8, 0x0F, 0x80, 0x3F, 0xC0, 0x7E, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xF0, 0x07, 0xF8,
  0x01, 0xC0, 0x3F, 0x80, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xFE, 0x3F, 0x00, 0x7F, 0xF8, 0xFC, 0x01, 0xFF, 0xE3, 0xF0, 0x07,
  0xFF, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0xFF, 0xC3, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x06, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x1F, 0x0F, 0xE0, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xDE, 0x00, 0x0F, 0xBE, 0x03, 0xEF, 0x00,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x03, 0xEF,
  0x80, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x01, 0xF0, 0xF0, 0x3E, 0x1F, 0x00, 0xF8,
  0x78, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x1F, 0x0F, 0xC0, 0x7E, 0x1E, 0x0F,
  0x87, 0xC0, 0x3E, 0x0F, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x87, 0xC1, 0xF0,
  0x0F, 0x83, 0xE7, 0xC1, 0xF8, 0x07, 0xC1, 0xF3, 0xE0, 0xFC, 0x07, 0xC0,
  0xFB, 0xE0, 0x7C, 0x03, 0xE0, 0x7D, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0xF0,
  0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x3F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x3E,
  0x01, 0xFF, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x00,
  0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x03, 0xEF, 0x80, 0x1F, 0x00, 0xFB, 0xE0,
  0x07, 0xC0, 0x3E, 0xF8, 0x01, 0xF0, 0x0F, 0xBF, 0x00, 0x7C, 0x03, 0xE7,
  0xC0, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x1F,
  0x0F, 0x80, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x00,
  0xF8, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x7C,
  0x03, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x3F, 0x3E, 0x01, 0xF0, 0x07,
  0xCF, 0x80, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x7D, 0xF0, 0x0F, 0x80,
  0x0F, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x7C,
  0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0xC0, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x0F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0xFE, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x82,
  0x00, 0x07, 0xE0, 0xE0, 0x07, 0xF0, 0x3F, 0x0F, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0x01, 0xFB,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0xC0, 0x3F,
  0x0F, 0x80, 0x3D, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0xF8,
  0x07, 0xDF, 0x01, 0xF0, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x0F, 0x80, 0xF9,
  0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x1F, 0x07,
  0xE0, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x03,
  0xE0, 0xF8, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x07, 0xC7, 0xC0, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x7C,
  0xFC, 0x00, 0x78, 0xF0, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x07, 0xCF, 0x80,
  0x07, 0x9F, 0x01, 0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x7D, 0xF0, 0x00, 0x7B,
  0xE0, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x80,
  0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x1E,
  0x07, 0x80, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0xC7, 0xC0, 0x7F, 0xF3, 0xE0,
  0x7F, 0xFD, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x1F, 0xE1, 0xF8, 0x1F, 0xE0, 0x7E, 0x1F, 0xF0, 0x3F, 0xFE, 0xF8, 0x1F,
  0xFE, 0x7C, 0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x1E, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x7F, 0xC0, 0x3F, 0x7F, 0xF0, 0x1F, 0x7F, 0xFC, 0x0F,
  0xFD, 0xFE, 0x07, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0xE1,
  0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x7E, 0x0F, 0xF0, 0x7F, 0x07, 0xBF, 0xFF, 0x07, 0xDF, 0xFF, 0x03, 0xC7,
  0xFF, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xDF, 0x07, 0xF0,
  0x10, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x10,
  0x7F, 0x07, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0xFF,
  0x8F, 0x80, 0x1F, 0xFC, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xF0,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xF0, 0x07, 0xE1, 0xFF, 0x00, 0x7F, 0xFD,
  0xF0, 0x07, 0xFF, 0x9F, 0x00, 0x3F, 0xF1, 0xE0, 0x01, 0xFE, 0x1E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x9F, 0x81,
  0xFC, 0x7C, 0x3F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x10, 0x7F, 0x01,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC2,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC1, 0xE0, 0x07, 0xFC, 0x3C, 0x01, 0xFF, 0xCF, 0x80, 0x7F,
  0xFD, 0xF0, 0x1F, 0xEF, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x1F, 0xE0, 0x1F, 0x87, 0xFC,
  0x03, 0xFF, 0xEF, 0x80, 0x7F, 0xFB, 0xF0, 0x07, 0xFE, 0x7C, 0x00, 0x7F,
  0x8F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x40, 0x03,
  0xF0, 0x0E, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x7F, 0xE0, 0x3F, 0x7F, 0xF0, 0x1F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00,
  0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x7C, 0x00, 0x3F, 0x9F, 0x00, 0x0F, 0xC7,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xC1, 0xF8, 0x07,
  0xE0, 0x07, 0x8F, 0xF8, 0x3F, 0xF0, 0x1F, 0x3F, 0xF8, 0xFF, 0xF0, 0x3E,
  0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xDF, 0xC0, 0xFF, 0x07, 0xFE,
  0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xE0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0xC3,
  0xE0, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xC1, 0xF8, 0x01, 0xE3, 0xFF,
  0x01, 0xF3, 0xFF, 0xC0, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFC, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xBF, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80,
  0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x0F,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x78, 0x3F, 0x00, 0x07, 0x8F, 0xF8, 0x00, 0xF9, 0xFF, 0xC0,
  0x0F, 0xBF, 0xFE, 0x00, 0xFF, 0xCF, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07,
  0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x3F, 0xFC, 0x01,
  0xF3, 0xFF, 0x80, 0x1F, 0x1F, 0xE0, 0x01, 0xF0, 0x10, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0xC3, 0xC0, 0x7F,
  0xF3, 0xE0, 0x7F, 0xFD, 0xF0, 0x7F, 0xBF, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F,
  0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7E, 0x1F, 0xF0, 0x3F, 0xFE,
  0xF8, 0x1F, 0xFE, 0x7C, 0x07, 0xFE, 0x7C, 0x01, 0xFE, 0x3E, 0x00, 0x10,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x3C, 0x7F, 0x07, 0xCF, 0xF0,
  0x7D, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x1F, 0x07, 0xE0, 0x10, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x10, 0x01, 0xF8, 0xE0, 0x3F, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x10, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0x00,
  0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1,
  0xF8, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x3F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7C,
  0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x1E, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE0,
  0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x07, 0xBE,
  0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x7C,
  0x03, 0xF8, 0x03, 0xEF, 0x80, 0x7F, 0x00, 0xF9, 0xF0, 0x1F, 0xE0, 0x1F,
  0x3E, 0x03, 0xFE, 0x07, 0xE7, 0xC0, 0x7F, 0xC0, 0xF8, 0xF8, 0x1E, 0xF8,
  0x3F, 0x1F, 0x03, 0xDF, 0x07, 0xC3, 0xE0, 0xFB, 0xE0, 0xF8, 0x7C, 0x1E,
  0x7C, 0x3E, 0x0F, 0x87, 0xCF, 0x87, 0xC1, 0xF0, 0xF1, 0xF1, 0xF0, 0x3E,
  0x1E, 0x3E, 0x3E, 0x07, 0xC7, 0xC7, 0xCF, 0xC0, 0x78, 0xF0, 0xF9, 0xF0,
  0x0F, 0x3E, 0x1F, 0x3E, 0x01, 0xE7, 0x83, 0xEF, 0x80, 0x3D, 0xF0, 0x7D,
  0xF0, 0x07, 0xBC, 0x0F, 0xBC, 0x00, 0xF7, 0x81, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xFC,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xA0, 0x00,
  0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 39, 14, 1, -38 },
  { 70, 17, 14, 21, 5, -38 },
  { 100, 30, 38, 30, 1, -38 },
  { 243, 25, 43, 26, 1, -40 },
  { 378, 35, 39, 40, 3, -38 },
  { 549, 30, 39, 32, 1, -38 },
  { 696, 7, 14, 12, 6, -38 },
  { 709, 17, 46, 15, 2, -38 },
  { 807, 18, 46, 15, -4, -38 },
  { 911, 22, 22, 26, 5, -40 },
  { 972, 23, 25, 28, 3, -31 },
  { 1044, 10, 13, 13, -2, -6 },
  { 1061, 13, 5, 16, 1, -17 },
  { 1070, 7, 8, 13, 1, -7 },
  { 1077, 26, 38, 19, -2, -38 },
  { 1201, 24, 39, 26, 2, -38 },
  { 1318, 17, 38, 26, 6, -38 },
  { 1399, 27, 38, 26, -1, -38 },
  { 1528, 26, 39, 26, 0, -38 },
  { 1655, 26, 38, 26, 0, -38 },
  { 1779, 25, 39, 26, 1, -38 },
  { 1901, 25, 39, 26, 2, -38 },
  { 2023, 25, 38, 26, 3, -38 },
  { 2142, 25, 39, 26, 1, -38 },
  { 2264, 24, 39, 26, 1, -38 },
  { 2381, 11, 30, 13, 1, -29 },
  { 2423, 15, 36, 13, -3, -29 },
  { 2491, 23, 26, 28, 3, -32 },
  { 2566, 23, 15, 28, 3, -26 },
  { 2610, 23, 26, 28, 3, -32 },
  { 2685, 19, 39, 21, 3, -38 },
  { 2778, 37, 43, 40, 2, -38 },
  { 2977, 28, 38, 28, -3, -38 },
  { 3110, 28, 38, 29, 1, -38 },
  { 3243, 28, 39, 28, 3, -38 },
  { 3380, 30, 38, 32, 1, -38 },
  { 3523, 26, 38, 25, 1, -38 },
  { 3647, 26, 38, 23, 1, -38 },
  { 3771, 30, 39, 33, 3, -38 },
  { 3918, 32, 38, 33, 1, -38 },
  { 4070, 22, 38, 17, -2, -38 },
  { 4175, 23, 48, 14, -8, -38 },
  { 4313, 31, 38, 28, 1, -38 },
  { 4461, 19, 38, 23, 1, -38 },
  { 4552, 41, 38, 41, 1, -38 },
  { 4747, 34, 38, 35, 1, -38 },
  { 4909, 30, 39, 34, 3, -38 },
  { 5056, 27, 38, 28, 1, -38 },
  { 5185, 30, 47, 34, 3, -38 },
  { 5362, 27, 38, 28, 1, -38 },
  { 5491, 26, 39, 25, 0, -38 },
  { 5618, 24, 38, 24, 4, -38 },
  { 5732, 30, 39, 32, 3, -38 },
  { 5879, 27, 38, 27, 5, -38 },
  { 6008, 42, 38, 42, 5, -38 },
  { 6208, 33, 38, 26, -3, -38 },
  { 6365, 25, 38, 25, 5, -38 },
  { 6484, 28, 38, 25, -1, -38 },
  { 6617, 21, 46, 16, -1, -38 },
  { 6738, 10, 38, 19, 6, -38 },
  { 6786, 21, 46, 16, -4, -38 },
  { 6907, 25, 23, 27, 1, -38 },
  { 6979, 20, 3, 19, -5, 5 },
  { 6987, 9, 9, 15, 8, -41 },
  { 6998, 25, 30, 28, 2, -29 },
  { 7092, 25, 41, 28, 1, -40 },
  { 7221, 21, 30, 22, 2, -29 },
  { 7300, 28, 41, 28, 2, -40 },
  { 7444, 22, 30, 25, 2, -29 },
  { 7527, 28, 54, 16, -6, -41 },
  { 7716, 27, 42, 28, 0, -29 },
  { 7858, 25, 40, 28, 1, -40 },
  { 7983, 13, 39, 13, 1, -39 },
  { 8047, 21, 52, 13, -7, -39 },
  { 8184, 26, 40, 25, 1, -40 },
  { 8314, 14, 40, 13, 1, -40 },
  { 8384, 39, 29, 42, 1, -29 },
  { 8526, 25, 29, 28, 1, -29 },
  { 8617, 23, 29, 27, 2, -29 },
  { 8701, 28, 42, 28, -2, -29 },
  { 8848, 25, 42, 28, 2, -29 },
  { 8980, 20, 29, 19, 1, -29 },
  { 9053, 21, 30, 21, 0, -29 },
  { 9132, 16, 36, 17, 2, -35 },
  { 9204, 25, 30, 28, 2, -29 },
  { 9298, 23, 29, 23, 3, -29 },
  { 9382, 35, 29, 36, 3, -29 },
  { 9509, 28, 29, 24, -2, -29 },
  { 9611, 31, 42, 23, -5, -29 },
  { 9774, 23, 29, 21, -1, -29 },
  { 9858, 20, 46, 18, 1, -38 },
  { 9973, 4, 53, 26, 11, -40 },
  { 10000, 21, 46, 18, -3, -38 },
  { 10121, 23, 7, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC53PT7B_H_
