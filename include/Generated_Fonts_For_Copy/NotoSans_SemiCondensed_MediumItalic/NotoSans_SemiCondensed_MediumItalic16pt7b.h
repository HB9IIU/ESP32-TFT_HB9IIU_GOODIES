#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x64, 0x0C, 0xC0, 0xDC, 0xA5, 0x60, 0x0D, 0x84,
  0x86, 0x4F, 0xF1, 0x20, 0x93, 0xFD, 0xFE, 0x24, 0x36, 0x12, 0x00, 0x04,
  0x1E, 0x3F, 0x28, 0x28, 0x38, 0x1C, 0x16, 0x16, 0x96, 0xFC, 0x10, 0x20,
  0x30, 0x5E, 0x25, 0x93, 0x6C, 0x9A, 0x25, 0x7F, 0xF5, 0x29, 0x12, 0x4C,
  0x92, 0x2D, 0x0E, 0x04, 0x0F, 0x04, 0xC6, 0x41, 0x60, 0xE0, 0xE2, 0xDB,
  0xC5, 0x63, 0xB3, 0xCF, 0x70, 0xEA, 0x0C, 0x43, 0x08, 0x61, 0x84, 0x10,
  0x43, 0x04, 0x10, 0x41, 0x80, 0x10, 0xC6, 0x10, 0x84, 0x63, 0x18, 0x8C,
  0x46, 0x22, 0x00, 0x12, 0x4E, 0x4F, 0x53, 0x61, 0x00, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x00, 0x36, 0x4C, 0xF0, 0xF0, 0x03, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x18, 0x79, 0x9A, 0x3C, 0x78,
  0xE1, 0xC2, 0x8D, 0x1B, 0x67, 0x80, 0x3B, 0xB4, 0x63, 0x18, 0x84, 0x63,
  0x10, 0x0C, 0x3E, 0x23, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2,
  0xFC, 0x0C, 0x3E, 0x23, 0x03, 0x02, 0x1C, 0x3C, 0x06, 0x06, 0x06, 0x8C,
  0xF8, 0x07, 0x06, 0x0A, 0x16, 0x36, 0x66, 0x44, 0xFF, 0xFE, 0x0C, 0x08,
  0x1F, 0x30, 0x30, 0x20, 0x7C, 0x26, 0x06, 0x06, 0x06, 0x8C, 0xF8, 0x06,
  0x3C, 0x83, 0x04, 0x1F, 0xB3, 0x62, 0x85, 0x1B, 0x63, 0xC0, 0x7E, 0x0C,
  0x10, 0x61, 0x83, 0x0C, 0x18, 0x60, 0x83, 0x00, 0x0C, 0x1F, 0x33, 0x33,
  0x32, 0x1C, 0x3C, 0x66, 0xC6, 0xC6, 0x66, 0x7C, 0x0C, 0x3E, 0x23, 0x63,
  0x63, 0x63, 0x7E, 0x3A, 0x06, 0x04, 0x9C, 0xF0, 0x23, 0x00, 0x00, 0x0C,
  0xC0, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x62, 0x30, 0x02, 0x0C, 0x63, 0x0C,
  0x0E, 0x07, 0x81, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0x81, 0xC0, 0xE0,
  0x63, 0x38, 0x40, 0x33, 0xE0, 0xC3, 0x08, 0xC6, 0x10, 0x40, 0x0C, 0x30,
  0x1F, 0x86, 0x09, 0x81, 0xA7, 0x99, 0x93, 0x26, 0x6C, 0x95, 0xB2, 0x9F,
  0x90, 0x03, 0x00, 0x3F, 0x00, 0x07, 0x07, 0x0F, 0x0B, 0x1B, 0x11, 0x3F,
  0x3F, 0x61, 0x61, 0xC1, 0x1F, 0x18, 0xCC, 0x66, 0x23, 0xF1, 0xF1, 0x8C,
  0xC6, 0x63, 0x23, 0x3F, 0x00, 0x06, 0x1F, 0x30, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x1F, 0x18, 0xCC, 0x66, 0x32, 0x19, 0x0D,
  0x86, 0xC2, 0x63, 0x27, 0x3F, 0x00, 0x1F, 0x30, 0x30, 0x30, 0x3E, 0x3E,
  0x60, 0x60, 0x60, 0x40, 0xFC, 0x1F, 0x30, 0x30, 0x30, 0x20, 0x3E, 0x60,
  0x60, 0x60, 0x40, 0xC0, 0x06, 0x0F, 0xCC, 0x2C, 0x04, 0x06, 0x03, 0x3D,
  0x86, 0xC3, 0x61, 0x39, 0x8F, 0xC0, 0x10, 0xCC, 0x33, 0x08, 0xC2, 0x3F,
  0x8F, 0xE6, 0x19, 0x84, 0x61, 0x10, 0xCC, 0x30, 0x1E, 0x10, 0x20, 0xC1,
  0x83, 0x04, 0x18, 0x30, 0x63, 0xE0, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x18, 0x41, 0x0C, 0x73, 0x80, 0x11, 0xCC, 0xC3, 0x60, 0xF0, 0x2C, 0x0F,
  0x06, 0xC1, 0x90, 0x66, 0x11, 0x8C, 0x60, 0x10, 0xC3, 0x0C, 0x20, 0x86,
  0x18, 0x61, 0x0F, 0xC0, 0x18, 0x39, 0xC3, 0x8E, 0x14, 0x51, 0xE2, 0x8B,
  0x14, 0xD1, 0xB4, 0x8D, 0xEC, 0x4E, 0x62, 0x73, 0x31, 0x10, 0x18, 0x67,
  0x08, 0xE3, 0x16, 0x62, 0xCC, 0x49, 0x19, 0xA3, 0x3C, 0x43, 0x88, 0x73,
  0x0C, 0x00, 0x0C, 0x1F, 0x8C, 0x6C, 0x34, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0x61, 0xB9, 0x8F, 0x80, 0x1F, 0x19, 0x8C, 0x66, 0x22, 0x31, 0xF1, 0xE0,
  0xC0, 0x60, 0x20, 0x30, 0x00, 0x0C, 0x1F, 0x8C, 0x6C, 0x34, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0x61, 0xB9, 0x8F, 0x80, 0xC0, 0x60, 0x18, 0x1F, 0x33,
  0x31, 0x31, 0x23, 0x3E, 0x6C, 0x64, 0x66, 0x46, 0xC6, 0x0C, 0x3F, 0x30,
  0x20, 0x20, 0x30, 0x1C, 0x0C, 0x06, 0x04, 0x8C, 0xF8, 0xFF, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x61, 0xB0, 0xD8, 0x48,
  0x24, 0x36, 0x1B, 0x0D, 0x84, 0xC6, 0x67, 0x1F, 0x00, 0xC3, 0xA1, 0x91,
  0x88, 0xC4, 0x42, 0x61, 0x20, 0xB0, 0x50, 0x38, 0x18, 0x00, 0x86, 0x38,
  0xE2, 0x8E, 0x69, 0xE4, 0x96, 0xCB, 0x6C, 0xA6, 0x8A, 0x78, 0xE7, 0x0C,
  0x70, 0xC6, 0x00, 0x18, 0xC6, 0x60, 0xB0, 0x28, 0x0E, 0x03, 0x01, 0xE0,
  0x58, 0x32, 0x18, 0x8C, 0x30, 0xC3, 0x46, 0x6C, 0x6C, 0x78, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x3F, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0xFC, 0x3C, 0xC3, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30,
  0xE3, 0x80, 0x93, 0x6C, 0x92, 0x4D, 0x80, 0x1C, 0x30, 0x82, 0x08, 0x61,
  0x84, 0x10, 0xC3, 0x0C, 0xE3, 0x80, 0x08, 0x1C, 0x14, 0x26, 0x62, 0xC3,
  0xFC, 0xCC, 0x3A, 0xF7, 0x1E, 0x38, 0x51, 0xA3, 0x6E, 0xE8, 0x10, 0x30,
  0x30, 0x36, 0x3F, 0x33, 0x63, 0x63, 0x62, 0x66, 0x66, 0xFC, 0x3D, 0xFC,
  0x30, 0x82, 0x08, 0x32, 0xF8, 0x03, 0x03, 0x02, 0x3A, 0x7E, 0xC6, 0xC6,
  0x84, 0x8C, 0x8C, 0xDC, 0xE8, 0x39, 0xFC, 0x73, 0xFA, 0x08, 0x32, 0x78,
  0x07, 0x82, 0x03, 0x01, 0xC1, 0xE0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x83, 0x81, 0xC0, 0x1D, 0x3D, 0x63, 0x63, 0x42, 0x46,
  0x46, 0x6E, 0x74, 0x04, 0x0C, 0xD8, 0x70, 0x10, 0x30, 0x30, 0x36, 0x3F,
  0x33, 0x63, 0x62, 0x62, 0x46, 0x46, 0xC6, 0x13, 0x03, 0x22, 0x66, 0x64,
  0x4C, 0x04, 0x30, 0x03, 0x08, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xCE,
  0x30, 0x10, 0x30, 0x30, 0x33, 0x26, 0x2C, 0x78, 0x78, 0x68, 0x4C, 0x4C,
  0xC6, 0x13, 0x33, 0x22, 0x66, 0x64, 0x4C, 0x26, 0x63, 0xEF, 0x33, 0x36,
  0x33, 0x62, 0x36, 0x62, 0x46, 0x24, 0x66, 0xC4, 0x60, 0x26, 0x3F, 0x33,
  0x63, 0x62, 0x62, 0x46, 0x46, 0xC6, 0x38, 0xFB, 0x1E, 0x38, 0x70, 0xA3,
  0x6C, 0x70, 0x13, 0x0F, 0xC6, 0x66, 0x33, 0x19, 0x88, 0xCC, 0x66, 0x7E,
  0x30, 0x18, 0x08, 0x0C, 0x00, 0x3A, 0xF7, 0x1E, 0x38, 0x51, 0xA3, 0x6E,
  0xE8, 0x10, 0x60, 0xC1, 0x80, 0x24, 0xB3, 0x18, 0x61, 0x84, 0x10, 0xC0,
  0x3D, 0xF6, 0x18, 0x30, 0x60, 0xA6, 0xF8, 0x21, 0x1F, 0xE4, 0x63, 0x18,
  0x84, 0x38, 0x62, 0x8D, 0x1E, 0x2C, 0x59, 0xA3, 0x4E, 0xE8, 0x87, 0x0B,
  0x36, 0x4D, 0x9A, 0x3C, 0x70, 0x60, 0xCC, 0x79, 0x9B, 0x73, 0x6A, 0x4D,
  0x59, 0xCA, 0x29, 0xC7, 0x30, 0xC6, 0x00, 0x31, 0x89, 0x87, 0x83, 0x80,
  0xC0, 0xE0, 0xD0, 0xCC, 0xC6, 0x00, 0x21, 0x98, 0x8C, 0xC6, 0x43, 0x61,
  0xA0, 0x70, 0x30, 0x18, 0x08, 0x0C, 0x1C, 0x0C, 0x00, 0x3E, 0xF8, 0x30,
  0xC3, 0x04, 0x18, 0x60, 0xF8, 0x0C, 0x61, 0x04, 0x10, 0xCC, 0x18, 0x21,
  0x86, 0x18, 0x70, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x20, 0x82, 0x18,
  0x60, 0xC6, 0x10, 0xC3, 0x08, 0xE2, 0x00, 0x63, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 2, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 13, 8, 0, -12 },
  { 36, 10, 12, 12, 1, -12 },
  { 51, 9, 12, 10, 0, -12 },
  { 65, 2, 4, 4, 2, -11 },
  { 66, 6, 14, 5, 0, -11 },
  { 77, 5, 15, 5, -1, -12 },
  { 87, 6, 7, 8, 2, -12 },
  { 93, 7, 7, 8, 1, -9 },
  { 100, 4, 4, 4, -1, -2 },
  { 102, 4, 1, 5, 0, -5 },
  { 103, 2, 2, 4, 0, -2 },
  { 104, 8, 11, 6, -1, -11 },
  { 115, 7, 12, 8, 1, -12 },
  { 126, 5, 11, 8, 2, -11 },
  { 133, 8, 12, 8, 0, -12 },
  { 145, 8, 12, 8, 0, -12 },
  { 157, 8, 11, 8, 0, -11 },
  { 168, 8, 11, 8, 0, -11 },
  { 179, 7, 12, 8, 1, -12 },
  { 190, 7, 11, 8, 1, -11 },
  { 200, 8, 12, 8, 0, -12 },
  { 212, 8, 12, 8, 0, -12 },
  { 224, 4, 9, 4, 0, -9 },
  { 229, 5, 11, 4, -1, -9 },
  { 236, 7, 8, 8, 1, -10 },
  { 243, 7, 5, 8, 1, -8 },
  { 248, 7, 8, 8, 1, -10 },
  { 255, 6, 12, 6, 1, -12 },
  { 264, 11, 12, 12, 1, -11 },
  { 281, 8, 11, 8, -1, -11 },
  { 292, 9, 11, 9, 0, -11 },
  { 305, 8, 12, 8, 1, -12 },
  { 317, 9, 11, 10, 0, -11 },
  { 330, 8, 11, 8, 0, -11 },
  { 341, 8, 11, 7, 0, -11 },
  { 352, 9, 12, 10, 1, -12 },
  { 366, 10, 11, 10, 0, -11 },
  { 380, 7, 11, 5, -1, -11 },
  { 390, 6, 14, 4, -2, -11 },
  { 401, 10, 11, 8, 0, -11 },
  { 415, 6, 11, 7, 0, -11 },
  { 424, 13, 11, 13, 0, -11 },
  { 442, 11, 11, 10, 0, -11 },
  { 458, 9, 12, 10, 1, -12 },
  { 472, 9, 11, 8, 0, -11 },
  { 485, 9, 15, 10, 1, -12 },
  { 502, 8, 11, 8, 0, -11 },
  { 513, 8, 12, 7, 0, -12 },
  { 525, 8, 11, 7, 1, -11 },
  { 536, 9, 11, 10, 1, -11 },
  { 549, 9, 11, 8, 1, -11 },
  { 562, 12, 11, 13, 2, -11 },
  { 579, 10, 11, 8, -1, -11 },
  { 593, 8, 11, 8, 1, -11 },
  { 604, 8, 11, 7, 0, -11 },
  { 615, 6, 14, 5, 0, -11 },
  { 626, 3, 11, 6, 2, -11 },
  { 631, 6, 14, 5, -1, -11 },
  { 642, 8, 6, 8, 0, -11 },
  { 648, 6, 1, 6, -1, 1 },
  { 649, 3, 2, 5, 2, -12 },
  { 650, 7, 9, 8, 1, -9 },
  { 658, 8, 12, 8, 0, -12 },
  { 670, 6, 9, 7, 1, -9 },
  { 677, 8, 12, 8, 1, -12 },
  { 689, 6, 9, 8, 1, -9 },
  { 696, 9, 16, 5, -2, -12 },
  { 714, 8, 13, 8, 0, -9 },
  { 727, 8, 12, 8, 0, -12 },
  { 739, 4, 12, 4, 0, -12 },
  { 745, 6, 16, 4, -2, -12 },
  { 757, 8, 12, 7, 0, -12 },
  { 769, 4, 12, 4, 0, -12 },
  { 775, 12, 9, 13, 0, -9 },
  { 789, 8, 9, 8, 0, -9 },
  { 798, 7, 9, 8, 1, -9 },
  { 806, 9, 13, 8, -1, -9 },
  { 821, 7, 13, 8, 1, -9 },
  { 833, 6, 9, 6, 0, -9 },
  { 840, 6, 9, 6, 0, -9 },
  { 847, 5, 11, 5, 1, -11 },
  { 854, 7, 9, 8, 1, -9 },
  { 862, 7, 9, 7, 1, -9 },
  { 870, 11, 9, 11, 1, -9 },
  { 883, 9, 9, 7, -1, -9 },
  { 894, 9, 13, 7, -1, -9 },
  { 909, 7, 9, 6, 0, -9 },
  { 917, 6, 14, 6, 0, -11 },
  { 928, 2, 16, 8, 3, -12 },
  { 932, 6, 14, 6, -1, -11 },
  { 943, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC16PT7B_H_
