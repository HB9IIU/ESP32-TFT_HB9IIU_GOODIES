#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0x0F,
  0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x1F,
  0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C,
  0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0xE3, 0xC0, 0x3F, 0x1E, 0x0C, 0x03, 0xE1,
  0xE0, 0x00, 0x7E, 0x1C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C, 0x00,
  0x07, 0xE3, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xF3, 0x80, 0x00, 0x3F,
  0xB8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xEF, 0xF0, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0xE3,
  0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1C, 0x1F, 0x00,
  0x01, 0xC3, 0xF0, 0x80, 0x1C, 0x3F, 0x0E, 0x03, 0xC7, 0xE0, 0xF8, 0x38,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x80, 0x7F, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x01, 0xF0,
  0x1E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x7C, 0x1E, 0x0F, 0x83, 0xE1, 0xF1, 0xFF, 0x3E, 0x0F,
  0x8F, 0x8F, 0xFE, 0xF8, 0x7C, 0x7C, 0x7F, 0xFB, 0xE1, 0xF1, 0xF3, 0xFF,
  0xFF, 0xFF, 0x8F, 0x8F, 0x87, 0xDF, 0xFE, 0x7C, 0x7C, 0x1F, 0x7F, 0xF1,
  0xF1, 0xF0, 0x7C, 0xFF, 0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0x7C, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0xF0, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x7C,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0x7C, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x7E, 0x01, 0xF0, 0x01,
  0xFF, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7E, 0x0F, 0xFF, 0xC0, 0x3F,
  0x0F, 0xE7, 0xE0, 0x1F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC7, 0xE0, 0x1F, 0xC7, 0xC3, 0xF0, 0x07, 0xE7,
  0xE3, 0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x3F,
  0xF0, 0x7E, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0xC3, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x40,
  0x1E, 0x00, 0x70, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0xFF, 0x3C, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0x03, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x0F,
  0xCF, 0x00, 0x1F, 0x8F, 0x80, 0x7F, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x0C, 0x07, 0xE0, 0x04, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x0C, 0x7E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFC, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0x7E, 0x7F, 0x9F,
  0x3F, 0xCF, 0xC7, 0xE3, 0xF0, 0xE0, 0xFC, 0x30, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x20, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x0C,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x0F, 0xF0, 0x78,
  0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x30, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x08, 0x00, 0x1F, 0xE0, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xE3, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE3, 0xFE, 0x00, 0xF9, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0x1F, 0x87, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x03,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x3F, 0xE1, 0xFF,
  0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xDF, 0x81, 0xFF, 0xE7, 0xC0,
  0x3F, 0xE3, 0xF0, 0x00, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x20,
  0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xBF, 0xE1,
  0xE0, 0x1F, 0xC2, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1E, 0x07,
  0xC0, 0x1F, 0xFE, 0x07, 0xC3, 0xE0, 0x1F, 0xFF, 0xC1, 0xF0, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7C, 0x7C, 0x07, 0xF0, 0xF8, 0x1F, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC7, 0x80, 0xF8, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x03, 0xC0, 0x7C,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0x9F, 0x03,
  0xE0, 0x1F, 0x01, 0xE7, 0xC1, 0xF0, 0x07, 0x80, 0x79, 0xF0, 0x7C, 0x03,
  0xE0, 0x3E, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0x9E, 0x07, 0xC0, 0x3E, 0x03,
  0xC7, 0x81, 0xE0, 0x1F, 0x01, 0xF3, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0xF8,
  0x1E, 0x03, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x0F, 0x81, 0xF0,
  0x7F, 0x07, 0xC3, 0xE0, 0x7E, 0x7F, 0xE7, 0xE0, 0x78, 0x1F, 0xFE, 0x7F,
  0xF0, 0x1E, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0x83, 0xFC, 0x01,
  0xF0, 0x07, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFE, 0x03, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x0E, 0x00, 0xFF, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x3F, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x0F,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x04, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xF0,
  0xFC, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x3F, 0xFE,
  0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0x80, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0x7C, 0x00, 0x0F, 0xBF,
  0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0xFC, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xF8,
  0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x83,
  0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x7C,
  0x0F, 0xC0, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xCF, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7D, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x3F, 0x00,
  0x3E, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x03,
  0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x00,
  0x7E, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xDF, 0x80, 0x0F, 0xC0, 0x1F,
  0x7E, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x03,
  0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x7E, 0x01, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0x00, 0x7E, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF0, 0x01,
  0xFB, 0xF0, 0x07, 0xC0, 0x07, 0xEF, 0x80, 0x3F, 0x00, 0x0F, 0xBE, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x01,
  0xFF, 0x80, 0x7E, 0x00, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00,
  0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xF8, 0x07, 0x80, 0x3F, 0x80, 0x04, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x04, 0x00, 0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF3, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7D,
  0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0x9F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF1, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x1F, 0x03,
  0xF0, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xE1, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x1F, 0x07, 0xE0,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x00,
  0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x80, 0x0F,
  0xCF, 0xC0, 0x7C, 0x7C, 0x00, 0x3F, 0x3E, 0x01, 0xF3, 0xF0, 0x00, 0xFC,
  0xF8, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0x0F, 0xDF,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07,
  0x80, 0x00, 0x1F, 0xC1, 0xF0, 0x07, 0xFF, 0x1F, 0x00, 0xFF, 0xF1, 0xF0,
  0x1F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x07, 0xFE, 0x07,
  0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0x7C, 0x03, 0xFF, 0xE7, 0xC0, 0x1F, 0xFC,
  0x7C, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x03, 0xF1,
  0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE,
  0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xF3, 0xFE, 0x07, 0xDF, 0xFF, 0xC0,
  0xF9, 0xFF, 0xF8, 0x0F, 0x8F, 0xFF, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x01, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0x03, 0xFF, 0x3E, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xFC, 0xFC, 0x00,
  0x7F, 0xF9, 0xF8, 0x01, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0x00,
  0x7F, 0xDF, 0xFC, 0x00, 0xFF, 0xFE, 0xF8, 0x00, 0xFF, 0xF9, 0xF0, 0x00,
  0xFF, 0xE3, 0xE0, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFC, 0x7F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E,
  0x3F, 0x01, 0xFE, 0x7E, 0x0F, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x3F, 0xC1, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x7C, 0x00, 0x7F, 0xF1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F,
  0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFE,
  0x01, 0xFC, 0x1F, 0xF8, 0x07, 0xFD, 0xF7, 0xC0, 0x1F, 0xFF, 0xDF, 0x00,
  0x3F, 0xFE, 0xFC, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0xFF, 0x0F, 0xC0, 0x00,
  0x40, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x30, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x03, 0xF1, 0xFF, 0x80, 0x3F, 0x7F, 0xFC,
  0x03, 0xF7, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xE0, 0x7F,
  0xC0, 0x7E, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xEF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0x00,
  0xFF, 0x00, 0x7C, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0x9F, 0xFF, 0x1F, 0xFF,
  0x01, 0xF7, 0xFF, 0xE7, 0xFF, 0xE0, 0x3E, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0xFF, 0x00, 0x3E, 0x1F, 0xFC, 0x03, 0xE7, 0xFF, 0xC0, 0x3E,
  0xFF, 0xFE, 0x03, 0xEF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFE, 0x07, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0,
  0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0xF8, 0x7F, 0xE0,
  0x01, 0xF1, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x00, 0x7F, 0xF3, 0xFE, 0x00, 0xFB, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xE0,
  0x07, 0xE7, 0xFF, 0x80, 0x0F, 0xC3, 0xFC, 0x00, 0x1F, 0x80, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x07, 0xFF, 0x1F, 0x00, 0xFF,
  0xF9, 0xF0, 0x1F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x07,
  0xFE, 0x07, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0x7C, 0x03, 0xFF, 0xEF, 0xC0,
  0x1F, 0xFC, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x01, 0x80, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0xFE, 0x07,
  0xC7, 0xF8, 0x0F, 0x9F, 0xF0, 0x1F, 0x3F, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF,
  0xF9, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xCF, 0xC1, 0xFC, 0x03, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF1, 0x00, 0x0F, 0xE3, 0x00, 0x3F, 0x87, 0xE1, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x03, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x8C, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x04, 0x00, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F,
  0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0x7F,
  0xBF, 0x7C, 0x0F, 0xFF, 0xEF, 0x80, 0xFF, 0xF9, 0xF0, 0x1F, 0xFE, 0x3E,
  0x01, 0xFF, 0x07, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0xE0, 0x0F, 0xCF,
  0x80, 0x3F, 0xC0, 0x1F, 0x9F, 0x00, 0xFF, 0x80, 0x7E, 0x3E, 0x01, 0xFF,
  0x00, 0xFC, 0x7C, 0x07, 0xDE, 0x03, 0xF0, 0xF8, 0x0F, 0xBC, 0x07, 0xE1,
  0xF0, 0x1E, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0xF0, 0x3F, 0x07, 0xC0, 0xF9,
  0xE0, 0x7E, 0x0F, 0x83, 0xE3, 0xC1, 0xF8, 0x1F, 0x07, 0xC7, 0x83, 0xF0,
  0x3E, 0x1F, 0x0F, 0x0F, 0xC0, 0x7C, 0x3E, 0x1E, 0x1F, 0x80, 0xF8, 0x78,
  0x3C, 0x3E, 0x01, 0xF1, 0xF0, 0x78, 0xFC, 0x03, 0xE3, 0xE0, 0xF1, 0xF0,
  0x07, 0xCF, 0x81, 0xE7, 0xE0, 0x0F, 0x9F, 0x03, 0xCF, 0xC0, 0x1F, 0x7C,
  0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x0F, 0x7E, 0x00, 0x7D, 0xE0, 0x1E, 0xF8,
  0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFA, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 43, 15, 1, -42 },
  { 82, 19, 15, 23, 6, -42 },
  { 118, 33, 42, 34, 1, -42 },
  { 292, 28, 48, 29, 1, -45 },
  { 460, 38, 44, 44, 4, -43 },
  { 669, 33, 44, 35, 1, -43 },
  { 851, 9, 15, 13, 6, -42 },
  { 868, 19, 51, 17, 2, -42 },
  { 990, 19, 51, 17, -4, -42 },
  { 1112, 24, 25, 29, 6, -45 },
  { 1187, 26, 28, 31, 3, -35 },
  { 1278, 12, 15, 15, -3, -7 },
  { 1301, 15, 6, 18, 1, -19 },
  { 1313, 8, 9, 15, 1, -8 },
  { 1322, 29, 42, 22, -3, -42 },
  { 1475, 27, 44, 29, 2, -43 },
  { 1624, 18, 42, 29, 7, -42 },
  { 1719, 30, 43, 29, -1, -43 },
  { 1881, 29, 44, 29, 0, -43 },
  { 2041, 29, 42, 29, 0, -42 },
  { 2194, 28, 43, 29, 1, -42 },
  { 2345, 27, 44, 29, 3, -43 },
  { 2494, 28, 42, 29, 3, -42 },
  { 2641, 28, 44, 29, 1, -43 },
  { 2795, 26, 44, 29, 2, -43 },
  { 2938, 12, 33, 15, 1, -32 },
  { 2988, 17, 40, 15, -3, -32 },
  { 3073, 26, 29, 31, 3, -36 },
  { 3168, 26, 17, 31, 3, -29 },
  { 3224, 26, 29, 31, 3, -36 },
  { 3319, 22, 44, 23, 3, -43 },
  { 3440, 42, 47, 45, 2, -42 },
  { 3687, 32, 42, 31, -4, -42 },
  { 3855, 31, 42, 32, 1, -42 },
  { 4018, 31, 44, 31, 3, -43 },
  { 4189, 33, 42, 35, 1, -42 },
  { 4363, 29, 42, 28, 1, -42 },
  { 4516, 29, 42, 26, 1, -42 },
  { 4669, 33, 44, 36, 3, -43 },
  { 4851, 36, 42, 36, 1, -42 },
  { 5040, 24, 42, 19, -2, -42 },
  { 5166, 26, 54, 16, -9, -42 },
  { 5342, 35, 42, 31, 1, -42 },
  { 5526, 21, 42, 26, 1, -42 },
  { 5637, 46, 42, 46, 1, -42 },
  { 5879, 38, 42, 38, 1, -42 },
  { 6079, 34, 44, 38, 3, -43 },
  { 6266, 30, 42, 31, 1, -42 },
  { 6424, 34, 53, 38, 3, -43 },
  { 6650, 30, 42, 31, 1, -42 },
  { 6808, 29, 44, 28, 0, -43 },
  { 6968, 27, 42, 27, 5, -42 },
  { 7110, 33, 43, 36, 4, -42 },
  { 7288, 30, 42, 30, 5, -42 },
  { 7446, 46, 42, 47, 6, -42 },
  { 7688, 37, 42, 29, -3, -42 },
  { 7883, 28, 42, 28, 5, -42 },
  { 8030, 32, 42, 28, -1, -42 },
  { 8198, 23, 51, 17, -1, -42 },
  { 8345, 12, 42, 22, 6, -42 },
  { 8408, 23, 51, 17, -4, -42 },
  { 8555, 28, 25, 30, 1, -42 },
  { 8643, 22, 4, 22, -5, 5 },
  { 8654, 9, 9, 17, 9, -45 },
  { 8665, 28, 33, 31, 2, -32 },
  { 8781, 28, 46, 31, 1, -45 },
  { 8942, 23, 33, 24, 2, -32 },
  { 9037, 31, 46, 31, 2, -45 },
  { 9216, 24, 33, 28, 2, -32 },
  { 9315, 32, 59, 18, -7, -45 },
  { 9551, 30, 46, 31, 0, -32 },
  { 9724, 28, 45, 31, 1, -45 },
  { 9882, 15, 44, 14, 1, -44 },
  { 9965, 24, 58, 15, -8, -44 },
  { 10139, 29, 45, 28, 1, -45 },
  { 10303, 15, 45, 14, 1, -45 },
  { 10388, 43, 32, 47, 1, -32 },
  { 10560, 28, 32, 31, 1, -32 },
  { 10672, 26, 33, 30, 2, -32 },
  { 10780, 31, 46, 31, -2, -32 },
  { 10959, 28, 46, 31, 2, -32 },
  { 11120, 23, 32, 21, 1, -32 },
  { 11212, 23, 33, 24, 0, -32 },
  { 11307, 17, 40, 19, 3, -39 },
  { 11392, 27, 33, 31, 3, -32 },
  { 11504, 26, 32, 26, 3, -32 },
  { 11608, 39, 32, 40, 4, -32 },
  { 11764, 32, 32, 26, -3, -32 },
  { 11892, 34, 46, 26, -5, -32 },
  { 12088, 25, 32, 23, -1, -32 },
  { 12188, 23, 51, 20, 1, -42 },
  { 12335, 5, 59, 29, 12, -45 },
  { 12372, 23, 51, 20, -3, -42 },
  { 12519, 26, 8, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC59PT7B_H_
