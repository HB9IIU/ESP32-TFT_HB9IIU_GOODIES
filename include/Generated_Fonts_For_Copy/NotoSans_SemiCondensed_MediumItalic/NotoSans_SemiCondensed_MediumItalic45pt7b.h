#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0x20, 0x00, 0x7C, 0x7D, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x1E, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80,
  0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x78, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1E,
  0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03,
  0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFD, 0x9E,
  0x0F, 0x8C, 0x30, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x30, 0x00, 0xF1,
  0x80, 0x07, 0xCC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x33,
  0xE0, 0x01, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x06, 0x1E, 0x20,
  0x31, 0xF1, 0xE1, 0x9F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0x03, 0xFC, 0x00, 0xF0, 0x3F, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0x78, 0x1E,
  0x1C, 0x07, 0x81, 0xE0, 0xE0, 0x78, 0x0F, 0x07, 0x03, 0xC0, 0x70, 0x78,
  0x3C, 0x07, 0x83, 0xC3, 0xC0, 0x3C, 0x1E, 0x1E, 0x01, 0xE0, 0xF1, 0xE0,
  0x0F, 0x07, 0x1E, 0x00, 0x78, 0x78, 0xF1, 0xC3, 0xC3, 0xCF, 0x3F, 0x9E,
  0x3C, 0xF3, 0xFE, 0xF1, 0xE7, 0x9F, 0xFF, 0xFE, 0x79, 0xE3, 0xDF, 0xE7,
  0x9E, 0x1E, 0x7E, 0x3C, 0xF0, 0xF0, 0x83, 0xC7, 0x07, 0x80, 0x1C, 0x78,
  0x3C, 0x01, 0xE3, 0xC1, 0xE0, 0x1E, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x70,
  0x0F, 0x07, 0x07, 0x80, 0xF0, 0x38, 0x3C, 0x07, 0x01, 0xC1, 0xC0, 0x78,
  0x0E, 0x1E, 0x07, 0x80, 0x79, 0xE0, 0x38, 0x03, 0xFF, 0x03, 0xC0, 0x0F,
  0xF0, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x03, 0xC7, 0xFF, 0x03, 0xE7, 0xE7, 0xC1, 0xE7, 0xC1, 0xF1, 0xF3, 0xE0,
  0xF8, 0xF3, 0xE0, 0x3E, 0xF9, 0xF0, 0x1F, 0xF8, 0xF0, 0x07, 0xF8, 0x78,
  0x03, 0xFC, 0x3C, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0xFF, 0x07,
  0xFB, 0xFF, 0xC1, 0xFF, 0xFB, 0xF0, 0x7F, 0xF8, 0xF8, 0x1F, 0xF0, 0x3E,
  0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xCF, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x06, 0x07, 0x00, 0xF0, 0xE0, 0x1F,
  0x9C, 0x07, 0xFF, 0x7F, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83,
  0xF8, 0x00, 0xF7, 0x80, 0x3E, 0x70, 0x1F, 0x8F, 0x01, 0xE1, 0xE0, 0x18,
  0x1E, 0x01, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x38, 0x3C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFE, 0xFB, 0xE2,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C,
  0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE7, 0xEF, 0xBF, 0x3E, 0x78, 0xF0, 0x83, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xDF, 0xC0, 0x3C, 0x0F, 0xC0, 0x20, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF1,
  0xF8, 0x06, 0x03, 0xF0, 0x10, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0xC0, 0x0F, 0xC3, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1D, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x9F,
  0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x3E, 0x01,
  0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xF0, 0x78, 0x07, 0xC3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x08, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x20, 0x03, 0xE1, 0x80, 0x3F, 0x0F,
  0xDF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE3, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x3F, 0x81, 0xF7,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x9F, 0xC3, 0xF0, 0x3E, 0x3F, 0x00, 0xF1,
  0xF8, 0x07, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x07,
  0xC1, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x7C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x03,
  0xE0, 0x7C, 0x3F, 0x01, 0xF3, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xF7, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0x7C,
  0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x3F, 0x0F, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8,
  0x3E, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x7E, 0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFB,
  0xC0, 0x7F, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0x81, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x78, 0x0C, 0x00, 0x00, 0x60, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x03, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xF3,
  0xF8, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0x80, 0x7C,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x60, 0x1E, 0x3C, 0x07, 0xFC, 0x1C, 0x70, 0x1F, 0xFC, 0x39, 0xE0, 0xFF,
  0xF0, 0x73, 0x81, 0xE1, 0xE0, 0xEF, 0x07, 0x83, 0xC1, 0xDE, 0x1E, 0x07,
  0x83, 0xB8, 0x3C, 0x0E, 0x07, 0xF0, 0xF0, 0x3C, 0x0F, 0xE1, 0xE0, 0x78,
  0x3F, 0xC3, 0xC0, 0xF0, 0x7F, 0x87, 0x01, 0xC0, 0xEE, 0x0E, 0x07, 0x83,
  0xDC, 0x1C, 0x0F, 0x07, 0x38, 0x38, 0x3E, 0x1E, 0x70, 0x78, 0xFC, 0x78,
  0xF0, 0xFF, 0xBF, 0xE1, 0xE0, 0xFE, 0x3F, 0x83, 0xC0, 0xF8, 0x3E, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xBC, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3C,
  0x07, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xC0,
  0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8,
  0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xEF, 0xC0, 0xFE, 0x01,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x18, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3C, 0x0F, 0xE0, 0x1E, 0x01,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xC0,
  0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x01, 0xFC, 0x0F, 0x83, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x80,
  0x30, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xFE, 0x7C,
  0x03, 0xFE, 0x3E, 0x03, 0xFF, 0x1E, 0x01, 0xFF, 0x8F, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1F, 0x80, 0x1E, 0x07, 0xE0, 0x1F,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x87, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0,
  0x7C, 0x00, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x81,
  0xEF, 0x00, 0x1F, 0xE0, 0x3D, 0xE0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0xF7, 0x80, 0x3D, 0xF0, 0x1E, 0xF0, 0x07, 0xBE, 0x07, 0xDE, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3E, 0x03, 0xCF,
  0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x78, 0xF0, 0x1F, 0x1C, 0x0F, 0x1E, 0x03,
  0xC3, 0x83, 0xC3, 0xC0, 0x78, 0x78, 0x78, 0xF8, 0x0F, 0x0F, 0x1E, 0x1F,
  0x03, 0xE1, 0xE3, 0xC3, 0xC0, 0x7C, 0x3C, 0xF0, 0x78, 0x0F, 0x07, 0x9E,
  0x0F, 0x01, 0xE0, 0xF7, 0x83, 0xE0, 0x3C, 0x1E, 0xF0, 0x7C, 0x0F, 0x83,
  0xFC, 0x0F, 0x01, 0xE0, 0x7F, 0x81, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C, 0x07,
  0x81, 0xFC, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x0F, 0x01,
  0xFE, 0x00, 0xF8, 0x1E, 0xF0, 0x07, 0x80, 0xF7, 0x80, 0x3C, 0x07, 0xBC,
  0x01, 0xE0, 0x3D, 0xF0, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x3C, 0x07,
  0x80, 0xF1, 0xF0, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x3C, 0x3C, 0x1F, 0x03,
  0xE1, 0xF0, 0xF8, 0x1F, 0x0F, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x81,
  0xE1, 0xE0, 0x3C, 0x0F, 0x9F, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xE7,
  0x80, 0xF0, 0x0F, 0xBC, 0x07, 0x80, 0x7D, 0xE0, 0x3C, 0x01, 0xFF, 0x03,
  0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x01, 0xFC, 0x07, 0x80,
  0x0F, 0xE0, 0x3C, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00,
  0x3E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x0F, 0xC0,
  0x78, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0x83, 0xC0, 0x7E, 0x07, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80,
  0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x7F, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3C, 0x0F, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xF0, 0xF8, 0x03,
  0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C,
  0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x1E, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0x80, 0x60, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x20, 0x03, 0xF0, 0xE0, 0x1F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03,
  0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xC0,
  0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x01,
  0xF0, 0x03, 0xCF, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF0, 0x07, 0xCF,
  0x80, 0x7F, 0x00, 0xF8, 0xF8, 0x07, 0xF0, 0x0F, 0x8F, 0x80, 0xFF, 0x00,
  0xF0, 0x78, 0x0F, 0xF0, 0x1F, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x78, 0x1E,
  0xF0, 0x3E, 0x07, 0x81, 0xEF, 0x03, 0xE0, 0x78, 0x3C, 0xF0, 0x3C, 0x07,
  0x83, 0xCF, 0x07, 0xC0, 0x78, 0x78, 0xF0, 0x78, 0x07, 0x87, 0x87, 0x0F,
  0x80, 0x78, 0x78, 0x70, 0xF0, 0x07, 0x8F, 0x07, 0x0F, 0x00, 0x78, 0xF0,
  0x71, 0xF0, 0x07, 0x9E, 0x07, 0x1E, 0x00, 0x79, 0xE0, 0x73, 0xE0, 0x07,
  0xBC, 0x07, 0x3C, 0x00, 0x7B, 0xC0, 0x73, 0xC0, 0x07, 0xBC, 0x07, 0x78,
  0x00, 0x7F, 0x80, 0x77, 0x80, 0x07, 0xF8, 0x07, 0x78, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9E, 0x00,
  0x7C, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x07,
  0x81, 0xE0, 0x3C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xF8,
  0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x21, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x79,
  0xE0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x1C, 0x7C, 0x00,
  0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF9, 0xF1, 0xE1, 0xE3, 0xC3, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xE3, 0xC1, 0xFF, 0x9E, 0x1F, 0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E,
  0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x7E, 0x3C, 0x03, 0xE1, 0xF0, 0x3F,
  0x0F, 0x83, 0xF8, 0x7F, 0x7B, 0xC1, 0xFF, 0x9C, 0x0F, 0xF9, 0xE0, 0x3F,
  0x8F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x3C, 0x01, 0xE7, 0xF8, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF,
  0x07, 0xF8, 0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE3, 0xFE, 0x7E, 0x1E,
  0xFF, 0xE0, 0xF3, 0xFE, 0x07, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x30, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x43, 0xF3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x07, 0xF3, 0xE0, 0x3F, 0xF7,
  0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0,
  0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x07, 0x80, 0x7C, 0x0F, 0x81,
  0xF8, 0x1F, 0x07, 0xF0, 0x3F, 0xBD, 0xE0, 0x3F, 0xFB, 0x80, 0x7F, 0xCF,
  0x00, 0x7F, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F,
  0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x07,
  0xDE, 0x03, 0xE7, 0x83, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x02, 0x1F, 0x87, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xE6, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x3C, 0x07, 0xFE,
  0x78, 0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1E,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xE0, 0xF0, 0x0F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0xFE, 0x07, 0xF7, 0xFC, 0x07, 0xFE, 0xF0, 0x0F, 0xF9,
  0xE0, 0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x20, 0x07, 0xC0, 0x70, 0x1F, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x1C, 0x01, 0xE7, 0xF8, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8,
  0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0x87, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x10, 0x78,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xC0, 0x07,
  0xBE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xDF,
  0x00, 0x3E, 0x7C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x03, 0x8F, 0xE0, 0xFF,
  0x03, 0xCF, 0xF8, 0xFF, 0xC1, 0xEF, 0xFE, 0xFF, 0xE0, 0xFF, 0x1F, 0xF1,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x3E, 0x03, 0xF0, 0x3E, 0x3F, 0x01, 0xF0,
  0x1F, 0x1F, 0x00, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0x07, 0x87, 0x80, 0x7C,
  0x07, 0xC3, 0xC0, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x01, 0xF1, 0xF0, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x78, 0x78, 0x07, 0xC0, 0x7C, 0x7C, 0x03,
  0xC0, 0x3E, 0x3E, 0x01, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F, 0x0F, 0x00,
  0xF8, 0x07, 0x87, 0x80, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0x03, 0xE3, 0xE0,
  0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x38, 0xFF, 0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xE0, 0xFF,
  0x1F, 0x87, 0xF0, 0x7C, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00,
  0xFB, 0xC0, 0x1E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE3, 0xFC,
  0x01, 0xE7, 0xFE, 0x01, 0xEF, 0xFE, 0x01, 0xFE, 0x3F, 0x01, 0xF8, 0x1F,
  0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0xF3, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1E, 0x7F, 0xC0, 0x1E, 0x3F, 0x80, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xE3, 0xC1,
  0xFF, 0x9E, 0x1F, 0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0xC7, 0x80, 0x7E, 0x3C, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x83,
  0xF8, 0x7F, 0x7F, 0xC1, 0xFF, 0xBC, 0x0F, 0xF9, 0xE0, 0x3F, 0x8F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x83, 0x8F, 0xC3, 0xCF, 0xE1,
  0xEF, 0xE0, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x83, 0x87, 0xC0,
  0x21, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x80, 0x3E, 0x3C, 0x7F,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC8, 0x3F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x01, 0xE1,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xE1, 0xF0, 0x7F, 0x0F, 0xCF, 0x78, 0x7F, 0xF7, 0x81, 0xFF,
  0x3C, 0x07, 0xF1, 0xE0, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0,
  0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x7C, 0x78,
  0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0xFC, 0x07, 0xFC,
  0x07, 0xE0, 0x3D, 0xE0, 0x7F, 0x03, 0xEF, 0x03, 0xF8, 0x1E, 0x78, 0x3D,
  0xC1, 0xF3, 0xC1, 0xFE, 0x0F, 0x1E, 0x0E, 0xF0, 0x78, 0xF0, 0xF7, 0x87,
  0xC7, 0x87, 0x3C, 0x3C, 0x3C, 0x79, 0xE3, 0xE1, 0xE3, 0xCF, 0x1E, 0x0F,
  0x3C, 0x79, 0xF0, 0x79, 0xE3, 0xCF, 0x03, 0xCE, 0x1E, 0x78, 0x1E, 0xF0,
  0xF7, 0xC0, 0xF7, 0x07, 0xBC, 0x07, 0xF8, 0x3D, 0xE0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF,
  0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x03,
  0xC0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x78,
  0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00,
  0x78, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x17, 0xFE, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 33, 12, 1, -32 },
  { 51, 14, 11, 18, 5, -32 },
  { 71, 25, 32, 26, 1, -32 },
  { 171, 21, 37, 22, 1, -34 },
  { 269, 29, 33, 34, 3, -33 },
  { 389, 25, 33, 27, 1, -33 },
  { 493, 6, 11, 10, 5, -32 },
  { 502, 15, 39, 13, 1, -32 },
  { 576, 14, 39, 13, -3, -32 },
  { 645, 19, 19, 22, 4, -34 },
  { 691, 19, 22, 24, 3, -27 },
  { 744, 9, 11, 11, -2, -5 },
  { 757, 11, 4, 13, 1, -14 },
  { 763, 6, 7, 11, 1, -6 },
  { 769, 22, 32, 16, -2, -32 },
  { 857, 20, 33, 22, 2, -33 },
  { 940, 14, 32, 22, 5, -32 },
  { 996, 23, 33, 22, -1, -33 },
  { 1091, 22, 33, 22, 0, -33 },
  { 1182, 22, 32, 22, 0, -32 },
  { 1270, 21, 32, 22, 1, -32 },
  { 1354, 21, 33, 22, 2, -33 },
  { 1441, 22, 32, 22, 2, -32 },
  { 1529, 21, 33, 22, 1, -33 },
  { 1616, 21, 33, 22, 1, -33 },
  { 1703, 10, 26, 11, 0, -25 },
  { 1736, 12, 31, 11, -2, -25 },
  { 1783, 20, 22, 24, 2, -27 },
  { 1838, 19, 13, 24, 3, -22 },
  { 1869, 19, 22, 24, 3, -27 },
  { 1922, 17, 34, 18, 2, -33 },
  { 1995, 31, 36, 34, 2, -32 },
  { 2135, 24, 32, 24, -3, -32 },
  { 2231, 23, 32, 25, 1, -32 },
  { 2323, 23, 33, 24, 3, -33 },
  { 2418, 25, 32, 27, 1, -32 },
  { 2518, 22, 32, 21, 1, -32 },
  { 2606, 22, 32, 20, 1, -32 },
  { 2694, 25, 33, 28, 3, -33 },
  { 2798, 27, 32, 28, 1, -32 },
  { 2906, 18, 32, 14, -1, -32 },
  { 2978, 20, 41, 12, -7, -32 },
  { 3081, 26, 32, 23, 1, -32 },
  { 3185, 16, 32, 20, 1, -32 },
  { 3249, 35, 32, 35, 1, -32 },
  { 3389, 29, 32, 29, 1, -32 },
  { 3505, 25, 33, 29, 3, -33 },
  { 3609, 23, 32, 23, 1, -32 },
  { 3701, 25, 41, 29, 3, -33 },
  { 3830, 23, 32, 24, 1, -32 },
  { 3922, 22, 33, 21, 0, -33 },
  { 4013, 20, 32, 20, 4, -32 },
  { 4093, 25, 32, 27, 3, -32 },
  { 4193, 23, 32, 23, 4, -32 },
  { 4285, 36, 32, 36, 4, -32 },
  { 4429, 28, 32, 22, -2, -32 },
  { 4541, 21, 32, 21, 4, -32 },
  { 4625, 24, 32, 21, -1, -32 },
  { 4721, 18, 39, 13, -1, -32 },
  { 4809, 8, 32, 17, 5, -32 },
  { 4841, 17, 39, 13, -3, -32 },
  { 4924, 21, 19, 23, 1, -32 },
  { 4974, 17, 3, 16, -4, 4 },
  { 4981, 7, 7, 13, 7, -34 },
  { 4988, 21, 25, 24, 2, -25 },
  { 5054, 21, 34, 24, 1, -34 },
  { 5144, 17, 25, 19, 2, -25 },
  { 5198, 23, 34, 24, 2, -34 },
  { 5296, 18, 25, 21, 2, -25 },
  { 5353, 24, 45, 14, -5, -34 },
  { 5488, 23, 36, 24, 0, -25 },
  { 5592, 21, 34, 24, 1, -34 },
  { 5682, 11, 33, 11, 1, -33 },
  { 5728, 18, 44, 11, -6, -33 },
  { 5827, 22, 34, 21, 1, -34 },
  { 5921, 11, 34, 11, 1, -34 },
  { 5968, 33, 25, 36, 1, -25 },
  { 6072, 21, 25, 24, 1, -25 },
  { 6138, 19, 25, 23, 2, -25 },
  { 6198, 24, 36, 24, -2, -25 },
  { 6306, 21, 36, 24, 2, -25 },
  { 6401, 17, 25, 16, 1, -25 },
  { 6455, 18, 25, 18, 0, -25 },
  { 6512, 14, 30, 14, 2, -30 },
  { 6565, 21, 24, 24, 2, -24 },
  { 6628, 20, 24, 20, 2, -24 },
  { 6688, 29, 24, 30, 3, -24 },
  { 6775, 24, 24, 20, -2, -24 },
  { 6847, 26, 35, 20, -4, -24 },
  { 6961, 19, 24, 18, -1, -24 },
  { 7018, 17, 39, 15, 1, -32 },
  { 7101, 4, 45, 22, 9, -34 },
  { 7124, 17, 39, 15, -2, -32 },
  { 7207, 20, 6, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC45PT7B_H_
