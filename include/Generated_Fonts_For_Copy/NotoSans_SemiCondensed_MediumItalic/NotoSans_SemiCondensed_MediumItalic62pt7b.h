#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0x87, 0xF3, 0xF8, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3E, 0x0F,
  0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xDC, 0xFC, 0x07, 0xF1, 0xE0, 0xC0, 0x3F, 0x0F, 0x02, 0x01,
  0xF8, 0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0xFC, 0x1C, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x07, 0xF3, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x77, 0xF8, 0x00, 0x03, 0x9F,
  0xC0, 0x00, 0x3C, 0x7F, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0x0E, 0x0F, 0xC0,
  0x00, 0x70, 0x7E, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x3C, 0x3F, 0x0C, 0x01,
  0xE3, 0xF8, 0x78, 0x0E, 0x3F, 0x83, 0xF8, 0x77, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0x0F, 0x8F, 0x83, 0xF8, 0xF8, 0x1F, 0x0F, 0x8F, 0xFC, 0xF8, 0x1F, 0x1F,
  0x1F, 0xFE, 0xF8, 0x3E, 0x3E, 0x3F, 0xFE, 0xFC, 0x7E, 0x3E, 0x3F, 0x3F,
  0x7F, 0xFC, 0x7C, 0x7C, 0x1F, 0x7F, 0xF8, 0xFC, 0xFC, 0x1F, 0x3F, 0xF8,
  0xF8, 0xF8, 0x1F, 0x1F, 0xE1, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF1, 0xF0,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x1F, 0x00,
  0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x03, 0xF1, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x0F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0x07, 0xFF, 0xF0, 0x0F, 0xE1, 0xFE, 0x7E, 0x01,
  0xF8, 0x7F, 0x8F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x1F, 0x80, 0x1F, 0x9F, 0xC3, 0xF0,
  0x03, 0xFB, 0xF0, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0x83,
  0xF0, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0x80, 0x7F,
  0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xF8, 0x07, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x78, 0x01, 0xC0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0x7F, 0xEF, 0x00, 0x3F, 0xFF,
  0x9F, 0xE3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03,
  0xF1, 0xF0, 0x03, 0xF8, 0xF8, 0x07, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0x00,
  0x78, 0x0F, 0xC0, 0x1C, 0x07, 0xE0, 0x04, 0x01, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xDF,
  0xF3, 0xF1, 0xFC, 0x7E, 0x1E, 0x0F, 0xC3, 0x83, 0xF8, 0x20, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0x80, 0x7F, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x1C, 0x00, 0x7F,
  0x00, 0x40, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC2, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x30, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x80,
  0x00, 0x7F, 0x03, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xDE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x1F, 0xFC, 0x03, 0xF3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xEF,
  0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x3F,
  0x8F, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF7, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xE1, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x7F,
  0xE1, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFC, 0x07,
  0xFF, 0xCF, 0xC0, 0x3F, 0xF9, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x08, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC3, 0xC0, 0x3F, 0x86, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xFF, 0x07, 0xC7,
  0xE0, 0x1F, 0xFF, 0xC0, 0xF8, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x3E, 0x01,
  0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x1F, 0x01, 0xF7, 0xC0, 0xF8, 0x03, 0xE0,
  0x3E, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x07, 0xC0, 0x1F, 0x00, 0xFF,
  0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xDF, 0x03,
  0xE0, 0x1F, 0x00, 0xFB, 0xE0, 0xF8, 0x03, 0xE0, 0x1E, 0x78, 0x1F, 0x00,
  0x7C, 0x07, 0xCF, 0x03, 0xE0, 0x1F, 0x80, 0xF9, 0xE0, 0x7C, 0x03, 0xE0,
  0x3E, 0x3C, 0x0F, 0x80, 0xFC, 0x07, 0xC7, 0x81, 0xF8, 0x3F, 0xC1, 0xF0,
  0xF0, 0x1F, 0x0F, 0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xCF, 0xFF, 0x83, 0xE0,
  0x7F, 0xF9, 0xFF, 0xE0, 0x7C, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0x80, 0x3F,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x08, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x04, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE0,
  0x07, 0xFC, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x07, 0xFF, 0xC3, 0xF8, 0x01,
  0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0xE1, 0xF8,
  0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x7F,
  0x80, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xCF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F,
  0x9F, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xF8, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0xFC, 0x01,
  0xFB, 0xE0, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xFC, 0x01,
  0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x03,
  0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xE1, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x07,
  0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0xC0, 0x1F,
  0x80, 0xF9, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xF9, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFB, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0xFC,
  0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0x01, 0xF9,
  0xF8, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F,
  0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0x80, 0x0F,
  0xDF, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF8,
  0x07, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xFC,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x04, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x82, 0x00,
  0x01, 0xFC, 0x06, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF1, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x7E, 0x00,
  0x3F, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xDF, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0x01, 0xF8,
  0x07, 0xE7, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0xF8, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x3E, 0x07, 0xF0, 0x07,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x81, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x0F, 0xDF, 0x80,
  0x00, 0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0x8F, 0x80, 0x3F, 0xFF, 0x3E, 0x01, 0xFF, 0xFD, 0xF8, 0x0F,
  0xF9, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFB, 0xE0,
  0x0F, 0xFF, 0xCF, 0x80, 0x1F, 0xFC, 0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE3, 0xFF, 0x00, 0x3F,
  0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0x80, 0xFF, 0xE3,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x83, 0xFE, 0x00, 0xFC,
  0x1F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0x83, 0xFF, 0x07, 0xF8,
  0x1F, 0x7F, 0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xC0, 0x7C,
  0x3F, 0xFC, 0x03, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xF0, 0xF0, 0x1F, 0xE0, 0x08, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x02, 0x07, 0xF8, 0x07, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFF,
  0xC7, 0xF0, 0x00, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFD, 0xF8, 0x00, 0xFF,
  0xFE, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0x3F, 0x81, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF7,
  0xC0, 0x03, 0xFF, 0xF3, 0xE0, 0x00, 0xFF, 0xE1, 0xF0, 0x00, 0x3F, 0xE0,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x3F, 0xC7, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x20, 0x7F, 0x80, 0x38, 0x0F, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC,
  0x08, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0x00, 0x1F, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0x3E, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0x9F, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFF, 0xC0,
  0x1F, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xDF, 0x80, 0x0F, 0xFF, 0x9F, 0x80,
  0x07, 0xFF, 0x1F, 0x80, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x20, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x80, 0x01, 0xFC, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xE3, 0xFF, 0x00, 0x3F, 0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xF0, 0x1F, 0xBF,
  0xFF, 0x80, 0xFF, 0xF3, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x3F,
  0x83, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xDF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x7F, 0x9F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x87, 0xFE, 0x03, 0xFF,
  0x00, 0x7C, 0x7F, 0xF8, 0x7F, 0xFC, 0x07, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x81, 0xF7, 0xC7, 0xFB, 0xE3, 0xFC, 0x0F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x87, 0xFE, 0x00, 0x7C, 0x7F, 0xF8,
  0x07, 0xE7, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0x81, 0xF7, 0xE7, 0xFC, 0x0F,
  0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0x7F, 0x07, 0xFC, 0x01, 0xF8, 0x3F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xFE,
  0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x7D, 0xF1, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF0,
  0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0x9F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0x00, 0x1F, 0x87, 0xFC, 0x00,
  0x1F, 0x80, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0x8F, 0x80,
  0x3F, 0xFF, 0x3E, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01,
  0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x03, 0xFF,
  0x01, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0x9F, 0x80,
  0x1F, 0xFC, 0x7E, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x1C, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0xFF, 0x01, 0xF1,
  0xFE, 0x03, 0xF3, 0xFE, 0x03, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xF8, 0x3E, 0x0F, 0xE0, 0x06, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x80, 0x03, 0xF8, 0xE0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x01, 0x1F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0xFF,
  0x81, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x3E, 0x01,
  0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0x0F, 0x80, 0x1F, 0xF0, 0x7C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xE0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x80, 0x1F, 0x9F, 0x80,
  0x3F, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE7, 0xE0, 0x1F, 0xF0,
  0x07, 0xE3, 0xF0, 0x0F, 0x7C, 0x07, 0xF1, 0xF8, 0x0F, 0xBE, 0x03, 0xF0,
  0xFC, 0x07, 0xDF, 0x01, 0xF8, 0x7E, 0x07, 0xCF, 0x81, 0xF8, 0x3F, 0x03,
  0xE7, 0xC0, 0xFC, 0x1F, 0x83, 0xF3, 0xE0, 0xFC, 0x0F, 0xC1, 0xF1, 0xF0,
  0x7E, 0x07, 0xE0, 0xF8, 0xF8, 0x7F, 0x03, 0xF0, 0xF8, 0x7C, 0x3F, 0x01,
  0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x7E, 0x3E,
  0x0F, 0x8F, 0xC0, 0x3F, 0x3F, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x03, 0xE7,
  0xE0, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0xFB, 0xF0, 0x03,
  0xF7, 0xC0, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x02, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC8,
  0x00, 0x0F, 0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 45, 16, 1, -44 },
  { 91, 20, 16, 24, 6, -44 },
  { 131, 35, 44, 35, 1, -44 },
  { 324, 29, 51, 31, 1, -47 },
  { 509, 40, 46, 47, 4, -45 },
  { 739, 35, 46, 37, 1, -45 },
  { 941, 9, 16, 14, 6, -44 },
  { 959, 20, 54, 18, 2, -44 },
  { 1094, 21, 55, 18, -5, -45 },
  { 1239, 25, 26, 30, 6, -47 },
  { 1321, 28, 30, 32, 3, -37 },
  { 1426, 13, 15, 15, -3, -7 },
  { 1451, 16, 5, 18, 1, -19 },
  { 1461, 8, 9, 15, 1, -8 },
  { 1470, 31, 44, 23, -3, -44 },
  { 1641, 28, 46, 31, 2, -45 },
  { 1802, 19, 44, 31, 7, -44 },
  { 1907, 31, 45, 31, -1, -45 },
  { 2082, 30, 46, 31, 0, -45 },
  { 2255, 30, 44, 31, 0, -44 },
  { 2420, 30, 45, 31, 1, -44 },
  { 2589, 28, 46, 31, 3, -45 },
  { 2750, 30, 44, 31, 3, -44 },
  { 2915, 30, 46, 31, 1, -45 },
  { 3088, 28, 46, 31, 2, -45 },
  { 3249, 13, 35, 15, 1, -34 },
  { 3306, 17, 42, 15, -3, -34 },
  { 3396, 28, 30, 32, 3, -37 },
  { 3501, 27, 18, 32, 4, -31 },
  { 3562, 28, 30, 32, 3, -37 },
  { 3667, 23, 46, 24, 3, -45 },
  { 3800, 43, 49, 47, 3, -44 },
  { 4064, 33, 44, 32, -4, -44 },
  { 4246, 33, 44, 34, 1, -44 },
  { 4428, 33, 46, 32, 3, -45 },
  { 4618, 35, 44, 37, 1, -44 },
  { 4811, 31, 44, 29, 1, -44 },
  { 4982, 31, 44, 27, 1, -44 },
  { 5153, 35, 46, 38, 3, -45 },
  { 5355, 38, 44, 38, 1, -44 },
  { 5564, 26, 44, 20, -2, -44 },
  { 5707, 27, 56, 16, -10, -44 },
  { 5896, 37, 44, 32, 1, -44 },
  { 6100, 22, 44, 27, 1, -44 },
  { 6221, 48, 44, 48, 1, -44 },
  { 6485, 40, 44, 40, 1, -44 },
  { 6705, 36, 46, 40, 3, -45 },
  { 6912, 32, 44, 32, 1, -44 },
  { 7088, 36, 56, 40, 3, -45 },
  { 7340, 32, 44, 33, 1, -44 },
  { 7516, 30, 46, 29, 0, -45 },
  { 7689, 28, 44, 28, 5, -44 },
  { 7843, 35, 45, 38, 4, -44 },
  { 8040, 31, 44, 32, 6, -44 },
  { 8211, 49, 44, 49, 6, -44 },
  { 8481, 38, 44, 31, -3, -44 },
  { 8690, 29, 44, 29, 6, -44 },
  { 8850, 34, 44, 29, -2, -44 },
  { 9037, 24, 54, 18, -1, -44 },
  { 9199, 11, 44, 23, 7, -44 },
  { 9260, 24, 54, 18, -4, -44 },
  { 9422, 29, 26, 32, 1, -44 },
  { 9517, 24, 5, 23, -6, 5 },
  { 9532, 10, 9, 17, 9, -47 },
  { 9544, 30, 35, 32, 2, -34 },
  { 9676, 29, 48, 33, 1, -47 },
  { 9850, 25, 35, 26, 2, -34 },
  { 9960, 33, 48, 33, 2, -47 },
  { 10158, 26, 35, 29, 2, -34 },
  { 10272, 33, 62, 19, -7, -47 },
  { 10528, 32, 49, 33, 0, -34 },
  { 10724, 29, 47, 33, 1, -47 },
  { 10895, 16, 46, 15, 1, -46 },
  { 10987, 25, 61, 15, -8, -46 },
  { 11178, 30, 47, 29, 1, -47 },
  { 11355, 16, 47, 15, 1, -47 },
  { 11449, 45, 34, 49, 1, -34 },
  { 11641, 29, 34, 33, 1, -34 },
  { 11765, 28, 35, 32, 2, -34 },
  { 11888, 32, 49, 33, -2, -34 },
  { 12084, 30, 49, 33, 2, -34 },
  { 12268, 24, 34, 23, 1, -34 },
  { 12370, 24, 35, 25, 0, -34 },
  { 12475, 19, 42, 20, 3, -41 },
  { 12575, 29, 34, 33, 3, -33 },
  { 12699, 27, 33, 27, 3, -33 },
  { 12811, 41, 33, 42, 4, -33 },
  { 12981, 33, 33, 28, -3, -33 },
  { 13118, 35, 48, 27, -5, -33 },
  { 13328, 26, 33, 25, -1, -33 },
  { 13436, 24, 54, 21, 1, -44 },
  { 13598, 5, 62, 30, 13, -47 },
  { 13637, 24, 54, 21, -3, -44 },
  { 13799, 28, 9, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC62PT7B_H_
