#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x44, 0x04, 0xC0, 0x55, 0x90, 0x1A, 0x14, 0x7F, 0x24,
  0x24, 0xFE, 0x28, 0x48, 0x50, 0x08, 0x72, 0xDC, 0x30, 0x61, 0xCB, 0xF8,
  0x82, 0x00, 0x73, 0x94, 0x94, 0xAB, 0xF5, 0x15, 0x2D, 0x49, 0xC6, 0x3C,
  0x24, 0x24, 0x38, 0x33, 0x5A, 0xCC, 0xCC, 0x76, 0x58, 0x19, 0x08, 0x84,
  0x23, 0x18, 0xC2, 0x10, 0x31, 0x11, 0x11, 0x13, 0x24, 0xC0, 0x12, 0x47,
  0xCC, 0x50, 0x60, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x2D, 0x60, 0xF0, 0x70,
  0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x20, 0xC0, 0x3C, 0x96, 0x51, 0x45,
  0x1C, 0xD2, 0x70, 0x7E, 0xA6, 0x64, 0x44, 0xC0, 0x7C, 0x90, 0x43, 0x08,
  0x42, 0x30, 0xF8, 0x3C, 0x10, 0x42, 0x38, 0x20, 0xE2, 0xF0, 0x0C, 0x31,
  0xCB, 0x4B, 0x2F, 0xC6, 0x10, 0x3C, 0x82, 0x1E, 0x4C, 0x30, 0xE2, 0xF0,
  0x3D, 0x0C, 0x2C, 0xDA, 0x29, 0xA4, 0xF0, 0xFC, 0x21, 0x84, 0x30, 0x84,
  0x10, 0x80, 0x3C, 0x92, 0x4F, 0x39, 0x3C, 0xF3, 0x78, 0x3D, 0x94, 0x51,
  0x6C, 0xF0, 0x86, 0xF0, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x64, 0x80,
  0x08, 0xD9, 0x07, 0x0C, 0xF8, 0x3E, 0x86, 0x0C, 0x13, 0x60, 0xF1, 0x13,
  0x6C, 0x08, 0x80, 0x3F, 0x30, 0x93, 0x32, 0x9A, 0x4D, 0x2A, 0xB5, 0x2C,
  0x80, 0x3E, 0x00, 0x0C, 0x1C, 0x78, 0xB3, 0x67, 0xD8, 0xA1, 0xC2, 0x3E,
  0x44, 0x8B, 0x27, 0xC8, 0x91, 0x26, 0xF8, 0x3E, 0xC3, 0x04, 0x08, 0x10,
  0x20, 0x60, 0x78, 0x3E, 0x44, 0x8B, 0x16, 0x28, 0x51, 0xA6, 0xF8, 0x3E,
  0x40, 0x83, 0x27, 0x88, 0x10, 0x20, 0xF8, 0x3E, 0x40, 0x83, 0x07, 0xC8,
  0x10, 0x20, 0xC0, 0x3E, 0xC3, 0x04, 0x09, 0xD0, 0xA1, 0x66, 0x78, 0x31,
  0x23, 0x23, 0x62, 0x7E, 0x42, 0x46, 0x46, 0xC4, 0x79, 0x88, 0x42, 0x31,
  0x08, 0xE0, 0x0C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xCE, 0x30, 0x33,
  0x24, 0x2C, 0x78, 0x78, 0x58, 0x48, 0x4C, 0xCC, 0x31, 0x08, 0xC6, 0x21,
  0x08, 0xF8, 0x30, 0xCC, 0x73, 0x1D, 0xCF, 0x52, 0x97, 0xA5, 0xC9, 0x36,
  0xC9, 0x00, 0x31, 0x98, 0x8E, 0x4D, 0x24, 0xB2, 0x51, 0x38, 0x8C, 0xC6,
  0x00, 0x3C, 0xCF, 0x0C, 0x18, 0x30, 0xE1, 0x66, 0x78, 0x3C, 0x4C, 0x8B,
  0x37, 0xC8, 0x10, 0x20, 0xC0, 0x3C, 0xCF, 0x0C, 0x18, 0x30, 0xE1, 0x66,
  0x78, 0x20, 0x60, 0x3C, 0x4C, 0x9B, 0x37, 0xC9, 0x12, 0x26, 0xCC, 0x3D,
  0x86, 0x08, 0x38, 0x20, 0xA6, 0xF0, 0xFC, 0x82, 0x08, 0x61, 0x84, 0x10,
  0x40, 0x62, 0x8D, 0x1E, 0x28, 0x50, 0xA3, 0x44, 0xF0, 0xC7, 0x8B, 0x26,
  0x4D, 0x0A, 0x18, 0x30, 0x40, 0xCC, 0x73, 0x3C, 0xCB, 0x52, 0xD5, 0x39,
  0x4E, 0x73, 0x18, 0xC6, 0x00, 0x33, 0x12, 0x1C, 0x0C, 0x18, 0x1C, 0x24,
  0x64, 0xC6, 0xCD, 0x25, 0x94, 0x61, 0x84, 0x10, 0x40, 0x7E, 0x18, 0x20,
  0xC3, 0x04, 0x10, 0x60, 0xF8, 0x39, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x38,
  0xC9, 0x24, 0x9B, 0x20, 0x38, 0x46, 0x21, 0x08, 0xC4, 0x21, 0x38, 0x10,
  0xA2, 0x91, 0xC4, 0xF8, 0x90, 0x3E, 0xC9, 0x12, 0x2C, 0xC9, 0x9E, 0x00,
  0x30, 0x82, 0x0F, 0x65, 0x94, 0x51, 0x4E, 0xE0, 0x3D, 0x84, 0x10, 0xC1,
  0x07, 0x80, 0x02, 0x04, 0x19, 0xF6, 0x48, 0x91, 0x66, 0x48, 0xF0, 0x3D,
  0x94, 0xDE, 0xC1, 0x07, 0x80, 0x0C, 0x61, 0x0E, 0x10, 0xC2, 0x08, 0x21,
  0x86, 0x10, 0xC0, 0x3E, 0xC9, 0x12, 0x2C, 0xC9, 0x1E, 0x04, 0x19, 0xE0,
  0x30, 0x82, 0x0F, 0x65, 0x94, 0x53, 0x4F, 0x20, 0x23, 0x02, 0x64, 0x44,
  0x4C, 0x08, 0x30, 0x02, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0xE0, 0x30,
  0x40, 0x81, 0x36, 0x8A, 0x1C, 0x28, 0x59, 0x90, 0x32, 0x22, 0x64, 0x44,
  0x4C, 0x3D, 0x99, 0xB6, 0x4D, 0x12, 0x4C, 0x92, 0x2C, 0x98, 0x3D, 0x96,
  0x51, 0x4F, 0x3C, 0x80, 0x3D, 0x94, 0x51, 0xC5, 0x27, 0x80, 0x3D, 0x96,
  0x51, 0x45, 0x3F, 0xA0, 0x82, 0x00, 0x3E, 0xC9, 0x12, 0x2C, 0xC9, 0x9E,
  0x04, 0x08, 0x30, 0x3B, 0x18, 0x84, 0x23, 0x00, 0x7A, 0x10, 0x61, 0x0B,
  0xC0, 0x44, 0xFC, 0x88, 0x88, 0xC0, 0x4F, 0x28, 0xA2, 0x9A, 0x4F, 0x00,
  0x8C, 0xE5, 0x6A, 0x73, 0x00, 0x99, 0x9B, 0xAA, 0xAA, 0xCC, 0xCC, 0xCC,
  0x36, 0x28, 0x60, 0xC3, 0x85, 0x33, 0x00, 0x22, 0x4C, 0x91, 0x62, 0x87,
  0x0C, 0x18, 0x21, 0x80, 0x78, 0xC4, 0x44, 0x63, 0xC0, 0x18, 0x8C, 0x42,
  0x61, 0x88, 0x42, 0x18, 0xFF, 0xF8, 0x30, 0xC4, 0x21, 0x04, 0xC4, 0x21,
  0x30, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 3, 5, 1, -9 },
  { 8, 8, 9, 7, 0, -9 },
  { 17, 6, 11, 6, 0, -10 },
  { 26, 8, 9, 10, 1, -9 },
  { 35, 8, 9, 8, 0, -9 },
  { 44, 2, 3, 3, 1, -9 },
  { 45, 5, 11, 4, 0, -9 },
  { 52, 4, 11, 4, -1, -9 },
  { 58, 6, 6, 6, 1, -10 },
  { 63, 5, 7, 7, 1, -8 },
  { 68, 3, 4, 3, -1, -2 },
  { 70, 4, 1, 4, 0, -4 },
  { 71, 2, 2, 3, 0, -2 },
  { 72, 7, 9, 5, -1, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 4, 9, 6, 2, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 6, 9, 6, 0, -9 },
  { 106, 6, 9, 6, 0, -9 },
  { 113, 6, 9, 6, 0, -9 },
  { 120, 6, 9, 6, 1, -9 },
  { 127, 6, 9, 6, 1, -9 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 6, 9, 6, 0, -9 },
  { 148, 3, 7, 3, 0, -7 },
  { 151, 4, 9, 3, -1, -7 },
  { 156, 5, 6, 7, 1, -8 },
  { 160, 5, 3, 7, 1, -6 },
  { 162, 5, 6, 7, 1, -8 },
  { 166, 4, 9, 5, 1, -9 },
  { 171, 9, 10, 10, 1, -9 },
  { 183, 7, 9, 7, -1, -9 },
  { 191, 7, 9, 7, 0, -9 },
  { 199, 7, 9, 7, 1, -9 },
  { 207, 7, 9, 8, 0, -9 },
  { 215, 7, 9, 6, 0, -9 },
  { 223, 7, 9, 6, 0, -9 },
  { 231, 7, 9, 8, 1, -9 },
  { 239, 8, 9, 8, 0, -9 },
  { 248, 5, 9, 4, 0, -9 },
  { 254, 6, 12, 3, -2, -9 },
  { 263, 8, 9, 7, 0, -9 },
  { 272, 5, 9, 6, 0, -9 },
  { 278, 10, 9, 10, 0, -9 },
  { 290, 9, 9, 8, 0, -9 },
  { 301, 7, 9, 8, 1, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 7, 11, 8, 1, -9 },
  { 327, 7, 9, 7, 0, -9 },
  { 335, 6, 9, 6, 0, -9 },
  { 342, 6, 9, 6, 1, -9 },
  { 349, 7, 9, 8, 1, -9 },
  { 357, 7, 9, 7, 1, -9 },
  { 365, 10, 9, 10, 1, -9 },
  { 377, 8, 9, 6, -1, -9 },
  { 386, 6, 9, 6, 1, -9 },
  { 393, 7, 9, 6, 0, -9 },
  { 401, 5, 11, 4, 0, -9 },
  { 408, 3, 9, 5, 1, -9 },
  { 412, 5, 11, 4, -1, -9 },
  { 419, 6, 5, 7, 0, -9 },
  { 423, 5, 1, 5, -1, 1 },
  { 424, 2, 2, 4, 2, -10 },
  { 425, 7, 7, 7, 0, -7 },
  { 432, 6, 10, 7, 0, -10 },
  { 440, 6, 7, 5, 0, -7 },
  { 446, 7, 10, 7, 0, -10 },
  { 455, 6, 7, 6, 0, -7 },
  { 461, 6, 13, 4, -1, -10 },
  { 471, 7, 10, 7, 0, -7 },
  { 480, 6, 10, 7, 0, -10 },
  { 488, 4, 10, 3, 0, -10 },
  { 493, 6, 13, 3, -2, -10 },
  { 503, 7, 10, 6, 0, -10 },
  { 512, 4, 10, 3, 0, -10 },
  { 517, 10, 7, 10, 0, -7 },
  { 526, 6, 7, 7, 0, -7 },
  { 532, 6, 7, 7, 0, -7 },
  { 538, 6, 10, 7, 0, -7 },
  { 546, 7, 10, 7, 0, -7 },
  { 555, 5, 7, 5, 0, -7 },
  { 560, 5, 7, 5, 0, -7 },
  { 565, 4, 9, 4, 1, -9 },
  { 570, 6, 7, 7, 1, -7 },
  { 576, 5, 7, 6, 1, -7 },
  { 581, 8, 7, 9, 1, -7 },
  { 588, 7, 7, 6, -1, -7 },
  { 595, 7, 10, 6, -1, -7 },
  { 604, 5, 7, 5, 0, -7 },
  { 609, 5, 11, 4, 0, -9 },
  { 616, 1, 13, 6, 3, -10 },
  { 618, 5, 11, 4, -1, -9 },
  { 625, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC13PT7B_H_
