#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x86, 0xFA, 0xA0, 0x14, 0x57, 0xCA, 0x2B, 0xF5, 0x14,
  0x13, 0xD4, 0xC1, 0x97, 0xC4, 0x40, 0x65, 0x52, 0xA5, 0xAE, 0xA5, 0x52,
  0xC6, 0x38, 0xA2, 0x8C, 0x56, 0x58, 0x9F, 0xE8, 0x12, 0x44, 0x48, 0x88,
  0x44, 0x21, 0x11, 0x13, 0x22, 0x48, 0x27, 0xD9, 0x60, 0x22, 0x2F, 0x22,
  0x78, 0xE0, 0xC0, 0x04, 0x20, 0x84, 0x20, 0x84, 0x30, 0x3B, 0x52, 0x94,
  0xE7, 0x4E, 0x36, 0xA2, 0x26, 0x44, 0x3A, 0x42, 0x11, 0x11, 0x1E, 0x3A,
  0x42, 0x61, 0x04, 0x7E, 0x08, 0xCA, 0x55, 0x7C, 0x42, 0x39, 0x10, 0xE1,
  0x84, 0x7E, 0x1C, 0x84, 0x1E, 0x4B, 0x24, 0x9C, 0xF8, 0x84, 0x42, 0x23,
  0x10, 0x3B, 0x52, 0x67, 0x46, 0x2E, 0x3A, 0x52, 0x97, 0x84, 0x5C, 0x68,
  0x01, 0x80, 0x32, 0x00, 0x24, 0xC0, 0x13, 0xCC, 0x31, 0xF0, 0xF0, 0x8C,
  0x33, 0xC8, 0xE3, 0x26, 0x48, 0x08, 0x1E, 0x21, 0x4D, 0x55, 0xA5, 0xAD,
  0x96, 0x40, 0x3C, 0x0C, 0x31, 0x45, 0x24, 0xF4, 0x71, 0x38, 0x96, 0x5E,
  0x49, 0x24, 0xBC, 0x3A, 0x21, 0x08, 0x42, 0x1E, 0x38, 0x96, 0x51, 0x45,
  0x14, 0xBC, 0x3C, 0x86, 0x1E, 0x41, 0x04, 0x3C, 0x3C, 0x86, 0x10, 0x79,
  0x04, 0x20, 0x3D, 0x08, 0x20, 0x9A, 0x28, 0xBE, 0x22, 0x4D, 0x93, 0xE4,
  0x48, 0x93, 0x44, 0x72, 0x26, 0x44, 0x4E, 0x08, 0x46, 0x21, 0x08, 0x46,
  0x27, 0x00, 0x26, 0x59, 0xE2, 0x87, 0x0A, 0x16, 0x44, 0x22, 0x64, 0x44,
  0x4F, 0x21, 0x99, 0x94, 0xCA, 0xA5, 0x52, 0xC9, 0x69, 0x24, 0x22, 0x65,
  0x4A, 0x95, 0x49, 0x93, 0x46, 0x39, 0x38, 0x61, 0x8E, 0x29, 0xBC, 0x38,
  0xB6, 0x53, 0x79, 0x04, 0x20, 0x39, 0x38, 0x61, 0x8E, 0x29, 0xBC, 0x30,
  0x40, 0x38, 0xB6, 0x52, 0x71, 0x45, 0xA2, 0x3A, 0x10, 0xC3, 0x0C, 0x5E,
  0xF9, 0x18, 0x84, 0x21, 0x18, 0x45, 0x38, 0xA2, 0x8A, 0x29, 0x3C, 0x8E,
  0x29, 0x24, 0xA2, 0x8C, 0x30, 0x89, 0xCC, 0xA6, 0x55, 0x4A, 0xA6, 0x63,
  0x31, 0x98, 0x22, 0x28, 0x70, 0xC1, 0x85, 0x1A, 0x66, 0x8C, 0xB4, 0xC4,
  0x21, 0x18, 0x7C, 0x21, 0x0C, 0x21, 0x0C, 0x3C, 0x32, 0x44, 0x44, 0x88,
  0x8C, 0xA9, 0x55, 0x31, 0x11, 0x12, 0x22, 0x2C, 0x11, 0x8C, 0x98, 0x80,
  0xF0, 0x80, 0x35, 0x24, 0xB2, 0xD9, 0xE0, 0x21, 0x16, 0xD4, 0xA7, 0x36,
  0x3A, 0x11, 0x8C, 0x38, 0x04, 0x13, 0xD2, 0x4B, 0x2D, 0x9A, 0x3A, 0x57,
  0xCC, 0x38, 0x1C, 0x43, 0x88, 0x20, 0x82, 0x18, 0x41, 0x08, 0x00, 0x35,
  0x24, 0xB2, 0xD9, 0xC1, 0x24, 0x60, 0x21, 0x16, 0xD4, 0xA7, 0x33, 0x21,
  0xA4, 0xB4, 0x10, 0x32, 0x22, 0x24, 0x44, 0x80, 0x20, 0x84, 0xD4, 0x61,
  0xCD, 0x26, 0x25, 0x24, 0xB4, 0x5B, 0x6D, 0x49, 0x49, 0xC9, 0x92, 0x5B,
  0x52, 0x9C, 0xCC, 0x3A, 0x53, 0x9D, 0xB8, 0x5B, 0x52, 0x9C, 0xDA, 0x10,
  0x80, 0x35, 0x24, 0xB2, 0xD9, 0xC1, 0x04, 0x10, 0x56, 0x44, 0xC8, 0x74,
  0x63, 0x1E, 0x27, 0x44, 0x4C, 0x60, 0x4D, 0x24, 0x92, 0xD9, 0xC0, 0x9B,
  0xAA, 0xCC, 0xB3, 0x6A, 0xD6, 0xCD, 0x93, 0x00, 0x4A, 0x88, 0xC5, 0x48,
  0x24, 0x92, 0x8A, 0x30, 0xC2, 0x18, 0xC0, 0x71, 0x24, 0xCF, 0x12, 0x22,
  0xC4, 0x44, 0x46, 0xFF, 0xE0, 0x30, 0x84, 0x21, 0x98, 0x84, 0x66, 0x00,
  0xDB,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 4, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 8, 1, -8 },
  { 25, 6, 8, 7, 0, -8 },
  { 31, 2, 3, 2, 1, -8 },
  { 32, 4, 10, 3, 0, -8 },
  { 37, 4, 10, 3, -1, -8 },
  { 42, 5, 4, 5, 1, -8 },
  { 45, 4, 6, 6, 1, -7 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 1, 3, 0, -1 },
  { 51, 6, 8, 4, -1, -8 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 4, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 6, 8, 5, 0, -8 },
  { 92, 5, 8, 5, 1, -8 },
  { 97, 5, 8, 5, 0, -8 },
  { 102, 5, 8, 5, 0, -8 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 4, 7, 3, -1, -6 },
  { 114, 4, 6, 6, 1, -7 },
  { 117, 4, 3, 6, 1, -5 },
  { 119, 4, 6, 6, 1, -7 },
  { 122, 4, 8, 4, 1, -8 },
  { 126, 8, 9, 8, 0, -8 },
  { 135, 6, 8, 6, -1, -8 },
  { 141, 6, 8, 6, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 6, 8, 7, 0, -8 },
  { 158, 6, 8, 5, 0, -8 },
  { 164, 6, 8, 5, 0, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 7, 8, 7, 0, -8 },
  { 183, 4, 8, 4, 0, -8 },
  { 187, 5, 10, 3, -2, -8 },
  { 194, 7, 8, 6, 0, -8 },
  { 201, 4, 8, 5, 0, -8 },
  { 205, 9, 8, 9, 0, -8 },
  { 214, 7, 8, 7, 0, -8 },
  { 221, 6, 8, 7, 1, -8 },
  { 227, 6, 8, 6, 0, -8 },
  { 233, 6, 10, 7, 1, -8 },
  { 241, 6, 8, 6, 0, -8 },
  { 247, 5, 8, 5, 0, -8 },
  { 252, 5, 8, 5, 1, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 6, 8, 6, 1, -8 },
  { 269, 9, 8, 9, 1, -8 },
  { 278, 7, 8, 5, -1, -8 },
  { 285, 5, 8, 5, 1, -8 },
  { 290, 6, 8, 5, 0, -8 },
  { 296, 4, 10, 3, 0, -8 },
  { 301, 2, 8, 4, 1, -8 },
  { 303, 4, 10, 3, -1, -8 },
  { 308, 5, 5, 6, 0, -8 },
  { 312, 4, 1, 4, -1, 1 },
  { 313, 1, 1, 3, 2, -8 },
  { 314, 6, 6, 6, 0, -6 },
  { 319, 5, 8, 6, 0, -8 },
  { 324, 5, 6, 5, 0, -6 },
  { 328, 6, 8, 6, 0, -8 },
  { 334, 5, 6, 5, 0, -6 },
  { 338, 6, 11, 3, -1, -8 },
  { 347, 6, 9, 6, 0, -6 },
  { 354, 5, 8, 6, 0, -8 },
  { 359, 3, 8, 3, 0, -8 },
  { 362, 4, 11, 3, -1, -8 },
  { 368, 6, 8, 5, 0, -8 },
  { 374, 3, 8, 3, 0, -8 },
  { 377, 8, 6, 9, 0, -6 },
  { 383, 5, 6, 6, 0, -6 },
  { 387, 5, 6, 6, 0, -6 },
  { 391, 5, 9, 6, 0, -6 },
  { 397, 6, 9, 6, 0, -6 },
  { 404, 4, 6, 4, 0, -6 },
  { 407, 4, 6, 4, 0, -6 },
  { 410, 4, 7, 4, 0, -7 },
  { 414, 6, 6, 6, 0, -6 },
  { 419, 4, 6, 5, 1, -6 },
  { 422, 7, 6, 7, 1, -6 },
  { 428, 5, 6, 5, 0, -6 },
  { 432, 6, 9, 5, -1, -6 },
  { 439, 4, 6, 4, 0, -6 },
  { 442, 4, 10, 4, 0, -8 },
  { 447, 1, 11, 5, 2, -8 },
  { 449, 5, 10, 4, -1, -8 },
  { 456, 4, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC11PT7B_H_
