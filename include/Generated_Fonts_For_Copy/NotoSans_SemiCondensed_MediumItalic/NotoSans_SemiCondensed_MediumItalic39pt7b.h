#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0x7C, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x1E, 0x71, 0xCE, 0x1C,
  0xE1, 0xCE, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70,
  0x70, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0xE0, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x0E, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3C, 0xC6, 0x1E, 0x30, 0x07, 0x8C, 0x01, 0xE7, 0x00, 0x79, 0x80, 0x1F,
  0x60, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0D, 0xE0, 0x07, 0x3C, 0x01, 0x8F, 0x00, 0x63, 0xC0, 0x18, 0xF2,
  0x06, 0x78, 0xF3, 0xBE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x0F, 0x03,
  0xF8, 0x03, 0x81, 0xFF, 0x01, 0xC0, 0xF1, 0xC0, 0xF0, 0x38, 0x70, 0x38,
  0x0E, 0x1C, 0x1C, 0x07, 0x07, 0x0F, 0x01, 0xC1, 0xC3, 0x80, 0x70, 0x71,
  0xC0, 0x1C, 0x3C, 0xF0, 0x07, 0x0E, 0x38, 0x03, 0xC3, 0x9C, 0x7C, 0x71,
  0xE7, 0x3F, 0x9C, 0x73, 0x9F, 0xE7, 0xF9, 0xCF, 0x3D, 0xFE, 0x73, 0x87,
  0x3E, 0x39, 0xE1, 0xC0, 0x1C, 0x70, 0x70, 0x07, 0x1C, 0x3C, 0x03, 0x8F,
  0x0E, 0x01, 0xC3, 0xC3, 0x80, 0x70, 0xE0, 0xE0, 0x38, 0x38, 0x78, 0x1C,
  0x0E, 0x1C, 0x07, 0x03, 0xCF, 0x03, 0x80, 0xFF, 0x81, 0xC0, 0x1F, 0xC0,
  0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xF1, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x03, 0xCF, 0xBC, 0x1E, 0x3C,
  0x78, 0x79, 0xE1, 0xF3, 0xCF, 0x03, 0xCF, 0x3C, 0x0F, 0xF8, 0xF0, 0x1F,
  0xE3, 0xC0, 0x7F, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xE0, 0xF8, 0x7F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0x3E, 0x07, 0xF8, 0x7C, 0x7D, 0xE7, 0x9E, 0x71,
  0xC7, 0x3C, 0xE3, 0x80, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x01, 0x80, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x41, 0xC0, 0xF1, 0xC0, 0xFD, 0x81, 0x7F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78, 0xF0,
  0x30, 0xF0, 0x10, 0x78, 0x00, 0x40, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xEF,
  0xF8, 0x39, 0xF7, 0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xF0, 0x78, 0xF0,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F,
  0x78, 0x07, 0xB8, 0x07, 0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x01, 0xE3, 0xC0,
  0xF1, 0xE0, 0xF0, 0xF8, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0xF0, 0x3E, 0x07, 0xE1, 0xFE, 0x3F, 0xE7, 0xDC, 0xFB, 0xCF, 0x3C,
  0x43, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0x81, 0xF0, 0x10, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03,
  0xC3, 0xF0, 0x20, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC4, 0x00,
  0xF8, 0xE0, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0E, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x07,
  0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xE0,
  0x78, 0x3C, 0x0E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x80, 0x83, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE2, 0x00, 0xF8,
  0xC0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0x82, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x86, 0x01, 0xEF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC1, 0xE3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1E, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF8, 0xF8, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x3E, 0x1E, 0x1E, 0x07, 0xCF,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0x87, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1E, 0x3C, 0x0F, 0x8F, 0x07, 0xE3, 0xF7, 0xF8, 0x7F, 0xDE, 0x0F, 0xE7,
  0x01, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x81, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x3F, 0x1F, 0x07,
  0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0xE3, 0xFF,
  0xCF, 0x1F, 0x20, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00,
  0x38, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x1C,
  0x0F, 0xF0, 0xE7, 0x07, 0xFE, 0x1C, 0xE1, 0xF1, 0xC3, 0xB8, 0x38, 0x78,
  0x77, 0x0E, 0x0E, 0x0F, 0xE3, 0xC1, 0xC1, 0xF8, 0x70, 0x38, 0x3F, 0x0E,
  0x0F, 0x0E, 0xE1, 0xC1, 0xC1, 0xDC, 0x78, 0x38, 0x3B, 0x8E, 0x0F, 0x0E,
  0x71, 0xE1, 0xE1, 0xCE, 0x1C, 0x7C, 0x71, 0xC3, 0xFF, 0xFE, 0x38, 0x7F,
  0x3F, 0x07, 0x03, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xDE, 0x00, 0x3D, 0xE0, 0x03,
  0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x00, 0xF1, 0xE0, 0x0F,
  0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0xF8, 0x78, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE1, 0xC0,
  0x7C, 0x02, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x06, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF9,
  0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03,
  0xE1, 0xE0, 0x3F, 0x0F, 0x03, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0x3E, 0x07, 0xC0, 0x08, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x3F, 0xCF, 0x81, 0xFF,
  0x3E, 0x07, 0xFC, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1F, 0x00,
  0xF0, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x3C, 0x0F,
  0x80, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E,
  0x78, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x03,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x83, 0xFC, 0x03, 0xDC, 0x0F, 0x70, 0x0F, 0xF0, 0x39, 0xC0, 0x7B,
  0xC0, 0xE7, 0x01, 0xCF, 0x07, 0x9C, 0x0F, 0x3C, 0x1E, 0x70, 0x38, 0xE0,
  0x79, 0xC1, 0xE7, 0x81, 0xC7, 0x07, 0x1E, 0x07, 0x1C, 0x3C, 0x78, 0x3C,
  0x70, 0xE1, 0xE0, 0xF1, 0xE7, 0x8F, 0x03, 0xC7, 0x9C, 0x3C, 0x0E, 0x1E,
  0xF0, 0xF0, 0x78, 0x7B, 0x83, 0xC1, 0xE0, 0xFE, 0x0E, 0x07, 0x83, 0xF0,
  0x78, 0x1E, 0x0F, 0xC1, 0xE0, 0x70, 0x3E, 0x07, 0x83, 0xC0, 0xF8, 0x1E,
  0x0F, 0x03, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x83,
  0xF0, 0x03, 0xC1, 0xF8, 0x01, 0xC0, 0xFC, 0x01, 0xE0, 0x7F, 0x00, 0xF0,
  0x3F, 0x80, 0x78, 0x3F, 0xC0, 0x3C, 0x1E, 0xE0, 0x1C, 0x0F, 0x78, 0x1E,
  0x07, 0x3C, 0x0F, 0x03, 0x9E, 0x07, 0x83, 0xC7, 0x83, 0x81, 0xE3, 0xC3,
  0xC0, 0xF1, 0xE1, 0xE0, 0x70, 0x70, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E,
  0x38, 0x1E, 0x0F, 0x3C, 0x0F, 0x03, 0xDE, 0x07, 0x01, 0xEF, 0x07, 0x80,
  0xF7, 0x83, 0xC0, 0x3B, 0x81, 0xE0, 0x1F, 0xC0, 0xF0, 0x0F, 0xE0, 0x70,
  0x07, 0xF0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFC, 0xFE, 0x0F,
  0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00,
  0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x1E,
  0x03, 0xC1, 0xE0, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFC, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x7E, 0x1F, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x07,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xE0,
  0xF8, 0x04, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC4, 0x01, 0xF0, 0xF0,
  0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x80, 0x71, 0xE0, 0x0E, 0x3C, 0x01,
  0xCF, 0x00, 0x39, 0xE0, 0x07, 0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xBC,
  0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x80, 0xF3, 0xC0, 0x7E, 0x03, 0xCF, 0x03,
  0xF8, 0x0F, 0x3C, 0x0E, 0xE0, 0x78, 0xF0, 0x3B, 0x81, 0xE3, 0xC1, 0xEE,
  0x0F, 0x0F, 0x07, 0x38, 0x3C, 0x3C, 0x3C, 0xE1, 0xE0, 0xF0, 0xE3, 0x87,
  0x83, 0xC7, 0x8E, 0x1E, 0x0F, 0x1C, 0x38, 0xF0, 0x3C, 0xF0, 0xE3, 0xC0,
  0xF3, 0xC3, 0x9E, 0x03, 0xCE, 0x0E, 0x78, 0x0F, 0x78, 0x39, 0xC0, 0x3D,
  0xC0, 0xEF, 0x00, 0xFF, 0x03, 0xBC, 0x03, 0xF8, 0x0E, 0xE0, 0x0E, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x87, 0x80,
  0x0F, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x1C, 0x0F, 0x87, 0x83,
  0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x03, 0x9E, 0x00, 0xF7, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xEF, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x1E, 0x03, 0x83,
  0x81, 0xE0, 0xE0, 0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xE7, 0x80, 0x39,
  0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xF3,
  0xC7, 0x9E, 0x3C, 0x70, 0x01, 0xF8, 0xE0, 0xFF, 0xBC, 0x3F, 0xF7, 0x07,
  0xC7, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x7C,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xF0,
  0x1E, 0x3E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x3F, 0x0F, 0x0F, 0xC1, 0xFF,
  0xB8, 0x1F, 0xE7, 0x01, 0xF9, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xCF, 0xC0, 0xF7, 0xF8, 0x7B, 0xFE, 0x1F, 0xC7, 0xC7,
  0xE0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x38, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E,
  0x78, 0x0F, 0x1F, 0x07, 0xCF, 0xC3, 0xE3, 0xFF, 0xF0, 0xE7, 0xF8, 0x38,
  0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0x82, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x18, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xCF, 0x01, 0xFF,
  0x78, 0x1F, 0xFB, 0x80, 0xF8, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07,
  0x80, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x80, 0xFF, 0xDC, 0x03, 0xFC, 0xE0,
  0x0F, 0xCF, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x0F, 0x0F, 0x1E,
  0x07, 0x3E, 0x07, 0x3C, 0x0F, 0x3C, 0x1F, 0x78, 0x7E, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xC0, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFA, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x70, 0x3F, 0xEF, 0x07, 0xFE, 0xE0, 0x7C, 0x7E, 0x0F, 0x83, 0xE1,
  0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F,
  0x83, 0xC0, 0xF8, 0x3C, 0x1F, 0x83, 0xC3, 0xF0, 0x3F, 0xFF, 0x01, 0xFE,
  0xF0, 0x0F, 0xCF, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0xC0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF,
  0xC0, 0xF7, 0xF8, 0x7B, 0xFF, 0x1F, 0xC7, 0xC7, 0xE0, 0xF1, 0xF0, 0x3C,
  0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x9E, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x03, 0x81,
  0xF0, 0x78, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x7C,
  0x07, 0x9F, 0x00, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0,
  0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0E, 0x3F, 0x0F, 0xE0, 0xE7, 0xF9, 0xFE,
  0x1E, 0xFF, 0xBF, 0xF1, 0xFC, 0x7F, 0x0F, 0x1F, 0x07, 0xE0, 0xF1, 0xF0,
  0x7C, 0x0F, 0x1E, 0x07, 0xC0, 0xF3, 0xE0, 0x78, 0x0F, 0x3C, 0x07, 0x80,
  0xF3, 0xC0, 0x78, 0x1E, 0x3C, 0x07, 0x01, 0xE3, 0x80, 0xF0, 0x1E, 0x78,
  0x0F, 0x01, 0xE7, 0x80, 0xF0, 0x1E, 0x78, 0x0F, 0x03, 0xC7, 0x81, 0xE0,
  0x3C, 0x70, 0x1E, 0x03, 0xCF, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0x8F,
  0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x07, 0x80, 0x07, 0x1F, 0x80, 0xE7, 0xF8,
  0x3D, 0xFF, 0x87, 0xF1, 0xF0, 0xFC, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78,
  0xF8, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3,
  0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0x3E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x70, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1F,
  0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0x8F, 0xC0,
  0x39, 0xFE, 0x03, 0xBF, 0xE0, 0x7F, 0x1F, 0x07, 0xE0, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0,
  0x3C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0xFF, 0x03, 0xDF, 0xE0, 0x3C,
  0xFC, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0xE0, 0xFF, 0xBC, 0x3F, 0xF7, 0x07, 0xC7, 0xE1, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC3,
  0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xEF, 0x01,
  0xF9, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x3E, 0x1C, 0xF8, 0x7B, 0xF0, 0xFF, 0x21, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xF0, 0x21,
  0xE0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79,
  0x81, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xFF, 0xFF, 0xEF, 0xFE, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x1E,
  0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0,
  0x7C, 0x3C, 0x3F, 0x0F, 0xFD, 0xC3, 0xFE, 0xF0, 0x7F, 0x3C, 0x00, 0xF0,
  0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE3, 0x81, 0xE1,
  0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x78, 0x1E, 0x3C, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xFC,
  0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7B, 0xC1, 0xF8, 0x1E, 0xF0, 0x7E, 0x0F,
  0x3C, 0x1F, 0x83, 0xCF, 0x0E, 0xE1, 0xE3, 0xC3, 0xB8, 0x78, 0x71, 0xEE,
  0x1C, 0x1C, 0x73, 0x8F, 0x07, 0x3C, 0xE3, 0x81, 0xCE, 0x39, 0xE0, 0x73,
  0x8E, 0x78, 0x1D, 0xC3, 0x9C, 0x07, 0x70, 0xEF, 0x01, 0xFC, 0x3B, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0xF0,
  0x78, 0x07, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x70, 0x01, 0xF3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3C,
  0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x38, 0x1E, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xBF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x01,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 28, 10, 1, -28 },
  { 36, 12, 10, 15, 4, -28 },
  { 51, 22, 28, 22, 1, -28 },
  { 128, 18, 32, 19, 1, -30 },
  { 200, 26, 28, 29, 2, -28 },
  { 291, 22, 28, 23, 1, -28 },
  { 368, 6, 10, 9, 4, -28 },
  { 376, 13, 34, 11, 1, -28 },
  { 432, 13, 34, 11, -3, -28 },
  { 488, 16, 17, 19, 4, -30 },
  { 522, 17, 19, 20, 2, -23 },
  { 563, 8, 10, 10, -2, -5 },
  { 573, 10, 3, 12, 1, -12 },
  { 577, 6, 5, 10, 0, -5 },
  { 581, 19, 28, 14, -2, -28 },
  { 648, 17, 28, 19, 2, -28 },
  { 708, 12, 28, 19, 5, -28 },
  { 750, 20, 28, 19, -1, -28 },
  { 820, 19, 28, 19, 0, -28 },
  { 887, 19, 28, 19, 0, -28 },
  { 954, 18, 28, 19, 1, -28 },
  { 1017, 18, 28, 19, 2, -28 },
  { 1080, 19, 28, 19, 2, -28 },
  { 1147, 18, 28, 19, 1, -28 },
  { 1210, 18, 28, 19, 1, -28 },
  { 1273, 9, 21, 10, 0, -21 },
  { 1297, 11, 26, 10, -2, -21 },
  { 1333, 17, 18, 20, 2, -23 },
  { 1372, 17, 11, 20, 2, -19 },
  { 1396, 17, 18, 20, 2, -23 },
  { 1435, 14, 28, 15, 2, -28 },
  { 1484, 27, 31, 30, 2, -28 },
  { 1589, 20, 28, 20, -2, -28 },
  { 1659, 20, 28, 21, 1, -28 },
  { 1729, 21, 28, 20, 2, -28 },
  { 1803, 21, 28, 23, 1, -28 },
  { 1877, 19, 28, 18, 1, -28 },
  { 1944, 19, 28, 17, 1, -28 },
  { 2011, 22, 28, 24, 2, -28 },
  { 2088, 24, 28, 24, 1, -28 },
  { 2172, 16, 28, 12, -1, -28 },
  { 2228, 17, 36, 10, -6, -28 },
  { 2305, 23, 28, 20, 1, -28 },
  { 2386, 14, 28, 17, 1, -28 },
  { 2435, 30, 28, 31, 1, -28 },
  { 2540, 25, 28, 25, 1, -28 },
  { 2628, 22, 28, 25, 2, -28 },
  { 2705, 20, 28, 20, 1, -28 },
  { 2775, 22, 35, 25, 2, -28 },
  { 2872, 20, 28, 21, 1, -28 },
  { 2942, 19, 28, 18, 0, -28 },
  { 3009, 18, 28, 18, 3, -28 },
  { 3072, 22, 28, 24, 2, -28 },
  { 3149, 19, 28, 20, 4, -28 },
  { 3216, 30, 28, 31, 4, -28 },
  { 3321, 24, 28, 19, -2, -28 },
  { 3405, 18, 28, 18, 4, -28 },
  { 3468, 21, 28, 18, -1, -28 },
  { 3542, 15, 34, 12, -1, -28 },
  { 3606, 8, 28, 14, 4, -28 },
  { 3634, 15, 34, 12, -3, -28 },
  { 3698, 18, 17, 20, 1, -28 },
  { 3737, 15, 3, 14, -4, 3 },
  { 3743, 6, 6, 11, 6, -30 },
  { 3748, 19, 21, 20, 1, -21 },
  { 3798, 18, 30, 21, 1, -30 },
  { 3866, 16, 21, 16, 1, -21 },
  { 3908, 21, 30, 21, 1, -30 },
  { 3987, 16, 21, 18, 1, -21 },
  { 4029, 20, 39, 12, -4, -30 },
  { 4127, 20, 30, 21, 0, -21 },
  { 4202, 18, 30, 21, 1, -30 },
  { 4270, 10, 29, 10, 1, -29 },
  { 4307, 16, 38, 10, -5, -29 },
  { 4383, 19, 30, 18, 1, -30 },
  { 4455, 10, 30, 10, 1, -30 },
  { 4493, 28, 21, 31, 1, -21 },
  { 4567, 19, 21, 21, 0, -21 },
  { 4617, 18, 21, 20, 1, -21 },
  { 4665, 20, 30, 21, -1, -21 },
  { 4740, 19, 30, 21, 1, -21 },
  { 4812, 15, 21, 14, 1, -21 },
  { 4852, 15, 21, 16, 0, -21 },
  { 4892, 12, 26, 12, 2, -26 },
  { 4931, 18, 21, 21, 2, -21 },
  { 4979, 17, 21, 17, 2, -21 },
  { 5024, 26, 21, 26, 2, -21 },
  { 5093, 21, 21, 17, -2, -21 },
  { 5149, 22, 30, 17, -3, -21 },
  { 5232, 17, 21, 15, -1, -21 },
  { 5277, 16, 34, 13, 0, -28 },
  { 5345, 3, 39, 19, 8, -30 },
  { 5360, 15, 34, 13, -2, -28 },
  { 5424, 17, 6, 20, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC39PT7B_H_
