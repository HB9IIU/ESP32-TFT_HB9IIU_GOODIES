#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0,
  0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x87,
  0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xBD,
  0xFC, 0x01, 0xFE, 0x3C, 0x1C, 0x01, 0xFC, 0x38, 0x04, 0x03, 0xF8, 0x78,
  0x00, 0x03, 0xF8, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78,
  0x00, 0x03, 0xF0, 0x70, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x03, 0xF8, 0xF0,
  0x00, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x03, 0x8F,
  0xF0, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x0F, 0x07,
  0xE0, 0x40, 0x0F, 0x0F, 0xE0, 0x70, 0x0F, 0x1F, 0xE0, 0x7E, 0x0E, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x00,
  0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE1, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC3, 0xF0, 0xFF,
  0x0F, 0xC0, 0xFC, 0x3E, 0x1F, 0xF8, 0xFC, 0x0F, 0x87, 0xC3, 0xFF, 0xCF,
  0xC1, 0xF8, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0x0F, 0x8F, 0xFF, 0xE7, 0xF7,
  0xF1, 0xF1, 0xF8, 0x3E, 0x7F, 0xFE, 0x3F, 0x1F, 0x83, 0xF3, 0xFF, 0xC3,
  0xE3, 0xF0, 0x3F, 0x3F, 0xF8, 0x7C, 0x3F, 0x03, 0xF0, 0xFF, 0x0F, 0xC3,
  0xE0, 0x3F, 0x01, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x3E,
  0x00, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x7E,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xC1, 0xFF, 0x7F, 0x00, 0x7E, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x83,
  0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8,
  0x7F, 0x00, 0x7F, 0x8F, 0xE1, 0xFC, 0x00, 0xFE, 0x7F, 0x07, 0xF0, 0x01,
  0xFD, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0xC3, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x07, 0xC0,
  0x03, 0xC0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xF8, 0x78, 0x00, 0x7F,
  0xE7, 0x80, 0x0F, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x70,
  0x0F, 0xFC, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7F, 0x3E, 0x00, 0x0F, 0xE3,
  0xF0, 0x01, 0xFE, 0x1F, 0x00, 0x3F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0x00, 0xFC, 0x00, 0x70, 0x0F, 0xC0, 0x02, 0x00, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF7, 0xFF, 0xF8, 0x04, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0x7F, 0x3F, 0xF3, 0xF1,
  0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x1E, 0x0F, 0xE0, 0xC0, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x00,
  0x3E, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xFC, 0x00,
  0xF8, 0x01, 0xFE, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x10, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x60, 0x00, 0x0F, 0xF0, 0x3C,
  0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x3F, 0xC0, 0xE0,
  0x00, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xF0,
  0x1F, 0xBF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7E, 0x1F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x80, 0x0F, 0xFB, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x03, 0xFC,
  0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0xFC, 0x07, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xF8,
  0x7F, 0x00, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x38, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xE3, 0xFF, 0x1E, 0x00, 0xFF, 0x08, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0x81, 0xF8, 0x01,
  0xFF, 0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0x80, 0x3F,
  0xFF, 0xE0, 0x3E, 0x3F, 0x00, 0xFF, 0xBF, 0xC0, 0x7C, 0x7C, 0x03, 0xF8,
  0x1F, 0x00, 0xF9, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xDF, 0x80, 0xF8, 0x03,
  0xE0, 0x1F, 0xBE, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xFB, 0xF0, 0x3E, 0x00, 0x7C,
  0x01, 0xF7, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xEF, 0x80, 0xF8, 0x03, 0xF0,
  0x0F, 0x9F, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x3E, 0x07, 0xE0, 0x0F, 0x80,
  0x7E, 0x7C, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xF1, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x07, 0xF8, 0x1F,
  0x87, 0xC0, 0x7E, 0x1E, 0xF8, 0x7E, 0x0F, 0x80, 0xFF, 0xFD, 0xFF, 0xF8,
  0x1F, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x7E, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3C, 0x00, 0xFF,
  0x80, 0x01, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x1F, 0xFE, 0x1F, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF8, 0x03,
  0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x00, 0x60, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0xFF,
  0x00, 0x1F, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x07, 0xFF,
  0xF1, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x7F, 0x00,
  0x10, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x02, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0xE0,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF8, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xC7, 0xC0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF0, 0x7E, 0x07, 0xF0, 0x07,
  0xF0, 0x3E, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0xC0,
  0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0x7E,
  0x00, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFF, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF0,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xC0, 0x0F,
  0xDF, 0xC0, 0x03, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0xFE,
  0x00, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x00, 0x0F,
  0xCF, 0xC0, 0x0F, 0xE0, 0x01, 0xFD, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xE0,
  0x1F, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x20, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0xF0, 0x1F, 0xF9,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xE0,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0x87, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x01, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xFE,
  0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x0F, 0x8F, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x03, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x07, 0xDF,
  0x80, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7E,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x7C, 0x01, 0xFF,
  0xF1, 0xF8, 0x07, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0x80, 0xFF, 0xFF,
  0x3E, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0x83,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xFC, 0x3F, 0xF0, 0x01, 0xFC,
  0x7F, 0xF8, 0x01, 0xFC, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFC, 0x01, 0xFB,
  0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0xFF,
  0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0x00, 0x7C, 0x7F, 0xFE, 0x00, 0xFC, 0x3F,
  0xFC, 0x00, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x70, 0x1F, 0xE0, 0x04,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x01, 0x01, 0xFF, 0x03, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x7F,
  0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0xEF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0xFD, 0xF8, 0x01, 0xFF, 0xFE,
  0x7C, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x87, 0xC0, 0x00, 0xFF,
  0x83, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x07, 0xE3, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE3, 0xF8, 0x0F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0x03, 0xFE, 0x01, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x8C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xC1, 0xF0, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0x00,
  0x3F, 0xFF, 0xCF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0,
  0x1F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0x0F,
  0xFE, 0x3F, 0x80, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x0C, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x30, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7E, 0x1F, 0xF8, 0x01, 0xFC, 0x7F, 0xF8, 0x03, 0xFB,
  0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0x3F, 0x81, 0xFF, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x7E, 0x7F, 0x80, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF0, 0x0F, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xDF, 0x07, 0xF7, 0xC1,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7F,
  0xE0, 0x07, 0xE1, 0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF,
  0xE0, 0x3F, 0x7F, 0xFF, 0xC0, 0xFD, 0xF8, 0x7F, 0x81, 0xFF, 0xC0, 0x7F,
  0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0xFC,
  0x00, 0x1F, 0x8F, 0xFF, 0xC0, 0x03, 0xF3, 0xFF, 0xF8, 0x00, 0x7E, 0xFF,
  0xFF, 0x80, 0x1F, 0xBE, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x0F, 0xDF, 0xFF, 0xF0, 0x01,
  0xFB, 0xFF, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xC0,
  0x01, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x01,
  0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFF, 0x07,
  0xE0, 0x03, 0xFE, 0x0F, 0xE0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x7E, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0x87, 0xF0, 0x00, 0x38, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x0F, 0xF0,
  0x1F, 0x8F, 0xF8, 0x07, 0xE7, 0xFE, 0x01, 0xF9, 0xFF, 0x80, 0x7E, 0xFF,
  0xE0, 0x3F, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0x80, 0x78, 0x1F, 0xC0, 0x04, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x20, 0x00, 0x7F, 0x0C, 0x00, 0x3F, 0xC3, 0xE0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x04, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFF, 0x07,
  0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0xF0, 0x3F,
  0xC1, 0xF7, 0xE0, 0x7F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x9F, 0x00, 0xFF,
  0xFE, 0x7E, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0x7C, 0x03, 0xF8, 0xFC, 0x01,
  0xF7, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0x7C, 0x07, 0xF0, 0xFC, 0x03, 0xEF,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xCF, 0xC0,
  0xFE, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0x8F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xF8, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0x8F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xF0, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3,
  0xE0, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0,
  0xFC, 0xFE, 0x00, 0xFC, 0x7C, 0x07, 0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x7C,
  0xFC, 0x00, 0x7C, 0xF8, 0x07, 0xDF, 0x80, 0x07, 0xDF, 0x80, 0x7D, 0xF8,
  0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x80, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x09, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xD0, 0x00, 0x3F, 0xFC,
  0x80, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 49, 17, 1, -48 },
  { 112, 21, 17, 26, 7, -48 },
  { 157, 38, 48, 38, 1, -48 },
  { 385, 32, 55, 33, 1, -51 },
  { 605, 44, 50, 50, 4, -49 },
  { 880, 38, 50, 40, 1, -49 },
  { 1118, 9, 17, 15, 7, -48 },
  { 1138, 22, 59, 19, 2, -48 },
  { 1301, 22, 59, 19, -5, -48 },
  { 1464, 28, 28, 33, 6, -51 },
  { 1562, 29, 32, 35, 4, -40 },
  { 1678, 14, 17, 16, -3, -8 },
  { 1708, 17, 6, 20, 1, -21 },
  { 1721, 9, 10, 16, 1, -9 },
  { 1733, 33, 48, 24, -3, -48 },
  { 1931, 30, 50, 33, 3, -49 },
  { 2119, 21, 48, 33, 8, -48 },
  { 2245, 34, 49, 33, -1, -49 },
  { 2454, 33, 50, 33, 0, -49 },
  { 2661, 33, 48, 33, 0, -48 },
  { 2859, 32, 49, 33, 1, -48 },
  { 3055, 31, 50, 33, 3, -49 },
  { 3249, 31, 48, 33, 4, -48 },
  { 3435, 31, 50, 33, 2, -49 },
  { 3629, 30, 50, 33, 2, -49 },
  { 3817, 14, 38, 17, 1, -37 },
  { 3884, 18, 46, 17, -3, -37 },
  { 3988, 29, 32, 35, 4, -40 },
  { 4104, 29, 19, 35, 4, -33 },
  { 4173, 29, 32, 35, 4, -40 },
  { 4289, 24, 50, 26, 4, -49 },
  { 4439, 47, 54, 51, 3, -48 },
  { 4757, 35, 48, 35, -4, -48 },
  { 4967, 34, 48, 37, 2, -48 },
  { 5171, 35, 50, 35, 4, -49 },
  { 5390, 37, 48, 40, 2, -48 },
  { 5612, 32, 48, 31, 2, -48 },
  { 5804, 32, 48, 30, 2, -48 },
  { 5996, 37, 50, 41, 4, -49 },
  { 6228, 40, 48, 41, 2, -48 },
  { 6468, 27, 48, 21, -2, -48 },
  { 6630, 29, 61, 18, -10, -48 },
  { 6852, 39, 48, 35, 2, -48 },
  { 7086, 23, 48, 29, 2, -48 },
  { 7224, 51, 48, 52, 2, -48 },
  { 7530, 43, 48, 44, 1, -48 },
  { 7788, 38, 50, 43, 4, -49 },
  { 8026, 34, 48, 35, 2, -48 },
  { 8230, 38, 60, 43, 4, -49 },
  { 8515, 33, 48, 36, 2, -48 },
  { 8713, 33, 50, 31, 0, -49 },
  { 8920, 30, 48, 30, 6, -48 },
  { 9100, 38, 49, 41, 4, -48 },
  { 9333, 34, 48, 34, 6, -48 },
  { 9537, 53, 48, 53, 6, -48 },
  { 9855, 42, 48, 33, -4, -48 },
  { 10107, 32, 48, 32, 6, -48 },
  { 10299, 37, 48, 31, -2, -48 },
  { 10521, 26, 59, 20, -1, -48 },
  { 10713, 13, 48, 25, 7, -48 },
  { 10791, 26, 59, 20, -5, -48 },
  { 10983, 32, 29, 34, 1, -48 },
  { 11099, 25, 4, 24, -6, 6 },
  { 11112, 11, 10, 19, 10, -51 },
  { 11126, 31, 38, 35, 3, -37 },
  { 11274, 32, 52, 35, 1, -51 },
  { 11482, 26, 38, 28, 3, -37 },
  { 11606, 34, 52, 35, 3, -51 },
  { 11827, 27, 38, 32, 3, -37 },
  { 11956, 36, 67, 20, -8, -51 },
  { 12258, 34, 53, 35, 0, -37 },
  { 12484, 31, 51, 35, 1, -51 },
  { 12682, 17, 50, 16, 1, -50 },
  { 12789, 27, 66, 16, -9, -50 },
  { 13012, 33, 51, 31, 1, -51 },
  { 13223, 18, 51, 16, 1, -51 },
  { 13338, 49, 37, 53, 1, -37 },
  { 13565, 31, 37, 35, 1, -37 },
  { 13709, 29, 38, 34, 3, -37 },
  { 13847, 35, 53, 35, -2, -37 },
  { 14079, 31, 53, 35, 3, -37 },
  { 14285, 26, 37, 24, 1, -37 },
  { 14406, 26, 38, 27, 0, -37 },
  { 14530, 20, 45, 21, 3, -44 },
  { 14643, 31, 37, 35, 3, -36 },
  { 14787, 29, 36, 29, 4, -36 },
  { 14918, 44, 36, 45, 4, -36 },
  { 15116, 35, 36, 30, -3, -36 },
  { 15274, 39, 52, 29, -6, -36 },
  { 15528, 29, 36, 27, -2, -36 },
  { 15659, 26, 59, 23, 1, -48 },
  { 15851, 6, 67, 32, 14, -51 },
  { 15902, 25, 59, 23, -3, -48 },
  { 16087, 29, 9, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC67PT7B_H_
