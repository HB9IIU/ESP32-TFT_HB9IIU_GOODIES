#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0x1E, 0x07, 0x83, 0xE0, 0x70, 0x00, 0x79, 0xEE, 0x39,
  0xC7, 0x79, 0xEE, 0x39, 0xC7, 0x38, 0xE6, 0x18, 0xC3, 0x00, 0x00, 0xE1,
  0xC0, 0x1C, 0x30, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x86,
  0x00, 0x61, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x1C, 0x38,
  0x03, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x70, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x6E,
  0x1E, 0x62, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1E, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xBC, 0x03, 0x1C,
  0x03, 0x1C, 0x03, 0x3C, 0x83, 0x38, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x38, 0x3F,
  0x80, 0xE0, 0xF7, 0x01, 0xC1, 0xC7, 0x07, 0x07, 0x0E, 0x1C, 0x0E, 0x1C,
  0x38, 0x1C, 0x30, 0xE0, 0x30, 0xE3, 0x80, 0xE1, 0xC7, 0x01, 0xC3, 0x9C,
  0x03, 0x86, 0x73, 0xF7, 0x1C, 0xEF, 0xEF, 0x7B, 0x9C, 0xEF, 0xEE, 0x71,
  0xCF, 0x9C, 0xE3, 0x80, 0x73, 0x87, 0x01, 0xC7, 0x0E, 0x03, 0x8E, 0x1C,
  0x0E, 0x1C, 0x30, 0x38, 0x30, 0xE0, 0x70, 0x61, 0xC1, 0xC0, 0xC7, 0x07,
  0x01, 0xDE, 0x0E, 0x03, 0xF8, 0x38, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0x78, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0x80, 0x78, 0xF0, 0x07, 0x3C, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0xC1, 0xDF, 0x38, 0x7B, 0xC7, 0x8E, 0xF0, 0x7B,
  0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0x70, 0x1F, 0x8E, 0x03, 0xE1, 0xE0, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0x3C, 0x3F, 0xC7, 0xC0, 0x7B, 0x9D, 0xEE, 0x73,
  0x9C, 0xC0, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x02, 0x0E, 0x06, 0x18, 0x0F, 0x30, 0x3F,
  0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F, 0x80, 0x77, 0x01, 0xE7, 0x07, 0x8E,
  0x02, 0x1E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF,
  0xBF, 0xC0, 0x13, 0xDF, 0xF7, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x0F, 0x0E,
  0x0F, 0x1E, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x78, 0x78, 0xF0, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0xE0, 0x7C, 0x3F, 0x0F, 0xE3, 0xDD,
  0xF7, 0x9C, 0xF2, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x0E,
  0x1F, 0x02, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC6, 0x03, 0xE3,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0xBC, 0x03, 0xDC,
  0x01, 0xCE, 0x01, 0xC7, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0xE0,
  0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1D, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x80, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0x80, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x71, 0xE0, 0x77,
  0xF0, 0xFF, 0xF8, 0xFC, 0x7C, 0xF8, 0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF0, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x40,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F,
  0xFF, 0x0F, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x0E,
  0x0E, 0x0F, 0x3E, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C,
  0x78, 0x78, 0x3C, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x38, 0x1E, 0x3C, 0x7E, 0x3F,
  0xEE, 0x1F, 0xDE, 0x0F, 0x9C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0x0F, 0x1F, 0x1F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x78, 0x78, 0xF8, 0x70, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x1F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x60, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x1F, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x38, 0x3F, 0xC7, 0x18, 0x3F, 0xE3, 0x9C, 0x3C, 0x71, 0xCC,
  0x38, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x1C, 0x1C, 0x3B, 0x8E, 0x0E, 0x1D,
  0x87, 0x0E, 0x0C, 0xC3, 0x07, 0x0E, 0xE3, 0x83, 0x87, 0x70, 0xC3, 0xC7,
  0x38, 0x73, 0x67, 0x0C, 0x3F, 0xBF, 0x87, 0x0F, 0x9F, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x0F, 0xC7,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03,
  0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x3C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80, 0x1D,
  0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0x87, 0x81, 0xE1, 0xC3, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0x1F,
  0x83, 0xC0, 0xF0, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0x70, 0x1F, 0x1C, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0x02, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x02, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0x87, 0xE0, 0xF0, 0x3C, 0x1E,
  0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70,
  0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xC0,
  0x1E, 0x38, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x03,
  0xE0, 0xE1, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x0C, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xCF, 0x03, 0xFC, 0xF0, 0x3F,
  0x8F, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x70, 0x78, 0x07, 0x07, 0xC0, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0x1E, 0x00,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1C, 0x1E,
  0x00, 0xE0, 0xF0, 0x0F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC3, 0xC0,
  0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0x83,
  0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xF0,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x09, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x70, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xE1, 0xF0, 0x0E, 0x1E, 0x01, 0xE3, 0xC0,
  0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1D, 0xE0, 0x01, 0xDE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x83, 0x80, 0x70, 0x3C, 0x07, 0x03, 0xC0, 0xF0,
  0x1C, 0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xF7, 0x01, 0xDC,
  0x1E, 0xE0, 0x73, 0x83, 0x9C, 0x0E, 0xF0, 0x73, 0x83, 0x9E, 0x0E, 0x70,
  0x73, 0x83, 0xCE, 0x1C, 0x70, 0x79, 0xC3, 0x9E, 0x0E, 0x38, 0xE3, 0xC1,
  0xC7, 0x1C, 0x78, 0x38, 0xE7, 0x0E, 0x0F, 0x1C, 0xE1, 0xC1, 0xC3, 0xB8,
  0x78, 0x38, 0x77, 0x0F, 0x07, 0x07, 0xC1, 0xE0, 0xE0, 0xF8, 0x38, 0x3C,
  0x1E, 0x07, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x70, 0x3C, 0x00, 0x07, 0x80,
  0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x03, 0xC3, 0xF0, 0x0E, 0x0F, 0xC0, 0x38,
  0x3F, 0x80, 0xE0, 0xEE, 0x07, 0x87, 0xB8, 0x1E, 0x1E, 0xF0, 0x70, 0x73,
  0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x3C, 0x3C, 0x78, 0xF0, 0xF0, 0xE3,
  0x83, 0x83, 0x8E, 0x0E, 0x0F, 0x38, 0x38, 0x3D, 0xE1, 0xE0, 0x77, 0x87,
  0x81, 0xDC, 0x1C, 0x07, 0xF0, 0x70, 0x0F, 0xC3, 0xC0, 0x3F, 0x0F, 0x00,
  0xF8, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x00,
  0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x07,
  0xC1, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0x70,
  0x7C, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x00,
  0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x07,
  0xC1, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78,
  0x78, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x03,
  0xC3, 0x87, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0x70, 0xE0, 0x38,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC3, 0x81, 0xE3,
  0xC0, 0x71, 0xE0, 0x3C, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC1, 0xF0, 0x60, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC6, 0x03, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0,
  0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x3C,
  0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x03, 0x87,
  0x80, 0x78, 0x70, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0x70,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1C, 0xF0, 0x0F, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x70,
  0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0xF0, 0x1C,
  0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x07, 0xB8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x1E, 0xF0, 0x1F,
  0x01, 0xEF, 0x01, 0xF0, 0x1C, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x38,
  0xF0, 0x3F, 0x07, 0x8F, 0x07, 0x70, 0x78, 0x70, 0x77, 0x07, 0x07, 0x0E,
  0x70, 0xF0, 0x70, 0xE7, 0x0E, 0x07, 0x1E, 0x71, 0xE0, 0x71, 0xC7, 0x1C,
  0x07, 0x1C, 0x71, 0xC0, 0x73, 0x87, 0x3C, 0x07, 0x38, 0x73, 0x80, 0x77,
  0x07, 0x78, 0x07, 0x70, 0x77, 0x00, 0x7F, 0x07, 0x70, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0x80, 0x7C, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x0F, 0x01,
  0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00,
  0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x77, 0x00, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x70, 0xE0, 0x03,
  0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x70, 0x1E, 0x01,
  0xE0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0xF8, 0x07, 0x9C, 0x07, 0x8E, 0x03,
  0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0x71, 0xE0, 0x38, 0xE0, 0x1C,
  0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x78, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x03,
  0x70, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38,
  0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF1, 0xC7, 0x8E, 0x1C, 0x70, 0x03, 0xE3, 0x83, 0xF9, 0xC3, 0xFF,
  0xC3, 0xE3, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x78,
  0x0E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3,
  0xC1, 0xF0, 0xF1, 0xF8, 0x7F, 0xFC, 0x3F, 0xDC, 0x0F, 0xCE, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x7C, 0x1E, 0xFE, 0x1D, 0xFF, 0x1F, 0x0F, 0x1E,
  0x0F, 0x3E, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF,
  0xF8, 0xEF, 0xF0, 0xC7, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0x82,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x08, 0x7F, 0xE0, 0xFF,
  0x81, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xE7,
  0x80, 0xFE, 0xF0, 0x3F, 0xFC, 0x0F, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x03, 0x87, 0xE0,
  0x7F, 0xF8, 0x0F, 0xF7, 0x00, 0xFC, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0x3C, 0x3E, 0x7F,
  0xF8, 0xFF, 0xC3, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x08, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1E, 0x20, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF1, 0xC0, 0xFE,
  0x70, 0x7F, 0xF8, 0x3C, 0x3E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78,
  0xF0, 0x1C, 0x3C, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE0, 0xE1, 0xF8, 0x3F, 0xFC, 0x0F, 0xF7,
  0x01, 0xF9, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x82,
  0x03, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x7C, 0x1E, 0xFE, 0x1D, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0,
  0x38, 0xE0, 0x38, 0x07, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x1F, 0xC0, 0xFC, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x0F, 0x8F, 0x0F, 0x07, 0x87,
  0x83, 0x87, 0x81, 0xC7, 0x81, 0xE7, 0x80, 0xF7, 0x80, 0x77, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xBC, 0x07, 0x1E, 0x03, 0x87, 0x03,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x3C, 0x38, 0x1E, 0x00, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x00, 0x1C, 0x7C, 0x3F,
  0x0E, 0x7F, 0x3F, 0x87, 0x7F, 0xBF, 0xE3, 0xE1, 0xF8, 0xF1, 0xE0, 0xF8,
  0x39, 0xF0, 0x78, 0x1C, 0xF0, 0x3C, 0x1E, 0x78, 0x1C, 0x0F, 0x38, 0x1E,
  0x07, 0x9C, 0x0F, 0x03, 0x9E, 0x07, 0x01, 0xCF, 0x03, 0x81, 0xE7, 0x01,
  0xC0, 0xF3, 0x81, 0xE0, 0x73, 0xC0, 0xF0, 0x39, 0xE0, 0x70, 0x1C, 0xF0,
  0x38, 0x1E, 0x70, 0x3C, 0x0F, 0x38, 0x1E, 0x07, 0x00, 0x0E, 0x3E, 0x07,
  0x3F, 0x83, 0xBF, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80,
  0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x3C,
  0x0F, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0E,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0x1F, 0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x1F,
  0x0F, 0x07, 0x83, 0xC3, 0xE0, 0x70, 0xF0, 0x1C, 0x3C, 0x0F, 0x0E, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE3,
  0xE0, 0xF0, 0xF8, 0x7C, 0x3B, 0xFE, 0x0E, 0xFF, 0x03, 0x9F, 0x81, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE3, 0x83, 0xF9, 0xC3, 0xFF, 0xC3,
  0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x0E,
  0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xF0, 0xE1, 0xF8, 0x7F, 0xF8, 0x3F, 0xDC, 0x0F, 0xCE, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x78, 0xE7, 0xC7, 0x7C, 0x3F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x07, 0xF0,
  0x3F, 0xF1, 0xFF, 0x8F, 0x02, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x20, 0x3C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x3F, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xFE, 0x3F, 0x87,
  0xE0, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x0F, 0x1E, 0x07,
  0x8E, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0xC1, 0xF0, 0xE1, 0xF8, 0x7F,
  0xF8, 0x3F, 0xDC, 0x0F, 0xCE, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7,
  0x01, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x70, 0x71, 0xE0, 0xE3,
  0x81, 0xCF, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x3F,
  0x81, 0xE0, 0x77, 0x07, 0xE1, 0xEE, 0x0F, 0xC3, 0x9C, 0x3B, 0x8F, 0x38,
  0x77, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x9C, 0xF1, 0xE7, 0x39, 0xC3, 0x9C,
  0x77, 0x87, 0x38, 0xEE, 0x0E, 0xE1, 0xDC, 0x1D, 0xC3, 0xF0, 0x3B, 0x07,
  0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x00, 0x07, 0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x01, 0xC3, 0x80, 0x3C,
  0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0E, 0x70, 0x03, 0xCF,
  0x00, 0xF1, 0xE0, 0x3C, 0x1C, 0x07, 0x83, 0xC3, 0xE0, 0x78, 0x00, 0x07,
  0x00, 0xF0, 0x70, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0,
  0x78, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0,
  0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00, 0x3B, 0x80, 0x03, 0xB8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x0F,
  0xC0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x1C,
  0x03, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 11, 9, 14, 4, -25 },
  { 46, 19, 25, 20, 1, -25 },
  { 106, 16, 29, 17, 1, -27 },
  { 164, 23, 25, 26, 2, -25 },
  { 236, 19, 25, 21, 1, -25 },
  { 296, 5, 9, 8, 4, -25 },
  { 302, 12, 31, 10, 1, -25 },
  { 349, 12, 31, 10, -3, -25 },
  { 396, 15, 15, 17, 3, -27 },
  { 425, 15, 17, 18, 2, -21 },
  { 457, 8, 9, 9, -2, -4 },
  { 466, 9, 3, 10, 1, -11 },
  { 470, 5, 5, 9, 0, -5 },
  { 474, 18, 25, 13, -2, -25 },
  { 531, 16, 25, 17, 1, -25 },
  { 581, 11, 25, 17, 4, -25 },
  { 616, 18, 25, 17, -1, -25 },
  { 673, 17, 25, 17, 0, -25 },
  { 727, 17, 25, 17, 0, -25 },
  { 781, 16, 25, 17, 1, -25 },
  { 831, 16, 25, 17, 2, -25 },
  { 881, 16, 25, 17, 2, -25 },
  { 931, 16, 25, 17, 1, -25 },
  { 981, 16, 25, 17, 1, -25 },
  { 1031, 8, 19, 9, 0, -19 },
  { 1050, 10, 24, 9, -2, -19 },
  { 1080, 15, 17, 18, 2, -21 },
  { 1112, 15, 10, 18, 2, -17 },
  { 1131, 15, 17, 18, 2, -21 },
  { 1163, 13, 25, 14, 2, -25 },
  { 1204, 25, 28, 27, 1, -25 },
  { 1292, 18, 25, 18, -2, -25 },
  { 1349, 18, 25, 19, 1, -25 },
  { 1406, 18, 25, 18, 2, -25 },
  { 1463, 19, 25, 21, 1, -25 },
  { 1523, 17, 25, 16, 1, -25 },
  { 1577, 17, 25, 16, 1, -25 },
  { 1631, 20, 25, 22, 2, -25 },
  { 1694, 21, 25, 22, 1, -25 },
  { 1760, 14, 25, 11, -1, -25 },
  { 1804, 15, 32, 9, -5, -25 },
  { 1864, 20, 25, 18, 1, -25 },
  { 1927, 12, 25, 15, 1, -25 },
  { 1965, 27, 25, 27, 1, -25 },
  { 2050, 22, 25, 23, 1, -25 },
  { 2119, 20, 25, 23, 2, -25 },
  { 2182, 18, 25, 18, 1, -25 },
  { 2239, 20, 31, 23, 2, -25 },
  { 2317, 17, 25, 19, 1, -25 },
  { 2371, 17, 25, 16, 0, -25 },
  { 2425, 16, 25, 16, 3, -25 },
  { 2475, 20, 25, 21, 2, -25 },
  { 2538, 18, 25, 18, 3, -25 },
  { 2595, 28, 25, 28, 3, -25 },
  { 2683, 22, 25, 17, -2, -25 },
  { 2752, 17, 25, 16, 3, -25 },
  { 2806, 19, 25, 16, -1, -25 },
  { 2866, 14, 31, 10, -1, -25 },
  { 2921, 6, 25, 13, 4, -25 },
  { 2940, 13, 31, 10, -2, -25 },
  { 2991, 16, 15, 18, 1, -25 },
  { 3021, 13, 2, 13, -3, 3 },
  { 3025, 6, 6, 10, 5, -27 },
  { 3030, 17, 19, 18, 1, -19 },
  { 3071, 16, 27, 18, 1, -27 },
  { 3125, 14, 19, 14, 1, -19 },
  { 3159, 19, 27, 19, 1, -27 },
  { 3224, 15, 19, 16, 1, -19 },
  { 3260, 19, 35, 11, -4, -27 },
  { 3344, 18, 27, 19, 0, -19 },
  { 3405, 16, 27, 18, 1, -27 },
  { 3459, 8, 26, 9, 1, -26 },
  { 3485, 13, 34, 9, -4, -26 },
  { 3541, 17, 27, 16, 1, -27 },
  { 3599, 10, 27, 9, 0, -27 },
  { 3633, 25, 19, 28, 1, -19 },
  { 3693, 17, 19, 18, 0, -19 },
  { 3734, 16, 19, 18, 1, -19 },
  { 3772, 18, 27, 18, -1, -19 },
  { 3833, 17, 27, 18, 1, -19 },
  { 3891, 13, 19, 13, 1, -19 },
  { 3922, 14, 19, 14, 0, -19 },
  { 3956, 10, 23, 11, 2, -23 },
  { 3985, 17, 19, 18, 1, -19 },
  { 4026, 15, 19, 15, 2, -19 },
  { 4062, 23, 19, 24, 2, -19 },
  { 4117, 19, 19, 16, -2, -19 },
  { 4163, 20, 27, 15, -3, -19 },
  { 4231, 15, 19, 14, -1, -19 },
  { 4267, 14, 31, 12, 0, -25 },
  { 4322, 3, 35, 17, 7, -27 },
  { 4336, 14, 31, 12, -2, -25 },
  { 4391, 15, 5, 18, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC35PT7B_H_
