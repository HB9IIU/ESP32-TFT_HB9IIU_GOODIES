#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x00, 0x79, 0xEE,
  0x3D, 0xC7, 0x38, 0xEF, 0x1D, 0xC7, 0xB8, 0xE7, 0x1C, 0xC3, 0x98, 0x60,
  0x00, 0x70, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x03, 0x86, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06,
  0x1C, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x30, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x30, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x79, 0x88, 0x38, 0xC0, 0x1C, 0x60,
  0x0E, 0x60, 0x07, 0xB0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xBC, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x63, 0x80,
  0x31, 0xC6, 0x19, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x1F, 0xC0,
  0x38, 0x1F, 0xE0, 0x70, 0x38, 0xE0, 0x70, 0x38, 0xE0, 0xE0, 0x70, 0xE1,
  0xC0, 0x70, 0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x60, 0xE7, 0x80, 0xE1, 0xC7,
  0x00, 0xE1, 0xCE, 0x38, 0xE1, 0xCE, 0xFE, 0xE3, 0x9D, 0xFE, 0x7F, 0xB9,
  0xCE, 0x7F, 0x3B, 0x87, 0x3E, 0x73, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xE7,
  0x0E, 0x01, 0xC7, 0x0E, 0x03, 0x87, 0x0E, 0x03, 0x87, 0x0E, 0x07, 0x07,
  0x1C, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0xB8, 0x1C, 0x03, 0xF8, 0x38, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x78, 0xF0, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x1E, 0x00,
  0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x0F,
  0x3F, 0xE0, 0xE7, 0x8F, 0x1E, 0x78, 0x79, 0xEF, 0x07, 0xBC, 0xE0, 0x3F,
  0x8E, 0x03, 0xF8, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x7F, 0x0F, 0xFF,
  0xF8, 0x7F, 0xE7, 0x83, 0xFC, 0x3C, 0x7B, 0xDC, 0xEF, 0x73, 0x9C, 0xE6,
  0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x06, 0x1C, 0x0F, 0x38,
  0x3F, 0xE1, 0x9F, 0xFF, 0x03, 0xFE, 0x0F, 0x84, 0x3B, 0x00, 0xE7, 0x07,
  0xCE, 0x07, 0x1E, 0x04, 0x1C, 0x00, 0x20, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x70,
  0x70, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0x13, 0xDF, 0xF7, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x38, 0x78, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x9E, 0x01, 0xCF, 0x00, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x87, 0x03, 0xC3, 0x83, 0xC1, 0xE3, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x87, 0xF3, 0xFC,
  0xFB, 0xBE, 0xF3, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xFC,
  0x1F, 0x1F, 0x03, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0xE1,
  0xF0, 0x40, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF3, 0x01, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x38,
  0xE0, 0x1C, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x70, 0x1C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE2, 0x03, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x7B, 0xF0, 0x77, 0xF8, 0xFF, 0xFC, 0xFC, 0x3C, 0xF8,
  0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xE1, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F,
  0x0E, 0x0F, 0x07, 0x8F, 0x83, 0xEF, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0xF9, 0xE0, 0xF8, 0x78, 0x78, 0x1C, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xE0, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38,
  0x0F, 0x38, 0x1F, 0x3C, 0x1F, 0x3E, 0xFF, 0x1F, 0xEE, 0x1F, 0xCE, 0x03,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x06, 0x0F, 0x0F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x78,
  0xF8, 0xF8, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFE,
  0x70, 0xF2, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x1F, 0x06, 0x1C, 0x1F, 0xF1, 0xCE, 0x0F, 0xF8, 0x73, 0x87,
  0x0E, 0x1C, 0xC3, 0x83, 0x87, 0x70, 0xE0, 0xE1, 0xDC, 0x70, 0x70, 0x67,
  0x1C, 0x1C, 0x39, 0x87, 0x07, 0x0E, 0x61, 0xC3, 0xC3, 0xB8, 0x70, 0xE1,
  0xCE, 0x1C, 0x78, 0x73, 0x87, 0xBF, 0x78, 0x61, 0xFD, 0xFC, 0x1C, 0x3E,
  0x3E, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x10, 0x01, 0xFC, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x38, 0x07, 0x0F, 0x00,
  0xE1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xFE, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0x87,
  0xE0, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0E, 0x0E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xFC,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xE0, 0x3E, 0x1C, 0x0F, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x03, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0x81, 0xF0, 0x70, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7E, 0x1E, 0x0F, 0x80, 0x21, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x1F,
  0xEF, 0x03, 0xFC, 0xF0, 0x3F, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF8, 0x07, 0x87, 0x80, 0x78, 0x7E,
  0x07, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x8F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xC0, 0x78,
  0x0E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xC7,
  0xC0, 0x0E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x38,
  0x1E, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x3F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xE0, 0xEE, 0x00, 0xFC, 0x0E, 0xE0, 0x1D, 0xC0, 0xEE, 0x01, 0xDC,
  0x0E, 0xE0, 0x3B, 0xC1, 0xEE, 0x03, 0xBC, 0x1E, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0xE7, 0x83, 0xCE, 0x0E, 0x78, 0x3C, 0xE1, 0xC7,
  0x83, 0x8E, 0x1C, 0x70, 0x38, 0xF3, 0x87, 0x03, 0x87, 0x38, 0xF0, 0x78,
  0x77, 0x0F, 0x07, 0x87, 0x70, 0xF0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE0,
  0xE0, 0x70, 0x7C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x0E,
  0x07, 0x81, 0xC0, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x70,
  0x3E, 0x00, 0xE0, 0xFE, 0x03, 0xC1, 0xFC, 0x07, 0x83, 0xB8, 0x0F, 0x07,
  0x70, 0x1C, 0x1E, 0xF0, 0x38, 0x3C, 0xE0, 0xF0, 0x71, 0xC1, 0xE0, 0xE3,
  0xC3, 0xC1, 0xC7, 0x87, 0x07, 0x87, 0x0E, 0x0F, 0x0F, 0x3C, 0x1C, 0x1E,
  0x78, 0x38, 0x1C, 0xE0, 0x70, 0x39, 0xC1, 0xE0, 0x7B, 0x83, 0xC0, 0xFF,
  0x07, 0x00, 0xFE, 0x0E, 0x01, 0xF8, 0x1C, 0x03, 0xF0, 0x78, 0x03, 0xE0,
  0xF0, 0x07, 0xC1, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xC7, 0x80,
  0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x07, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78,
  0x78, 0x1E, 0x1C, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xF1, 0xF0,
  0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C,
  0xF0, 0x07, 0x87, 0x80, 0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1C, 0x7E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F,
  0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x83,
  0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x07, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0x1E, 0x0F, 0x00, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x20, 0x0F, 0x0E, 0x07, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0x83, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x70,
  0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x70, 0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x70, 0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0E,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0xF0,
  0x70, 0x1E, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x3C, 0x07, 0x87, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01,
  0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0x80,
  0x78, 0x07, 0x9C, 0x03, 0xC0, 0x3C, 0xE0, 0x3E, 0x01, 0xC7, 0x01, 0xF0,
  0x1E, 0x38, 0x0F, 0x80, 0xE1, 0xC0, 0xFC, 0x0F, 0x0E, 0x07, 0xE0, 0x78,
  0x70, 0x77, 0x07, 0x83, 0x83, 0xB8, 0x3C, 0x1C, 0x3D, 0xC1, 0xC0, 0xE1,
  0xCE, 0x1E, 0x07, 0x0E, 0x70, 0xE0, 0x38, 0xE3, 0x8F, 0x01, 0xC7, 0x1C,
  0x78, 0x0E, 0x70, 0xE3, 0x80, 0x73, 0x87, 0x3C, 0x03, 0xBC, 0x39, 0xC0,
  0x1D, 0xC1, 0xDE, 0x00, 0xEE, 0x0E, 0xE0, 0x07, 0xE0, 0x37, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78,
  0x07, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0x38, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x38,
  0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xF8,
  0x07, 0x9C, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xE1, 0xE0,
  0x70, 0xF0, 0x38, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3B, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xE7, 0x8E, 0x1C, 0x70, 0x01, 0xC0, 0x03,
  0xF9, 0xC3, 0xFE, 0xE3, 0xF7, 0xF1, 0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0, 0xF8, 0x78, 0xFC, 0x3F, 0xEE, 0x1F,
  0xE7, 0x07, 0xE7, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x30, 0x1E, 0xFE, 0x0F,
  0xFF, 0x87, 0x77, 0xC3, 0xE1, 0xE1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x38, 0x07, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xE3, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xEF, 0xF8, 0x77, 0xF8, 0x39,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x7C, 0xE1, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x10, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x1C, 0x07,
  0xF3, 0x81, 0xFF, 0x70, 0x7E, 0x7E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0x78,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0E, 0x01, 0xC1, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x1F, 0x03, 0xC3,
  0xE0, 0x7F, 0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0xE0, 0x00, 0x00, 0xF0, 0x07,
  0xF8, 0x3F, 0xF8, 0x78, 0xF1, 0xE0, 0xE7, 0x81, 0xCE, 0x07, 0xBC, 0x1F,
  0x78, 0xFC, 0xFF, 0xF1, 0xFF, 0x87, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x08, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00,
  0x01, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x17, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x70, 0x7F, 0xDC, 0x3F, 0x3F,
  0x0F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81,
  0xF1, 0xE0, 0xF8, 0x3C, 0x7E, 0x0F, 0xFF, 0x83, 0xFD, 0xE0, 0x7E, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x80, 0x78, 0x3C,
  0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x1C, 0x1E, 0xFE, 0x1F, 0xFF, 0x1D, 0xCF, 0x1F, 0x07, 0x1E, 0x07, 0x3E,
  0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x78,
  0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x3C, 0x03, 0x03, 0xC3, 0xE0, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x01, 0x1E,
  0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x87, 0x81, 0xC7, 0x81, 0xE7, 0x80,
  0xF7, 0x80, 0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0x3C,
  0x07, 0x0E, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x70,
  0x3C, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x00, 0x02, 0x18, 0x0E, 0x07, 0x3F, 0x8F, 0xE1, 0xDF, 0xE7, 0xF8,
  0x7E, 0x7F, 0xDF, 0x1F, 0x0F, 0xC3, 0xC7, 0x83, 0xE0, 0xF3, 0xE0, 0xF0,
  0x3C, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0x8E, 0x03, 0x80, 0xE3, 0x81,
  0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x9E, 0x07, 0x01, 0xC7,
  0x01, 0xC0, 0x73, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x03,
  0x8E, 0x03, 0x80, 0xE3, 0x81, 0xE0, 0x78, 0x01, 0x1E, 0x07, 0x3F, 0x83,
  0xBF, 0xE1, 0xFD, 0xF0, 0xF8, 0x38, 0x78, 0x1C, 0x7C, 0x0E, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0,
  0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0x9E, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x86, 0x00, 0xE7, 0xF0, 0x1D,
  0xFF, 0x03, 0xB9, 0xE0, 0x7C, 0x1C, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x7F,
  0xC0, 0xEF, 0xF0, 0x1C, 0xFC, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF9, 0xC3, 0xFE, 0xE3, 0xF3, 0xF1,
  0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9C, 0x03, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0,
  0xF8, 0x78, 0x7C, 0x3F, 0xFE, 0x1F, 0xEF, 0x07, 0xE7, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x02, 0x38, 0xE7, 0xC7, 0x7E, 0x3B, 0xF1,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0xC7, 0x86, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x80, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xE0, 0x06, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x3F, 0xFF, 0xFC, 0xF0, 0x3C,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0x8F, 0xE1, 0xF8, 0x3C, 0x07, 0x3C, 0x0F, 0x38,
  0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70,
  0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0,
  0xF8, 0xF1, 0xF8, 0xFF, 0xB8, 0xFF, 0x38, 0x7E, 0x70, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x38, 0x70,
  0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x3C, 0x0F,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x1C, 0xF0, 0xFC, 0x3C,
  0xF1, 0xDC, 0x38, 0xF1, 0xDC, 0x78, 0xF1, 0xDC, 0x70, 0xF3, 0x9C, 0x70,
  0xF3, 0x9C, 0xF0, 0xF7, 0x1C, 0xE0, 0xF7, 0x1D, 0xE0, 0xFE, 0x1D, 0xC0,
  0xFE, 0x1D, 0xC0, 0xEE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0E,
  0x1E, 0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7B,
  0x80, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0xF0, 0xE0, 0x3C, 0x1E, 0x07, 0x83,
  0xC3, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x1E, 0x00, 0x70,
  0xF0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xE7, 0x80, 0x07, 0x3C, 0x00,
  0x39, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x9F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1C, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x02, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x30, 0x00, 0x7E, 0x01, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 10, 14, 4, -26 },
  { 48, 20, 26, 21, 1, -26 },
  { 113, 17, 29, 18, 1, -27 },
  { 175, 24, 26, 27, 2, -26 },
  { 253, 20, 26, 22, 1, -26 },
  { 318, 5, 10, 8, 4, -26 },
  { 325, 12, 32, 10, 1, -26 },
  { 373, 12, 32, 10, -3, -26 },
  { 421, 15, 16, 18, 3, -28 },
  { 451, 16, 17, 19, 2, -21 },
  { 485, 8, 9, 9, -2, -4 },
  { 494, 9, 3, 11, 1, -11 },
  { 498, 5, 5, 9, 0, -5 },
  { 502, 18, 26, 13, -2, -26 },
  { 561, 17, 26, 18, 1, -26 },
  { 617, 11, 26, 18, 4, -26 },
  { 653, 18, 26, 18, -1, -26 },
  { 712, 17, 26, 18, 0, -26 },
  { 768, 18, 26, 18, 0, -26 },
  { 827, 17, 26, 18, 1, -26 },
  { 883, 16, 26, 18, 2, -26 },
  { 935, 17, 26, 18, 2, -26 },
  { 991, 17, 26, 18, 1, -26 },
  { 1047, 16, 26, 18, 1, -26 },
  { 1099, 8, 20, 9, 0, -20 },
  { 1119, 10, 25, 9, -2, -20 },
  { 1151, 16, 18, 19, 2, -22 },
  { 1187, 16, 10, 19, 2, -18 },
  { 1207, 16, 18, 19, 2, -22 },
  { 1243, 13, 26, 14, 2, -26 },
  { 1286, 26, 29, 27, 1, -26 },
  { 1381, 19, 26, 19, -2, -26 },
  { 1443, 19, 26, 20, 1, -26 },
  { 1505, 19, 26, 19, 2, -26 },
  { 1567, 20, 26, 22, 1, -26 },
  { 1632, 17, 26, 17, 1, -26 },
  { 1688, 17, 26, 16, 1, -26 },
  { 1744, 20, 26, 22, 2, -26 },
  { 1809, 22, 26, 22, 1, -26 },
  { 1881, 15, 26, 11, -1, -26 },
  { 1930, 16, 33, 9, -6, -26 },
  { 1996, 21, 26, 19, 1, -26 },
  { 2065, 13, 26, 16, 1, -26 },
  { 2108, 28, 26, 28, 1, -26 },
  { 2199, 23, 26, 23, 1, -26 },
  { 2274, 20, 26, 23, 2, -26 },
  { 2339, 18, 26, 19, 1, -26 },
  { 2398, 20, 32, 23, 2, -26 },
  { 2478, 18, 26, 19, 1, -26 },
  { 2537, 18, 26, 17, 0, -26 },
  { 2596, 16, 26, 16, 3, -26 },
  { 2648, 21, 26, 22, 2, -26 },
  { 2717, 19, 26, 18, 3, -26 },
  { 2779, 29, 26, 29, 3, -26 },
  { 2874, 23, 26, 18, -2, -26 },
  { 2949, 17, 26, 17, 3, -26 },
  { 3005, 20, 26, 17, -1, -26 },
  { 3070, 14, 32, 11, -1, -26 },
  { 3126, 7, 26, 13, 4, -26 },
  { 3149, 14, 32, 11, -3, -26 },
  { 3205, 17, 16, 18, 1, -26 },
  { 3239, 13, 3, 13, -3, 3 },
  { 3244, 6, 6, 10, 5, -28 },
  { 3249, 17, 20, 19, 1, -20 },
  { 3292, 17, 27, 19, 1, -27 },
  { 3350, 15, 20, 15, 1, -20 },
  { 3388, 19, 27, 19, 1, -27 },
  { 3453, 15, 20, 17, 1, -20 },
  { 3491, 19, 37, 11, -4, -28 },
  { 3579, 18, 29, 19, 0, -20 },
  { 3645, 16, 27, 19, 1, -27 },
  { 3699, 9, 27, 9, 1, -27 },
  { 3730, 15, 36, 9, -5, -27 },
  { 3798, 17, 27, 17, 1, -27 },
  { 3856, 10, 27, 9, 0, -27 },
  { 3890, 26, 20, 28, 1, -20 },
  { 3955, 17, 20, 19, 0, -20 },
  { 3998, 16, 20, 19, 1, -20 },
  { 4038, 19, 29, 19, -1, -20 },
  { 4107, 17, 29, 19, 1, -20 },
  { 4169, 13, 20, 13, 1, -20 },
  { 4202, 14, 20, 14, 0, -20 },
  { 4237, 10, 24, 11, 2, -24 },
  { 4267, 16, 19, 19, 2, -19 },
  { 4305, 15, 19, 16, 2, -19 },
  { 4341, 24, 19, 24, 2, -19 },
  { 4398, 19, 19, 16, -2, -19 },
  { 4444, 21, 28, 16, -3, -19 },
  { 4518, 16, 19, 14, -1, -19 },
  { 4556, 14, 32, 12, 0, -26 },
  { 4612, 2, 36, 17, 8, -27 },
  { 4621, 14, 32, 12, -2, -26 },
  { 4677, 16, 5, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC36PT7B_H_
