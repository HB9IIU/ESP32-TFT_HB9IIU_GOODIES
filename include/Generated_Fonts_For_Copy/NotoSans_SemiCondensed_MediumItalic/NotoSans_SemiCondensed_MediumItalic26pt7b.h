#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83,
  0x06, 0x00, 0x00, 0x71, 0xE3, 0x80, 0x67, 0xE7, 0xE6, 0xE6, 0xC6, 0xCC,
  0xCC, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63,
  0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x07,
  0xFF, 0xDF, 0xFF, 0x06, 0x30, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x00, 0xCE,
  0x00, 0x01, 0x80, 0x18, 0x03, 0x81, 0xFF, 0x3F, 0xE3, 0xB2, 0x32, 0x03,
  0x20, 0x3A, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x05, 0xC0, 0x4C, 0x0C, 0xC8,
  0xDC, 0xEF, 0x8F, 0xF0, 0x7C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x1C, 0x06,
  0x1F, 0x07, 0x19, 0x83, 0x0C, 0xC3, 0x0C, 0x63, 0x86, 0x31, 0x83, 0x19,
  0x81, 0x8D, 0xC0, 0xCC, 0xDF, 0x66, 0xDF, 0xBE, 0xEC, 0xCE, 0x6E, 0x70,
  0x66, 0x30, 0x73, 0x18, 0x31, 0x8C, 0x30, 0xC6, 0x38, 0x66, 0x18, 0x3F,
  0x18, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x71, 0x80, 0xC3,
  0x01, 0x8E, 0x03, 0x98, 0x07, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFE, 0x39,
  0xCC, 0x67, 0x1D, 0xCC, 0x1F, 0x38, 0x3E, 0x30, 0x38, 0x71, 0xF0, 0xFF,
  0xF0, 0xFC, 0x70, 0x6F, 0xFD, 0xB0, 0x03, 0x06, 0x0E, 0x0C, 0x18, 0x38,
  0x30, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0E,
  0x06, 0x07, 0x03, 0x03, 0x83, 0x83, 0x80, 0x03, 0x00, 0xE0, 0x18, 0x33,
  0x0F, 0xE6, 0x3F, 0xC3, 0x98, 0xD8, 0x73, 0x06, 0x70, 0x86, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6, 0x60, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0xFE, 0x1E,
  0xE3, 0x86, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0x60, 0x6E, 0x06, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x18, 0xE3, 0x87, 0xF0, 0x3E,
  0x00, 0x03, 0x0F, 0x1F, 0x7E, 0xF6, 0x4E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x03, 0xC0, 0x7F, 0x87,
  0xBC, 0x10, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x27,
  0xFE, 0x3F, 0xF0, 0x03, 0xC0, 0x7F, 0x87, 0xBC, 0x10, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0x78, 0x03, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0xC1, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xB8, 0x19, 0x81, 0xCC, 0x0C,
  0xE0, 0xC7, 0x0C, 0x38, 0xE1, 0x8E, 0x0C, 0x7F, 0xFB, 0xFF, 0xC0, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0xC1, 0xC7, 0xFC, 0x1F, 0xC0,
  0x01, 0xF0, 0x7F, 0x0F, 0x91, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x38,
  0x7F, 0xC7, 0xDE, 0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C,
  0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x00,
  0x03, 0x80, 0xFE, 0x1C, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0x61, 0xDE,
  0x0F, 0x81, 0xF0, 0x3F, 0x87, 0x1C, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C,
  0xE1, 0xCF, 0xF8, 0x7F, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x37, 0x06,
  0xE0, 0xDC, 0x1B, 0x03, 0x70, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x1F, 0xC3, 0xF0, 0x00, 0x1C, 0x73, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xF3, 0x80, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x0E, 0x18, 0x70, 0xC0, 0x00, 0x10,
  0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0x80,
  0x00, 0x0F, 0x1F, 0xE3, 0xBC, 0x87, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x0F,
  0x07, 0x81, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x78, 0x78, 0x38, 0x06, 0x1C, 0x00,
  0xCE, 0x08, 0x33, 0x1F, 0xCD, 0x8E, 0x73, 0x63, 0x18, 0xD9, 0x86, 0x3C,
  0x61, 0x8F, 0x18, 0xE3, 0xC6, 0x31, 0xB1, 0x9C, 0x6C, 0x7D, 0xF3, 0x1E,
  0x78, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x80, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x36, 0x00, 0xD8, 0x07, 0x60,
  0x19, 0x80, 0xE6, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x83, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF1, 0x81, 0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x7F, 0x01, 0xC0, 0x0F,
  0x00, 0xFF, 0x87, 0xFE, 0x38, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0E,
  0x3F, 0xE1, 0xFC, 0x1C, 0x78, 0xE0, 0xE7, 0x07, 0x30, 0x39, 0x81, 0xDC,
  0x1C, 0xE3, 0xE7, 0xFE, 0x3F, 0xC0, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x40,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x7F, 0xC1, 0xFF, 0x87, 0x0E, 0x18,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC,
  0x0E, 0x70, 0x39, 0x80, 0xE6, 0x07, 0x38, 0x38, 0xE3, 0xC3, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x7F, 0xC7,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00,
  0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0xF0, 0x21, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE1, 0xF9, 0x83, 0xF7, 0x00, 0xCE, 0x03,
  0x9C, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x78, 0x30, 0x7F, 0xE0, 0x7F, 0x80,
  0x0C, 0x06, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0x8E,
  0x07, 0x1C, 0x0E, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0x81, 0xC7, 0x03,
  0x8C, 0x07, 0x18, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xC0,
  0x0F, 0xE1, 0xFC, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x0F,
  0xC3, 0xF8, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE1, 0x38, 0x3F, 0x07, 0xC0,
  0x0C, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0x81, 0x8E, 0x07, 0x3C, 0x0E,
  0x70, 0x1D, 0xC0, 0x37, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0x9C, 0x07, 0x38,
  0x0C, 0x70, 0x18, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x03, 0x80,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xC0, 0x0E, 0x00,
  0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xF0,
  0x7E, 0x3F, 0x06, 0xC3, 0xF0, 0xEC, 0x33, 0x0D, 0xC3, 0x31, 0xDC, 0x73,
  0x19, 0xC7, 0x33, 0x98, 0x63, 0x31, 0x86, 0x37, 0x38, 0x63, 0x63, 0x8E,
  0x3E, 0x30, 0xE3, 0xC3, 0x0C, 0x38, 0x70, 0xC3, 0x87, 0x00, 0x1E, 0x03,
  0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1F, 0x06, 0x3F, 0x06, 0x3B, 0x0E,
  0x33, 0x8E, 0x33, 0x8E, 0x31, 0x8C, 0x71, 0x8C, 0x71, 0xDC, 0x61, 0xDC,
  0x60, 0xD8, 0x60, 0xF8, 0xE0, 0xF8, 0xE0, 0x78, 0xC0, 0x78, 0xC0, 0x70,
  0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x01, 0xCC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xDC, 0x03, 0x98, 0x0E, 0x38, 0x3C, 0x78, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x0F, 0x00, 0xFF, 0x07, 0xFC, 0x38, 0xF1, 0x83, 0x9C, 0x1C, 0xE0, 0xE7,
  0x06, 0x30, 0x71, 0x8F, 0x1F, 0xF0, 0xFE, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x1D, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x03, 0x98, 0x0E, 0x38,
  0x3C, 0x78, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0xFF, 0x07, 0xFC, 0x38, 0xE1, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0E, 0x30, 0xF1, 0xFF, 0x1F, 0xF0, 0xE7, 0x07, 0x38,
  0x30, 0xC1, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x07, 0x30, 0x38, 0x03, 0xE0,
  0x7F, 0xC7, 0xFC, 0x38, 0x21, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0xC3, 0xC7, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x00, 0x38, 0x0C,
  0xE0, 0x73, 0x81, 0xCC, 0x07, 0x70, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E,
  0x60, 0x3B, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0x8C, 0x0E,
  0x30, 0x38, 0xE1, 0xC3, 0xFE, 0x07, 0xF0, 0x00, 0xE0, 0x1F, 0x80, 0xEE,
  0x03, 0x98, 0x1C, 0x60, 0x71, 0x83, 0x86, 0x0E, 0x18, 0x70, 0x61, 0xC1,
  0x8E, 0x06, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x7C, 0x0E, 0x06, 0xC0,
  0xE0, 0xEC, 0x1E, 0x0E, 0xC1, 0xE1, 0xCC, 0x36, 0x1C, 0xC3, 0x61, 0x8C,
  0x76, 0x38, 0xC6, 0x63, 0x0C, 0xE6, 0x70, 0xCC, 0x67, 0x0C, 0xC6, 0x60,
  0xDC, 0x6E, 0x0D, 0x86, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0E, 0x07, 0x80, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x1C,
  0x06, 0x1C, 0x07, 0x38, 0x07, 0x70, 0x03, 0x70, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0x60, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70, 0xE0, 0x3B, 0x03, 0x98,
  0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xC0, 0xCE, 0x06, 0xE0, 0x37, 0x01, 0xF0,
  0x0F, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x07, 0xE0, 0xF8, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xF8, 0x3F, 0x00, 0xC6, 0x31, 0xCE,
  0x71, 0x8C, 0x63, 0x18, 0xE7, 0x18, 0xC6, 0x31, 0x8E, 0x07, 0xC1, 0xF0,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x1F,
  0x0F, 0xC0, 0x02, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0D, 0x81, 0x98, 0x39,
  0xC3, 0x0C, 0x70, 0xC6, 0x06, 0xE0, 0x6C, 0x07, 0xFF, 0xFF, 0xE0, 0xEE,
  0x63, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x07, 0x70, 0x66, 0x06, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x3C, 0x7F, 0xC7, 0xD8, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x77, 0x83, 0xFE, 0x1E,
  0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x98, 0x18, 0xC1, 0xCE, 0x0E,
  0x70, 0xE3, 0xC7, 0x1F, 0xF1, 0xDF, 0x00, 0x0F, 0xC7, 0xF3, 0x85, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x84, 0x7F, 0x0F,
  0xC0, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0xF3, 0x07, 0xEC, 0x38, 0xF1, 0xC1, 0xC7, 0x06, 0x18, 0x18, 0xE0, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x07, 0xFC, 0x1F, 0x60,
  0x0F, 0xC3, 0xF8, 0xE3, 0xB8, 0x77, 0x0C, 0xC7, 0xBF, 0xE7, 0xF0, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x47, 0xF8, 0x7E, 0x00, 0x00, 0x3C, 0x03, 0xF0,
  0x0E, 0x40, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x98, 0x7E, 0xC7, 0x1E, 0x70,
  0x73, 0x83, 0x18, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38,
  0xE3, 0xC3, 0xFE, 0x1F, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC4, 0x1C, 0x3F,
  0xC1, 0xFC, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x77, 0xC3, 0xFE, 0x1E, 0x38, 0xE1, 0xCE, 0x0C, 0x70, 0x63, 0x87,
  0x18, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x87, 0x18, 0x39, 0xC1, 0xC0,
  0x0E, 0x1C, 0x30, 0x00, 0x03, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06,
  0x1C, 0x38, 0x70, 0xC3, 0x80, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xE0, 0xF0,
  0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0xE3, 0x8E, 0x18, 0xE0, 0xCE, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xEE, 0x0E, 0x70, 0x71, 0x83, 0x8E, 0x18, 0x71, 0xC1, 0xC0, 0x06, 0x1C,
  0x38, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38,
  0x70, 0xE1, 0x87, 0x00, 0x19, 0xE3, 0xE3, 0x7E, 0xFC, 0x79, 0xF1, 0x8E,
  0x1C, 0x33, 0x83, 0x06, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0x83, 0x87, 0x30,
  0x60, 0xCE, 0x0C, 0x19, 0xC3, 0x87, 0x38, 0x70, 0xE6, 0x0C, 0x1D, 0xC1,
  0x83, 0x00, 0x19, 0xF0, 0xDF, 0x87, 0x8E, 0x38, 0x73, 0x83, 0x1C, 0x18,
  0xE1, 0xC6, 0x0E, 0x70, 0x73, 0x83, 0x1C, 0x18, 0xE1, 0xC6, 0x0E, 0x70,
  0x70, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x37, 0x06, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0x71, 0xE7, 0xF8, 0x7C, 0x00, 0x0C, 0xF0, 0x37,
  0xE0, 0xF1, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x06, 0x18,
  0x38, 0xE0, 0xE3, 0x87, 0x0F, 0x1C, 0x37, 0xE1, 0xDF, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x31, 0xFB, 0x38,
  0xF7, 0x07, 0x70, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xCE, 0x3C, 0x7F, 0xC7, 0xD8, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x19, 0xC6, 0xF1, 0xF0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x1F, 0xCF, 0xF3, 0x84,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3A, 0x1E, 0xFF,
  0x3F, 0x80, 0x0C, 0x18, 0x18, 0x7F, 0xFF, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xFC, 0x7C, 0x38, 0x33, 0x87, 0x30, 0x77,
  0x07, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE,
  0x3C, 0xFF, 0xC7, 0xD8, 0xE0, 0x7E, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0x86,
  0x38, 0x63, 0x06, 0x70, 0x66, 0x06, 0xE0, 0x6C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xC3, 0x83, 0xE1, 0xC3, 0xB0, 0xF1, 0xD8, 0xD8, 0xCC, 0x7C, 0xE6,
  0x6E, 0x63, 0x37, 0x71, 0xBB, 0xB0, 0xD8, 0xD8, 0x6C, 0x7C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x30, 0xC0, 0xC7,
  0x03, 0xB8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x76,
  0x01, 0x9C, 0x0E, 0x70, 0x70, 0xC3, 0x83, 0x80, 0x1C, 0x0E, 0x18, 0x38,
  0x30, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x07, 0x70, 0x0E,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x40, 0xF0, 0x3C, 0x1C,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x07, 0xC1, 0xC0, 0xF0, 0x0E,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x03,
  0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x70,
  0x0F, 0x07, 0x83, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x3C, 0x0E, 0x00, 0x3C, 0x1F, 0xFF, 0xC7, 0xF8, 0x0C,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 15, 19, 15, 0, -19 },
  { 61, 12, 22, 13, 1, -20 },
  { 94, 17, 19, 20, 2, -19 },
  { 135, 15, 19, 16, 0, -19 },
  { 171, 3, 7, 6, 3, -19 },
  { 174, 8, 23, 7, 1, -19 },
  { 197, 9, 23, 8, -2, -19 },
  { 223, 11, 11, 13, 2, -20 },
  { 239, 12, 12, 14, 1, -15 },
  { 257, 5, 6, 6, -1, -3 },
  { 261, 6, 2, 8, 1, -8 },
  { 263, 4, 3, 6, 0, -3 },
  { 265, 13, 19, 9, -1, -19 },
  { 296, 12, 19, 13, 1, -19 },
  { 325, 8, 19, 13, 3, -19 },
  { 344, 13, 19, 13, 0, -19 },
  { 375, 13, 19, 13, 0, -19 },
  { 406, 13, 19, 13, 0, -19 },
  { 437, 13, 19, 13, 0, -19 },
  { 468, 12, 19, 13, 1, -19 },
  { 497, 13, 19, 13, 1, -19 },
  { 528, 12, 19, 13, 1, -19 },
  { 557, 11, 19, 13, 1, -19 },
  { 584, 6, 14, 6, 0, -14 },
  { 595, 7, 17, 6, -1, -14 },
  { 610, 12, 13, 14, 1, -16 },
  { 630, 11, 8, 14, 2, -13 },
  { 641, 12, 13, 14, 1, -16 },
  { 661, 10, 19, 10, 1, -19 },
  { 685, 18, 21, 20, 1, -19 },
  { 733, 14, 19, 14, -2, -19 },
  { 767, 13, 19, 14, 1, -19 },
  { 798, 14, 19, 14, 1, -19 },
  { 832, 14, 19, 16, 1, -19 },
  { 866, 12, 19, 12, 1, -19 },
  { 895, 12, 19, 12, 1, -19 },
  { 924, 15, 19, 16, 1, -19 },
  { 960, 15, 19, 16, 1, -19 },
  { 996, 11, 19, 8, -1, -19 },
  { 1023, 11, 24, 7, -4, -19 },
  { 1056, 15, 19, 14, 1, -19 },
  { 1092, 9, 19, 11, 1, -19 },
  { 1114, 20, 19, 20, 1, -19 },
  { 1162, 16, 19, 17, 1, -19 },
  { 1200, 15, 19, 17, 1, -19 },
  { 1236, 13, 19, 14, 1, -19 },
  { 1267, 15, 23, 17, 1, -19 },
  { 1311, 13, 19, 14, 1, -19 },
  { 1342, 13, 19, 12, 0, -19 },
  { 1373, 12, 19, 12, 2, -19 },
  { 1402, 14, 19, 16, 2, -19 },
  { 1436, 14, 19, 13, 2, -19 },
  { 1470, 20, 19, 21, 3, -19 },
  { 1518, 16, 19, 13, -1, -19 },
  { 1556, 13, 19, 12, 2, -19 },
  { 1587, 14, 19, 12, -1, -19 },
  { 1621, 11, 23, 8, -1, -19 },
  { 1653, 5, 19, 10, 3, -19 },
  { 1665, 10, 23, 8, -2, -19 },
  { 1694, 12, 12, 13, 1, -19 },
  { 1712, 10, 2, 9, -2, 2 },
  { 1715, 4, 4, 7, 4, -20 },
  { 1717, 12, 14, 14, 1, -14 },
  { 1738, 13, 20, 14, 0, -20 },
  { 1771, 10, 14, 11, 1, -14 },
  { 1789, 14, 20, 14, 1, -20 },
  { 1824, 11, 14, 12, 1, -14 },
  { 1844, 14, 26, 8, -3, -20 },
  { 1890, 13, 20, 14, 0, -14 },
  { 1923, 13, 20, 14, 0, -20 },
  { 1956, 7, 19, 6, 0, -19 },
  { 1973, 10, 25, 6, -3, -19 },
  { 2005, 13, 20, 12, 0, -20 },
  { 2038, 7, 20, 6, 0, -20 },
  { 2056, 19, 14, 21, 0, -14 },
  { 2090, 13, 14, 14, 0, -14 },
  { 2113, 11, 14, 13, 1, -14 },
  { 2133, 14, 20, 14, -1, -14 },
  { 2168, 12, 20, 14, 1, -14 },
  { 2198, 10, 14, 9, 0, -14 },
  { 2216, 10, 14, 10, 0, -14 },
  { 2234, 8, 17, 8, 1, -17 },
  { 2251, 12, 14, 14, 1, -14 },
  { 2272, 12, 14, 11, 1, -14 },
  { 2293, 17, 14, 18, 2, -14 },
  { 2323, 14, 14, 12, -1, -14 },
  { 2348, 15, 20, 11, -2, -14 },
  { 2386, 12, 14, 10, -1, -14 },
  { 2407, 10, 23, 9, 0, -19 },
  { 2436, 3, 26, 13, 5, -20 },
  { 2446, 10, 23, 9, -1, -19 },
  { 2475, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC26PT7B_H_
