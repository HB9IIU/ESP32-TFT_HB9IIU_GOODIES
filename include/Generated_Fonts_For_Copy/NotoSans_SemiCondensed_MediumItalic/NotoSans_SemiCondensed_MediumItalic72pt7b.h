#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F,
  0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0,
  0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x7F, 0x80, 0x3F, 0xC7, 0x83, 0xC0, 0x1F, 0xE1, 0xE0, 0x10, 0x07,
  0xF0, 0x78, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0x3F, 0x83, 0xC0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x01, 0xF8, 0x3C, 0x00,
  0x00, 0x7F, 0x0F, 0x00, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0x07, 0xFD, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7B, 0xFE, 0x00, 0x00, 0x1E, 0x7F, 0xC0,
  0x00, 0x07, 0x8F, 0xF0, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0xF0, 0x7F,
  0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x03, 0xC1,
  0xFC, 0x00, 0x01, 0xE0, 0xFF, 0x04, 0x00, 0x78, 0x3F, 0x81, 0xC0, 0x1E,
  0x1F, 0xE0, 0x7C, 0x07, 0x8F, 0xF0, 0x1F, 0xFB, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x20,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x02, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0xFF,
  0x8F, 0x80, 0xFC, 0x3F, 0x0F, 0xFF, 0x3E, 0x03, 0xF0, 0xFC, 0x7F, 0xFE,
  0xFC, 0x1F, 0xC7, 0xE3, 0xFF, 0xFB, 0xF0, 0x7E, 0x3F, 0x0F, 0xFF, 0xFF,
  0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF8, 0x3F, 0x7F,
  0xFE, 0x3F, 0x0F, 0xC0, 0xFC, 0xFF, 0xF0, 0xFC, 0x7E, 0x03, 0xF1, 0xFF,
  0x87, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0x00,
  0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F,
  0xEF, 0xE0, 0x07, 0xF0, 0x3F, 0xE7, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x01, 0xF8,
  0x00, 0x7C, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x07, 0xFC, 0x7C, 0x00,
  0x3F, 0xFD, 0xF0, 0x01, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF8, 0x7E,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0xE0,
  0x01, 0xC0, 0x3F, 0x80, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F,
  0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xBF, 0xEF, 0xFB, 0xFC, 0x7F, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xF7,
  0xF3, 0xFF, 0x9F, 0xC3, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xC1, 0xFE,
  0x07, 0x03, 0xFC, 0x08, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x40, 0x00, 0x03, 0xFC, 0x0E, 0x00, 0x01, 0xFF, 0x81, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x02, 0x00, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x1F, 0xF8, 0x0F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x1F, 0xC3,
  0xFF, 0x80, 0x07, 0xF1, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xFE, 0x00, 0xFE,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFF, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF,
  0xE7, 0xF0, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x04,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFC, 0x3C, 0x00, 0xFF, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xFF,
  0x80, 0x7E, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x1F,
  0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF1, 0xF8,
  0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xCF,
  0xC0, 0x7E, 0x00, 0x7E, 0x00, 0xF9, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE7, 0xC0, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE7, 0xE0, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x00,
  0x7F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x03, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xBF, 0xFF, 0x80, 0xFC,
  0x03, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x7F, 0xFC, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x20,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x30, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x7F,
  0x80, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x87, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC7,
  0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F,
  0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFF,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF1, 0xFC,
  0x07, 0xF8, 0x01, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xCF, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xFC, 0x03, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x01, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0x0F, 0xF8, 0x07, 0x00, 0x03, 0xFF,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x3F, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0x8F, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0xFC, 0x01,
  0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0xE7, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF8, 0x07, 0xFE,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xCF, 0xC0, 0x0F,
  0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0x87, 0xFF, 0x80, 0x0F, 0xE7,
  0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0x80, 0x7F,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x9F,
  0xFC, 0x07, 0xEF, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0x00, 0x7E, 0x3F,
  0xFF, 0x80, 0x3F, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x07, 0xFC,
  0x01, 0xC0, 0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0x00,
  0x1F, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0xE0, 0x03, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFB, 0xF8, 0x00, 0x7F,
  0xFF, 0x9F, 0x80, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xE0,
  0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x3F, 0xE0,
  0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xE3,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0x03, 0xFE, 0x00,
  0x38, 0x1F, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC1,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x02,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x7E, 0x00,
  0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0xF9,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0x80,
  0x03, 0xFF, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x02, 0x00, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0x87,
  0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xFE, 0x01, 0xFD,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x83, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xF8,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x3F, 0x7C, 0x0F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x03, 0xFF, 0x00,
  0x0F, 0xC3, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xEF, 0x81,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x03,
  0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x03, 0xF1, 0xFF, 0xFC, 0x00,
  0x0F, 0xCF, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xEF, 0x81, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x7F, 0xF0, 0x01, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xF7, 0xFF, 0xFC, 0x00,
  0x1F, 0xCF, 0xFF, 0xE0, 0x00, 0xFF, 0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0xF0, 0x00, 0x0F, 0xE0, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0xFC,
  0x01, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0xE7,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF8, 0x07,
  0xFE, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xDF, 0xC0,
  0x0F, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0x00, 0x01, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x3F,
  0xE0, 0x0F, 0xC7, 0xFE, 0x00, 0xFC, 0xFF, 0xE0, 0x1F, 0xDF, 0xFE, 0x01,
  0xFD, 0xFF, 0xC0, 0x1F, 0xBF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xE0, 0x7F,
  0xC0, 0x1C, 0x07, 0xF8, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x80, 0x00, 0xFF, 0x0E, 0x00, 0x1F, 0xE0, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x38, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0x80, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFB, 0xFB, 0xF8, 0x07, 0xFF,
  0xFE, 0xFC, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0x8F, 0xC0, 0x07,
  0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFC,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFB, 0xF0,
  0x0F, 0xE0, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF3, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0x80, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x83, 0xF0,
  0xFE, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x03, 0xF1,
  0xFC, 0x00, 0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x7E, 0x03, 0xF3,
  0xF8, 0x00, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x3F, 0xFF, 0x00, 0x03,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xFC,
  0x80, 0x00, 0x3F, 0xF0, 0x80, 0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 52, 19, 1, -51 },
  { 125, 23, 18, 28, 7, -51 },
  { 177, 41, 51, 41, 1, -51 },
  { 439, 34, 59, 36, 1, -55 },
  { 690, 46, 53, 54, 5, -52 },
  { 995, 41, 53, 43, 1, -52 },
  { 1267, 11, 18, 16, 7, -51 },
  { 1292, 24, 63, 21, 2, -52 },
  { 1481, 23, 63, 21, -5, -52 },
  { 1663, 30, 31, 35, 7, -55 },
  { 1780, 32, 35, 38, 4, -43 },
  { 1920, 14, 17, 18, -3, -8 },
  { 1950, 19, 7, 21, 1, -23 },
  { 1967, 10, 10, 18, 1, -9 },
  { 1980, 35, 52, 26, -3, -52 },
  { 2208, 32, 53, 36, 3, -52 },
  { 2420, 23, 51, 36, 8, -51 },
  { 2567, 36, 52, 36, -1, -52 },
  { 2801, 35, 53, 36, 0, -52 },
  { 3033, 35, 52, 36, 0, -52 },
  { 3261, 35, 52, 36, 1, -51 },
  { 3489, 34, 53, 36, 3, -52 },
  { 3715, 34, 51, 36, 4, -51 },
  { 3932, 34, 53, 36, 2, -52 },
  { 4158, 33, 53, 36, 2, -52 },
  { 4377, 15, 41, 18, 1, -40 },
  { 4454, 21, 49, 18, -4, -40 },
  { 4583, 32, 35, 38, 4, -43 },
  { 4723, 32, 21, 38, 4, -36 },
  { 4807, 32, 35, 38, 4, -43 },
  { 4947, 26, 53, 28, 4, -52 },
  { 5120, 51, 58, 55, 3, -52 },
  { 5490, 38, 51, 38, -4, -51 },
  { 5733, 37, 51, 39, 2, -51 },
  { 5969, 38, 53, 38, 4, -52 },
  { 6221, 39, 51, 43, 2, -51 },
  { 6470, 35, 51, 34, 2, -51 },
  { 6694, 35, 51, 32, 2, -51 },
  { 6918, 40, 53, 44, 4, -52 },
  { 7183, 43, 51, 44, 2, -51 },
  { 7458, 29, 51, 23, -2, -51 },
  { 7643, 31, 65, 19, -11, -51 },
  { 7895, 42, 51, 37, 2, -51 },
  { 8163, 25, 51, 32, 2, -51 },
  { 8323, 55, 51, 56, 2, -51 },
  { 8674, 46, 51, 47, 2, -51 },
  { 8968, 41, 53, 46, 4, -52 },
  { 9240, 36, 51, 38, 2, -51 },
  { 9470, 41, 64, 46, 4, -52 },
  { 9798, 36, 51, 38, 2, -51 },
  { 10028, 35, 53, 34, 0, -52 },
  { 10260, 33, 51, 33, 6, -51 },
  { 10471, 41, 52, 44, 4, -51 },
  { 10738, 37, 51, 37, 6, -51 },
  { 10974, 56, 51, 57, 7, -51 },
  { 11331, 45, 51, 36, -4, -51 },
  { 11618, 34, 51, 34, 6, -51 },
  { 11835, 39, 51, 34, -2, -51 },
  { 12084, 28, 63, 21, -1, -52 },
  { 12305, 13, 52, 26, 8, -52 },
  { 12390, 28, 63, 21, -5, -52 },
  { 12611, 33, 32, 37, 2, -52 },
  { 12743, 28, 5, 26, -7, 6 },
  { 12761, 12, 11, 20, 11, -55 },
  { 12778, 34, 41, 38, 3, -40 },
  { 12953, 34, 56, 38, 1, -55 },
  { 13191, 28, 41, 30, 3, -40 },
  { 13335, 37, 56, 38, 3, -55 },
  { 13594, 29, 41, 34, 3, -40 },
  { 13743, 38, 72, 22, -8, -55 },
  { 14085, 37, 57, 38, 0, -40 },
  { 14349, 34, 55, 38, 1, -55 },
  { 14583, 18, 54, 18, 1, -54 },
  { 14705, 28, 71, 18, -9, -54 },
  { 14954, 35, 55, 34, 1, -55 },
  { 15195, 19, 55, 18, 1, -55 },
  { 15326, 53, 40, 57, 1, -40 },
  { 15591, 34, 40, 38, 1, -40 },
  { 15761, 31, 40, 37, 3, -39 },
  { 15916, 38, 57, 38, -3, -40 },
  { 16187, 34, 57, 38, 3, -40 },
  { 16430, 28, 40, 26, 1, -40 },
  { 16570, 28, 41, 29, 0, -40 },
  { 16714, 22, 48, 23, 3, -47 },
  { 16846, 34, 40, 38, 3, -39 },
  { 17016, 31, 39, 31, 4, -39 },
  { 17168, 48, 39, 49, 4, -39 },
  { 17402, 38, 39, 32, -3, -39 },
  { 17588, 41, 56, 31, -6, -39 },
  { 17875, 31, 39, 29, -2, -39 },
  { 18027, 28, 62, 25, 1, -51 },
  { 18244, 6, 72, 35, 15, -55 },
  { 18298, 27, 62, 25, -3, -51 },
  { 18508, 32, 10, 38, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC72PT7B_H_
