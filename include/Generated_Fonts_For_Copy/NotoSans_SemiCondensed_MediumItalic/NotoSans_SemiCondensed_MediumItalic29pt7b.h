#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x73, 0xB9,
  0xD8, 0xCC, 0x6E, 0x77, 0x3B, 0x19, 0x8C, 0x00, 0xC7, 0x00, 0xE3, 0x00,
  0x61, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x1C, 0x60, 0x7F, 0xFE, 0x7F, 0xFF,
  0x07, 0x18, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x03, 0xFF,
  0xF3, 0xFF, 0xF8, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x70, 0x0E, 0x30, 0x06,
  0x18, 0x03, 0x1C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0xF1, 0xFF,
  0x9E, 0xC8, 0xE6, 0x07, 0x20, 0x3B, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x03, 0x70, 0x1B, 0x80, 0xCC, 0x04, 0xE4, 0x27, 0x3F, 0xF1, 0xFF,
  0x01, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x01, 0x87, 0xE0, 0x61,
  0xCC, 0x1C, 0x31, 0x83, 0x06, 0x30, 0xE1, 0xC6, 0x38, 0x30, 0xC6, 0x06,
  0x19, 0xC0, 0xC7, 0x73, 0x98, 0xCC, 0xFB, 0xBB, 0xBF, 0x7E, 0xEE, 0x77,
  0x99, 0x8E, 0x07, 0x31, 0xC1, 0xCE, 0x30, 0x31, 0xC6, 0x0E, 0x30, 0xC3,
  0x86, 0x38, 0x60, 0xE6, 0x1C, 0x1F, 0xC7, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0x78, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x0C, 0x70, 0x0E,
  0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x87, 0x73, 0x8E, 0xE1,
  0xCE, 0xE1, 0xFC, 0xE0, 0xF8, 0xC0, 0xF8, 0xE0, 0xF0, 0xF1, 0xF8, 0xFF,
  0xBC, 0x7F, 0x1E, 0x77, 0x76, 0xEE, 0xCC, 0x01, 0x81, 0x81, 0xC1, 0xC0,
  0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18,
  0x00, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83, 0x81, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x00, 0x07, 0x00, 0x70, 0x07, 0x0E,
  0x60, 0xFE, 0x07, 0xFF, 0x0F, 0xF1, 0xE0, 0x3B, 0x0F, 0x30, 0x63, 0x82,
  0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0xE7,
  0x1C, 0x63, 0x8C, 0x00, 0xFF, 0xFF, 0xF0, 0x27, 0xFF, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0x83, 0xFE, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0F, 0xC0, 0x7E, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1C,
  0xE0, 0xE7, 0x0E, 0x1C, 0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0x83, 0xC3,
  0xE7, 0xFF, 0xB3, 0xB9, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x80, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0xC3, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC2, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x72, 0x03, 0xCE, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xD8, 0x07, 0xE0, 0x3B, 0x81,
  0xCE, 0x06, 0x30, 0x39, 0xC1, 0xC7, 0x0E, 0x1C, 0x70, 0x71, 0x83, 0x8F,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x72, 0x03, 0xCE, 0x3E, 0x3F, 0xF0, 0x7F,
  0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x73, 0xC1, 0xFF, 0x87, 0xCF, 0x1C, 0x1C, 0xF0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0xC3, 0x87, 0x1E, 0x1F, 0xF0,
  0x3F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x87, 0xDE, 0x38, 0x71, 0x81, 0x8C, 0x1C, 0x60,
  0xE3, 0x8F, 0x1E, 0xF0, 0x7E, 0x03, 0xE0, 0x7B, 0x87, 0x8E, 0x70, 0x7B,
  0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x3C, 0x78, 0xFF, 0x83, 0xF8, 0x00,
  0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x7B, 0x83, 0xDE, 0x3C, 0x7F, 0xE1, 0xF7, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x21, 0xE1, 0xFE, 0x0F, 0xC0, 0x00, 0x0C,
  0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0E, 0x3C,
  0x78, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x30, 0x07,
  0x01, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x70, 0x0F, 0x07, 0xE1, 0xF0, 0x7C, 0x0F, 0x00,
  0xC0, 0x08, 0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x30, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00,
  0xF0, 0x78, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x18, 0xE1, 0xFC,
  0xC6, 0x1F, 0xC7, 0x71, 0xC6, 0x3B, 0x1C, 0x31, 0x98, 0xC3, 0x8D, 0xC6,
  0x18, 0x6E, 0x70, 0xC3, 0x63, 0x8E, 0x3B, 0x1C, 0x71, 0x98, 0xE7, 0x98,
  0xE3, 0xEF, 0xC7, 0x0E, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x20, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x6C, 0x00, 0xEC, 0x00, 0xEC, 0x01, 0xCC, 0x01,
  0xCE, 0x03, 0x8E, 0x03, 0x8E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70,
  0x0E, 0xF0, 0x07, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0xE0, 0xF1, 0xC0,
  0xE3, 0x81, 0xC7, 0x07, 0x8C, 0x0E, 0x38, 0x38, 0x7F, 0xE0, 0xFF, 0x81,
  0xC7, 0x87, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF0, 0x23, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF3, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0F, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0xE0, 0xF0, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x10, 0xFF, 0x83, 0xFE,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x87,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x1E, 0x02, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0xFE, 0xE0, 0xFC, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xF0, 0x38, 0x7C, 0x78, 0x3F, 0xF8, 0x1F,
  0xF0, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x80, 0x0F, 0xF0,
  0xFF, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x87, 0x07, 0x83, 0x87, 0x83, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0x80,
  0x73, 0x80, 0x33, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xBC, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0xC0, 0x70, 0xE0, 0x70,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x07, 0xE1, 0xB8, 0x1B, 0x86, 0xE0, 0xEE, 0x3B, 0x83, 0x70,
  0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x0C, 0xE3, 0x9C, 0x71, 0x8C, 0x61, 0xC6,
  0x73, 0x87, 0x19, 0x8E, 0x1C, 0x6E, 0x38, 0x61, 0xB0, 0xE3, 0x87, 0xC3,
  0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xE1, 0xC1, 0xC0, 0x0E, 0x01, 0xC3,
  0xC0, 0x70, 0xF0, 0x1C, 0x7C, 0x07, 0x1F, 0x81, 0x87, 0xE0, 0xE1, 0xB8,
  0x38, 0xE6, 0x0E, 0x39, 0xC3, 0x8E, 0x71, 0xC3, 0x8C, 0x70, 0xC3, 0x9C,
  0x70, 0xE7, 0x1C, 0x39, 0x87, 0x06, 0xE1, 0xC1, 0xF8, 0x60, 0x7E, 0x38,
  0x0F, 0x8E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x79, 0xF0, 0x7F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC7, 0x0F, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x9F, 0x8F, 0xFC,
  0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E,
  0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C,
  0xE0, 0x3C, 0xF0, 0x78, 0x79, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC7, 0x0F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x3C,
  0xE1, 0xE3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x38,
  0x70, 0xE3, 0x83, 0x8E, 0x0F, 0x38, 0x1C, 0xE0, 0x70, 0x01, 0xF0, 0x1F,
  0xF0, 0xFF, 0xC7, 0x82, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x72, 0x03, 0x8F, 0x3E, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xFD,
  0xFF, 0xEF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xF9,
  0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x0E,
  0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x38,
  0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x6C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x1F, 0xC0, 0xF0, 0x3B,
  0x81, 0xE0, 0x77, 0x07, 0xC1, 0xCE, 0x0F, 0x83, 0x9C, 0x3F, 0x0E, 0x38,
  0x7E, 0x1C, 0x70, 0xDC, 0x70, 0xE3, 0xB8, 0xE1, 0xC6, 0x71, 0xC3, 0x9C,
  0xE7, 0x07, 0x31, 0xCE, 0x0E, 0xE3, 0xB8, 0x1D, 0xC7, 0x70, 0x3B, 0x0E,
  0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF8,
  0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0xF0, 0x78,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x03, 0x9C, 0x00, 0x77, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03,
  0x87, 0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x01, 0xE0, 0xE0, 0x3F, 0x03,
  0xF8, 0x1D, 0xC1, 0xCE, 0x1E, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x77, 0x03,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x1C, 0x71,
  0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x1C, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x03, 0x00, 0x1C,
  0x01, 0xE0, 0x0F, 0x80, 0xFC, 0x06, 0x60, 0x73, 0x83, 0x0C, 0x38, 0x63,
  0x83, 0x98, 0x0D, 0xC0, 0x7C, 0x01, 0x80, 0xFF, 0xE0, 0xF3, 0x8C, 0x70,
  0x07, 0x9C, 0x3F, 0x71, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE1, 0xE3, 0xCF,
  0x87, 0xFE, 0x0F, 0x38, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE7, 0x07, 0x7E, 0x1F, 0xFC, 0x78, 0x71, 0xE1, 0xC7,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x39, 0xE0, 0xE7,
  0x87, 0x1F, 0x3C, 0x6F, 0xE3, 0x9F, 0x00, 0x03, 0xF0, 0xFE, 0x1F, 0xE3,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x08, 0x7F, 0x83, 0xF8, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x81, 0xE7, 0x07, 0xEE, 0x1F, 0xF8,
  0x78, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC1, 0xE3, 0x87, 0x87, 0x9F, 0x07, 0xFE, 0x07, 0x9C,
  0x00, 0x03, 0xC0, 0xFE, 0x1E, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x71, 0xEF,
  0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x0C, 0x7F, 0xC3,
  0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xC8, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xCE, 0x0F, 0xDC,
  0x3F, 0xF0, 0xF1, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC1, 0xE3, 0x83, 0xC7, 0x0F, 0x0F, 0x3E, 0x0F, 0xDC,
  0x0F, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x84, 0x0E, 0x0F, 0x7C, 0x1F,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE7, 0x07, 0x7E, 0x1F, 0xFC, 0x78, 0x71, 0xC1, 0xC7,
  0x07, 0x3C, 0x1C, 0xE0, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7,
  0x07, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xC0, 0x02, 0x07, 0x0F, 0x06, 0x00,
  0x00, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0x8E, 0x1E, 0x1C, 0x78, 0x38, 0xE0, 0x73, 0x80, 0xCE, 0x03,
  0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0xE3, 0x81, 0xC7,
  0x83, 0x87, 0x07, 0x0E, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x07, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0x0C, 0xF0, 0xF0, 0x77, 0xE7, 0xE1, 0xFF,
  0xBF, 0xC7, 0x87, 0x8F, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x63, 0x83, 0x83,
  0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x1C,
  0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x38, 0x38,
  0x38, 0x0C, 0xF0, 0x77, 0xE1, 0xFF, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x73,
  0xC1, 0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x71,
  0xC1, 0xC7, 0x07, 0x38, 0x1C, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x70, 0xE7,
  0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x0E, 0x39, 0xF1, 0xFF, 0x07, 0xE0, 0x06, 0x38, 0x0D, 0xF8, 0x3F,
  0xF8, 0x78, 0x70, 0xF0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x71, 0xE0, 0xE3, 0xC3, 0x87, 0xCF, 0x0F, 0xFC, 0x19,
  0xF0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x8C, 0x3F, 0x71, 0xFF, 0x8F, 0x1E, 0x38, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C,
  0xE1, 0xE3, 0xCF, 0x87, 0xEE, 0x0F, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0xF1, 0xDE, 0x1F,
  0xE1, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x07, 0xC3, 0xFC, 0xF3,
  0x9C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x1D, 0x87, 0x3F, 0xE7, 0xF8, 0x0C, 0x06, 0x07, 0x07, 0xF7, 0xFF,
  0xFC, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0xF2, 0x3E, 0x1F, 0x00, 0x1C, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38,
  0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x0F, 0x38,
  0x38, 0xE1, 0xE3, 0xCF, 0x87, 0xEE, 0x1F, 0x38, 0xC0, 0x7C, 0x0F, 0xE0,
  0xEE, 0x1E, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x30, 0xE7, 0x0E, 0x60, 0xEE,
  0x0E, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE0, 0xE0, 0xFC, 0x3C,
  0x3B, 0x87, 0x87, 0x71, 0xF0, 0xEE, 0x36, 0x39, 0xCE, 0xC7, 0x39, 0x99,
  0xC7, 0x33, 0x38, 0xEE, 0x66, 0x1D, 0x8D, 0xC3, 0xF1, 0xB0, 0x6C, 0x3E,
  0x0D, 0x87, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x0E,
  0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0x77, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xEE, 0x03, 0xCE, 0x07, 0x1C,
  0x1C, 0x38, 0x70, 0x38, 0x06, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x01,
  0x9C, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x30, 0x1E, 0x03, 0xE0,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x01, 0xE0, 0x3E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3E,
  0x07, 0x81, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x07, 0xC0, 0xF0, 0x10, 0x00, 0xFC, 0x1F, 0xFF, 0x87, 0xF8, 0x1E,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 11, 3, -21 },
  { 31, 17, 21, 17, 0, -21 },
  { 76, 13, 24, 14, 1, -22 },
  { 115, 19, 21, 22, 2, -21 },
  { 165, 16, 21, 17, 1, -21 },
  { 207, 4, 8, 6, 3, -21 },
  { 211, 9, 26, 8, 1, -21 },
  { 241, 9, 26, 8, -2, -21 },
  { 271, 12, 12, 14, 3, -22 },
  { 289, 12, 14, 15, 2, -17 },
  { 310, 6, 7, 7, -1, -3 },
  { 316, 7, 3, 9, 1, -9 },
  { 319, 4, 4, 7, 0, -4 },
  { 321, 14, 21, 11, -1, -21 },
  { 358, 13, 21, 14, 1, -21 },
  { 393, 9, 21, 14, 3, -21 },
  { 417, 14, 21, 14, 0, -21 },
  { 454, 14, 21, 14, 0, -21 },
  { 491, 14, 21, 14, 0, -21 },
  { 528, 14, 21, 14, 0, -21 },
  { 565, 14, 21, 14, 1, -21 },
  { 602, 13, 21, 14, 2, -21 },
  { 637, 13, 21, 14, 1, -21 },
  { 672, 13, 21, 14, 1, -21 },
  { 707, 7, 16, 7, 0, -16 },
  { 721, 8, 20, 7, -1, -16 },
  { 741, 12, 14, 15, 2, -17 },
  { 762, 12, 8, 15, 2, -14 },
  { 774, 12, 14, 15, 2, -17 },
  { 795, 10, 21, 11, 2, -21 },
  { 822, 21, 24, 22, 1, -21 },
  { 885, 16, 21, 15, -2, -21 },
  { 927, 15, 21, 16, 1, -21 },
  { 967, 15, 21, 15, 2, -21 },
  { 1007, 16, 21, 17, 1, -21 },
  { 1049, 14, 21, 14, 1, -21 },
  { 1086, 14, 21, 13, 1, -21 },
  { 1123, 16, 21, 18, 2, -21 },
  { 1165, 17, 21, 18, 1, -21 },
  { 1210, 12, 21, 9, -1, -21 },
  { 1242, 12, 27, 8, -4, -21 },
  { 1283, 17, 21, 15, 1, -21 },
  { 1328, 10, 21, 13, 1, -21 },
  { 1355, 22, 21, 23, 1, -21 },
  { 1413, 18, 21, 19, 1, -21 },
  { 1461, 16, 21, 19, 2, -21 },
  { 1503, 14, 21, 15, 1, -21 },
  { 1540, 16, 26, 19, 2, -21 },
  { 1592, 14, 21, 15, 1, -21 },
  { 1629, 14, 21, 14, 0, -21 },
  { 1666, 14, 21, 13, 2, -21 },
  { 1703, 16, 21, 18, 2, -21 },
  { 1745, 14, 21, 15, 3, -21 },
  { 1782, 23, 21, 23, 3, -21 },
  { 1843, 19, 21, 14, -2, -21 },
  { 1893, 13, 21, 14, 3, -21 },
  { 1928, 16, 21, 14, -1, -21 },
  { 1970, 12, 26, 9, -1, -21 },
  { 2009, 6, 21, 11, 3, -21 },
  { 2025, 11, 26, 9, -2, -21 },
  { 2061, 13, 13, 15, 1, -21 },
  { 2083, 11, 1, 11, -3, 3 },
  { 2085, 5, 4, 8, 4, -22 },
  { 2088, 14, 16, 15, 1, -16 },
  { 2116, 14, 22, 15, 0, -22 },
  { 2155, 12, 16, 12, 1, -16 },
  { 2179, 15, 22, 15, 1, -22 },
  { 2221, 12, 16, 14, 1, -16 },
  { 2245, 15, 29, 9, -3, -22 },
  { 2300, 15, 23, 15, 0, -16 },
  { 2344, 14, 22, 15, 0, -22 },
  { 2383, 8, 22, 7, 0, -22 },
  { 2405, 12, 29, 7, -4, -22 },
  { 2449, 15, 22, 14, 0, -22 },
  { 2491, 8, 22, 7, 0, -22 },
  { 2513, 22, 16, 23, 0, -16 },
  { 2557, 14, 16, 15, 0, -16 },
  { 2585, 13, 16, 15, 1, -16 },
  { 2611, 15, 23, 15, -1, -16 },
  { 2655, 14, 23, 15, 1, -16 },
  { 2696, 12, 16, 11, 0, -16 },
  { 2720, 11, 16, 12, 0, -16 },
  { 2742, 9, 19, 9, 1, -19 },
  { 2764, 14, 16, 15, 1, -16 },
  { 2792, 12, 16, 13, 2, -16 },
  { 2816, 19, 16, 20, 2, -16 },
  { 2854, 15, 16, 13, -1, -16 },
  { 2884, 17, 23, 13, -3, -16 },
  { 2933, 13, 16, 11, -1, -16 },
  { 2959, 12, 26, 10, 0, -21 },
  { 2998, 2, 29, 14, 6, -22 },
  { 3006, 11, 26, 10, -1, -21 },
  { 3042, 12, 4, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC29PT7B_H_
