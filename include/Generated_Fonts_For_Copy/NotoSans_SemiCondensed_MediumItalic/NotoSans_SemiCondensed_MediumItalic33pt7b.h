#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC3, 0xE0, 0xE0, 0x39, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xE3,
  0x18, 0xE3, 0x1C, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x30, 0xC0, 0x1C, 0x30,
  0x07, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x8E,
  0x00, 0xC3, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x1C, 0x01, 0x86, 0x00,
  0xE1, 0x80, 0x38, 0xE0, 0x0C, 0x38, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0xE0, 0xFF, 0xE3, 0xFB, 0x87, 0x31,
  0x0E, 0x60, 0x3C, 0xC0, 0x79, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xBC, 0x03, 0x38, 0x06, 0x70, 0x08, 0xE4, 0x33,
  0xCF, 0x6F, 0x1F, 0xFC, 0x3F, 0xF0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x70, 0x7E, 0x03, 0x83, 0xFC, 0x0E, 0x0E, 0x70,
  0x70, 0x71, 0xC3, 0x81, 0xC7, 0x0E, 0x06, 0x1C, 0x70, 0x38, 0x71, 0x80,
  0xE1, 0x8E, 0x03, 0x8E, 0x70, 0x0E, 0x39, 0x9F, 0x39, 0xCE, 0xFE, 0xFF,
  0x77, 0x19, 0xF9, 0x9C, 0x73, 0xCE, 0x61, 0x80, 0x73, 0x86, 0x01, 0x8E,
  0x18, 0x0E, 0x38, 0xE0, 0x70, 0xC3, 0x81, 0x83, 0x0C, 0x0E, 0x0C, 0x70,
  0x70, 0x39, 0xC1, 0x80, 0xFE, 0x0E, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1C, 0x78, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0,
  0x38, 0x70, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0xC1, 0xCF, 0x70, 0xF7, 0x9E, 0x3B, 0xC3, 0xCE, 0xE0, 0xF7, 0x38, 0x1F,
  0xCE, 0x03, 0xE3, 0x80, 0xF0, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFE, 0xF0,
  0xFE, 0x1E, 0x3B, 0xDE, 0xE7, 0x39, 0x8C, 0xE0, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x18, 0xE0, 0x7B, 0x03, 0xFC, 0xF1,
  0xFF, 0xC1, 0xFF, 0x0F, 0x80, 0x76, 0x07, 0x9C, 0x1C, 0x70, 0x10, 0xE0,
  0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x3C, 0x71, 0xE3, 0x87, 0x1C,
  0x78, 0xFF, 0xFF, 0xFE, 0x7B, 0xFE, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x07, 0xF0, 0x1F, 0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0x81, 0xCF, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03,
  0xBC, 0x07, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0x87,
  0x0F, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xC0, 0xF0, 0xFC, 0x7E,
  0x7F, 0xBE, 0xEE, 0x79, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0x20, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xE1,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x06, 0x0F,
  0x04, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x80, 0x78, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xDE, 0x03, 0x9C, 0x07, 0x1C,
  0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7A, 0x00, 0xFF,
  0x81, 0xFF, 0x81, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC8, 0x0F, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xC0, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x39, 0xF0, 0x7B, 0xF8, 0x77,
  0xF8, 0x7C, 0x3C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0x70, 0x38, 0x70, 0x78, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1E, 0x1C, 0x1E, 0x78, 0x1F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xDE,
  0x1E, 0x1E, 0x78, 0x1C, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xCF,
  0x07, 0x9F, 0xBE, 0x1F, 0xF8, 0x1F, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xEF, 0xC7, 0xFB, 0x87, 0xEF, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x00, 0x0E, 0x1F, 0x1E, 0x1E, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0xF8, 0x70, 0x03, 0x81,
  0xF0, 0x7C, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x38, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x0E, 0x00,
  0x20, 0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xE3, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x1C,
  0x1F, 0xC6, 0x38, 0x7F, 0xC6, 0x38, 0xF1, 0x87, 0x70, 0xE1, 0x86, 0x71,
  0xC3, 0x86, 0x61, 0x83, 0x86, 0x63, 0x83, 0x0E, 0xE3, 0x87, 0x0E, 0xE3,
  0x87, 0x0C, 0xE3, 0x87, 0x1C, 0xE3, 0x8F, 0x38, 0xE3, 0xFB, 0xF8, 0x61,
  0xF3, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x80, 0x1F, 0x9F, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78,
  0xE0, 0x38, 0x78, 0x3C, 0x3C, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0F,
  0xE0, 0x07, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC3, 0xF0, 0xE0,
  0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x0E, 0x07, 0x87,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x70, 0x1C,
  0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x03, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xE1,
  0xF0, 0x61, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x38, 0xFE, 0x0E, 0x07, 0x83, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xC7, 0x01, 0xE1, 0xC0, 0xF8, 0xF0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0x06, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0xFE, 0xF0, 0x7F, 0xBC, 0x1F, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0x78,
  0x0E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x1E,
  0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x80, 0x38, 0x38, 0x07, 0x83, 0x80, 0x78,
  0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x07, 0x01, 0xE1,
  0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0xF0, 0x1C, 0x3C, 0x07,
  0x8F, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x78,
  0xF0, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x77, 0x01,
  0xDC, 0x3B, 0x80, 0xEE, 0x1D, 0xC0, 0xEF, 0x0E, 0xE0, 0x77, 0x07, 0x70,
  0x73, 0x87, 0xB8, 0x39, 0xC3, 0x9C, 0x39, 0xE1, 0xC6, 0x1C, 0xE0, 0xE3,
  0x1C, 0x70, 0x71, 0x8E, 0x38, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x1E, 0x1C,
  0x3F, 0x0E, 0x0E, 0x1F, 0x87, 0x0F, 0x0F, 0x83, 0x87, 0x07, 0xC3, 0xC3,
  0x83, 0xC1, 0xE1, 0xC1, 0xE0, 0xE0, 0x07, 0x80, 0x38, 0x7C, 0x03, 0xC3,
  0xE0, 0x1C, 0x1F, 0x00, 0xE0, 0xFC, 0x07, 0x07, 0xE0, 0x38, 0x77, 0x03,
  0xC3, 0xBC, 0x1C, 0x1C, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x38, 0x78,
  0xE3, 0xC3, 0x87, 0x1C, 0x1C, 0x38, 0xE0, 0xE1, 0xE7, 0x07, 0x07, 0x38,
  0x70, 0x3B, 0x83, 0x81, 0xDC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x0F, 0x01,
  0xF8, 0x70, 0x0F, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xC1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x78,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xE0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x87, 0x83, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xC7, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x78, 0x1E, 0x3C, 0x0E, 0x1C,
  0x07, 0x0E, 0x07, 0x87, 0x03, 0xC7, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0x80, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xC1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x78,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xE0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x87, 0x83, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1E,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x1E, 0x3C, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF0, 0x38, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x70, 0x70, 0x78, 0x70,
  0x78, 0xF0, 0x38, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0x00, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0x86, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x78,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCF,
  0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80,
  0xFE, 0x01, 0xE0, 0x3B, 0x80, 0xF8, 0x1E, 0xE0, 0x3E, 0x07, 0x38, 0x1F,
  0x83, 0xCE, 0x07, 0xE0, 0xE3, 0x83, 0xB8, 0x38, 0xE0, 0xEE, 0x1E, 0x38,
  0x3B, 0x87, 0x0E, 0x1C, 0xE3, 0xC3, 0x87, 0x38, 0xE0, 0xE3, 0x8E, 0x38,
  0x38, 0xE3, 0x9C, 0x0F, 0x70, 0xE7, 0x03, 0xDC, 0x3B, 0xC0, 0xE6, 0x0E,
  0xE0, 0x3B, 0x83, 0xB8, 0x0E, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C,
  0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xC0, 0x3C, 0x00,
  0x03, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x83, 0xC0, 0x1C,
  0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7B, 0x80, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x03,
  0xC7, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x81, 0xE0, 0x3C,
  0x1E, 0x00, 0xE0, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x70,
  0x78, 0x70, 0x70, 0x70, 0xF0, 0x78, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x40, 0xFC, 0x0F, 0xE0, 0x00, 0xE0, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0xEE, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0x63, 0x80,
  0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xF3,
  0x9C, 0x71, 0x80, 0x03, 0xC7, 0x0F, 0xF7, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xB8, 0x7F,
  0xB8, 0x3E, 0x70, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x3C, 0x0E, 0xFE, 0x0F, 0xFF, 0x0F,
  0x8F, 0x1F, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1C, 0x7C, 0x3C, 0x7E,
  0xF8, 0x77, 0xF0, 0xE3, 0xE0, 0x03, 0xF0, 0x3F, 0xC7, 0xFE, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x8F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x07, 0x8E, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0x87, 0x87, 0x83,
  0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC1, 0xFE, 0xE0,
  0xFF, 0x60, 0x3E, 0x30, 0x00, 0x03, 0xF0, 0x1F, 0xE1, 0xFF, 0xC7, 0x8F,
  0x3C, 0x1C, 0xE0, 0xF7, 0x83, 0x9C, 0x7E, 0x7F, 0xF3, 0xFF, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x01, 0x1F, 0x38, 0x3F, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF3, 0x83, 0xFD, 0xC3, 0xFF, 0xC1, 0xE1,
  0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x3C,
  0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0,
  0x7F, 0xB8, 0x3F, 0xB8, 0x0F, 0x9C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x83, 0x03, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x7C, 0x0E, 0xFE, 0x0F, 0xFF, 0x0F, 0x8F, 0x1F, 0x07,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E,
  0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C,
  0xF0, 0x38, 0x01, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x00, 0x00, 0x10, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0xF0, 0x1F, 0x80, 0xF0,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x0F, 0x0E, 0x0F, 0x07, 0x0F, 0x03, 0x8F,
  0x03, 0xCF, 0x01, 0xCF, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8F, 0x03, 0xC3, 0x81,
  0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x3C, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x00,
  0x0E, 0x7C, 0x3E, 0x07, 0x7F, 0x3F, 0x83, 0xFF, 0xBF, 0xC1, 0xF1, 0xF8,
  0xF1, 0xF0, 0xF8, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1C, 0x38, 0x1C,
  0x0E, 0x3C, 0x0E, 0x07, 0x1E, 0x0F, 0x07, 0x8E, 0x07, 0x03, 0xC7, 0x03,
  0x81, 0xC3, 0x81, 0xC0, 0xE3, 0xC0, 0xE0, 0x71, 0xE0, 0xF0, 0x78, 0xE0,
  0x70, 0x38, 0x70, 0x38, 0x1C, 0x78, 0x1C, 0x0E, 0x00, 0x0E, 0x7C, 0x0E,
  0xFE, 0x0F, 0xFF, 0x1F, 0x8F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78,
  0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xF0, 0xE3, 0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xB8, 0x0F,
  0x70, 0x1F, 0xE0, 0x3B, 0xC0, 0x77, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x1C,
  0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x07, 0x3E, 0x03, 0xBF, 0x81,
  0xFF, 0xE0, 0xF8, 0xF0, 0xF8, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07,
  0x0E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0,
  0x70, 0xF8, 0x78, 0x7E, 0xF8, 0x3B, 0xF8, 0x1C, 0xF8, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xE7, 0x0F, 0xF7, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xB8, 0x7F,
  0x70, 0x3E, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x78, 0x77, 0xC3, 0xFE,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x07, 0xF0, 0xFF, 0xC7, 0xFC, 0x78, 0x23, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x72,
  0x07, 0x9E, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0x0E, 0x06, 0x07, 0x03, 0x87,
  0xFF, 0xFF, 0xFE, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x8F, 0xC3, 0xE0, 0x1C, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C,
  0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0x7B, 0xB8, 0x7F, 0x30, 0x3E, 0x70, 0xE0, 0x3F, 0x80, 0xEE,
  0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0xE1, 0xC1,
  0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x3F, 0x83, 0xE0, 0xEE, 0x0F, 0x87,
  0xB8, 0x3E, 0x1C, 0xE1, 0xF8, 0x73, 0x86, 0xE3, 0x8E, 0x3B, 0x8E, 0x38,
  0xEE, 0x78, 0xE7, 0x39, 0xC3, 0x9C, 0xEF, 0x0E, 0x63, 0xB8, 0x3B, 0x8E,
  0xE0, 0xEC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x87, 0x07, 0x83, 0xC3,
  0x80, 0xE3, 0x80, 0x73, 0xC0, 0x3D, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xEF, 0x00, 0xF3, 0x80,
  0xF1, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x0E, 0x01,
  0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x18, 0x07, 0xC0, 0x7E,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x3F, 0x01, 0xE0, 0x1F, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x1E, 0x00,
  0xF8, 0x0B, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x03, 0xE0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0x80, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 24, 9, 0, -24 },
  { 28, 11, 9, 13, 3, -24 },
  { 41, 18, 24, 19, 1, -24 },
  { 95, 15, 27, 16, 1, -25 },
  { 146, 22, 24, 25, 2, -24 },
  { 212, 18, 24, 20, 1, -24 },
  { 266, 5, 9, 7, 3, -24 },
  { 272, 11, 29, 10, 1, -24 },
  { 312, 10, 29, 10, -2, -24 },
  { 349, 14, 14, 16, 3, -25 },
  { 374, 14, 16, 17, 2, -20 },
  { 402, 7, 8, 8, -2, -4 },
  { 409, 8, 3, 10, 1, -10 },
  { 412, 5, 4, 8, 0, -4 },
  { 415, 17, 24, 12, -2, -24 },
  { 466, 15, 24, 16, 1, -24 },
  { 511, 10, 24, 16, 4, -24 },
  { 541, 17, 24, 16, -1, -24 },
  { 592, 16, 24, 16, 0, -24 },
  { 640, 16, 24, 16, 0, -24 },
  { 688, 15, 24, 16, 1, -24 },
  { 733, 16, 24, 16, 1, -24 },
  { 781, 15, 24, 16, 2, -24 },
  { 826, 15, 24, 16, 1, -24 },
  { 871, 15, 24, 16, 1, -24 },
  { 916, 8, 18, 8, 0, -18 },
  { 934, 10, 22, 8, -2, -18 },
  { 962, 14, 16, 17, 2, -20 },
  { 990, 14, 9, 17, 2, -16 },
  { 1006, 14, 16, 17, 2, -20 },
  { 1034, 12, 24, 13, 2, -24 },
  { 1070, 24, 27, 25, 1, -24 },
  { 1151, 17, 24, 17, -2, -24 },
  { 1202, 17, 24, 18, 1, -24 },
  { 1253, 17, 24, 17, 2, -24 },
  { 1304, 18, 24, 20, 1, -24 },
  { 1358, 16, 24, 15, 1, -24 },
  { 1406, 16, 24, 15, 1, -24 },
  { 1454, 18, 24, 20, 2, -24 },
  { 1508, 20, 24, 20, 1, -24 },
  { 1568, 14, 24, 11, -1, -24 },
  { 1610, 14, 31, 9, -5, -24 },
  { 1665, 19, 24, 17, 1, -24 },
  { 1722, 11, 24, 14, 1, -24 },
  { 1755, 25, 24, 26, 1, -24 },
  { 1830, 21, 24, 21, 1, -24 },
  { 1893, 19, 24, 21, 2, -24 },
  { 1950, 17, 24, 17, 1, -24 },
  { 2001, 19, 30, 21, 2, -24 },
  { 2073, 16, 24, 17, 1, -24 },
  { 2121, 16, 24, 15, 0, -24 },
  { 2169, 15, 24, 15, 3, -24 },
  { 2214, 19, 24, 20, 2, -24 },
  { 2271, 17, 24, 17, 3, -24 },
  { 2322, 26, 24, 26, 3, -24 },
  { 2400, 21, 24, 16, -2, -24 },
  { 2463, 16, 24, 16, 3, -24 },
  { 2511, 18, 24, 15, -1, -24 },
  { 2565, 13, 29, 10, -1, -24 },
  { 2613, 7, 24, 12, 3, -24 },
  { 2634, 12, 29, 10, -2, -24 },
  { 2678, 15, 15, 17, 1, -24 },
  { 2707, 13, 2, 12, -3, 3 },
  { 2711, 5, 5, 9, 5, -25 },
  { 2715, 16, 18, 17, 1, -18 },
  { 2751, 16, 25, 17, 0, -25 },
  { 2801, 13, 18, 14, 1, -18 },
  { 2831, 17, 25, 17, 1, -25 },
  { 2885, 14, 18, 16, 1, -18 },
  { 2917, 18, 33, 10, -4, -25 },
  { 2992, 17, 26, 17, 0, -18 },
  { 3048, 16, 25, 17, 0, -25 },
  { 3098, 9, 25, 8, 0, -25 },
  { 3127, 13, 33, 8, -4, -25 },
  { 3181, 17, 25, 15, 0, -25 },
  { 3235, 9, 25, 8, 0, -25 },
  { 3264, 25, 18, 26, 0, -18 },
  { 3321, 16, 18, 17, 0, -18 },
  { 3357, 15, 18, 17, 1, -18 },
  { 3391, 17, 26, 17, -1, -18 },
  { 3447, 16, 26, 17, 1, -18 },
  { 3499, 13, 18, 12, 0, -18 },
  { 3529, 13, 18, 13, 0, -18 },
  { 3559, 9, 22, 11, 2, -22 },
  { 3584, 16, 18, 17, 1, -18 },
  { 3620, 14, 18, 14, 2, -18 },
  { 3652, 22, 18, 22, 2, -18 },
  { 3702, 17, 18, 15, -1, -18 },
  { 3741, 19, 26, 14, -3, -18 },
  { 3803, 14, 18, 13, -1, -18 },
  { 3835, 13, 29, 11, 0, -24 },
  { 3883, 3, 33, 16, 7, -25 },
  { 3896, 13, 29, 11, -2, -24 },
  { 3944, 14, 5, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC33PT7B_H_
