#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x3C, 0x3E, 0x01, 0xFC, 0x3C,
  0x0C, 0x01, 0xF8, 0x3C, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x03, 0xF8, 0x78,
  0x00, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xF8, 0x78,
  0x00, 0x03, 0xF8, 0xF0, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xFE, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x03, 0x87,
  0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x0F, 0x07, 0xF0, 0x40, 0x0F, 0x0F,
  0xE0, 0x70, 0x0F, 0x1F, 0xE0, 0x7E, 0x0F, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x1F, 0x81, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0xFF, 0x8F, 0xC0, 0xFC, 0x3E,
  0x1F, 0xFC, 0xFC, 0x0F, 0xC7, 0xE3, 0xFF, 0xE7, 0xC1, 0xF8, 0xFC, 0x7F,
  0xFF, 0x7E, 0x3F, 0x8F, 0x8F, 0xE3, 0xF7, 0xFF, 0xF1, 0xF8, 0xFC, 0x3F,
  0x7F, 0xFE, 0x3F, 0x1F, 0x81, 0xF3, 0xFF, 0xC3, 0xE1, 0xF0, 0x1F, 0x1F,
  0xF8, 0x7E, 0x3F, 0x01, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x1F, 0x00, 0x03, 0xF0,
  0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7C,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xF0,
  0x3F, 0xCF, 0xE0, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0x7F, 0x9F, 0xC1, 0xFC, 0x00,
  0x7F, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFF, 0x0F,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x10, 0x03, 0xF0, 0x03, 0x80, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0xE1, 0xF0, 0x03, 0xFF, 0x3C, 0x00, 0x7F, 0xFF, 0x81, 0xF7, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0x9F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFB, 0xE0,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xF0, 0xFC, 0x03, 0xFC,
  0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xC0, 0x3F, 0x00, 0x18, 0x07, 0xF0,
  0x02, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x0E, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFB, 0xF9, 0xFF, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x0F, 0xE0, 0xE0,
  0x7F, 0x02, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x0F,
  0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x04, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x60, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x60, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x3F, 0xF0, 0x1F,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0xF8, 0x03, 0xF9,
  0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x74, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFF,
  0x0F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF9, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x3F, 0x80,
  0x3F, 0xFC, 0x7E, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7C, 0x03, 0xFC, 0x18, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x3E, 0x0F,
  0xC0, 0x1F, 0xFF, 0xF0, 0x3E, 0x0F, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x1F,
  0x80, 0x7F, 0x03, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x7C,
  0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0xFC,
  0x0F, 0x80, 0x1F, 0x80, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0xF8,
  0x0F, 0x80, 0x7F, 0x01, 0xF8, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0xF8,
  0x0F, 0x80, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xE0, 0xF8,
  0x0F, 0xC3, 0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF, 0xC0, 0xF8,
  0x07, 0xFF, 0x8F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x0C, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x01,
  0xFF, 0x80, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xE3, 0xFC, 0x00, 0x7F, 0xFF,
  0x0F, 0xF0, 0x01, 0xFF, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0xFE, 0x00,
  0x1F, 0xFF, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xE0, 0x00,
  0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x3F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE1, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC3, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0xDF, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xF0, 0x03,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0xF8, 0x03, 0xF8,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F,
  0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x81, 0xF8, 0x01, 0xFF, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0x02, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x00, 0x1F, 0xE0, 0x30, 0x00,
  0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x01, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0x9F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF0,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x7F,
  0xFC, 0x3E, 0x01, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x7E, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF,
  0xDF, 0x80, 0x7F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0x1F, 0x80, 0x1F, 0xFE,
  0x1F, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xF8, 0x01, 0xFC, 0xFF, 0xFC, 0x01, 0xFD,
  0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xFE, 0x01, 0xFB, 0xF7, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xF8, 0x7F, 0xC0, 0x7E, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0x80, 0x7C, 0x7F, 0xFF, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC0, 0x10, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0x81, 0xFF,
  0x03, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xF8, 0x7F,
  0x00, 0x0F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0x9F, 0x80, 0x07, 0xFF, 0xE3, 0xF0,
  0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFE,
  0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x1F, 0xF3, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x03, 0xFE,
  0x01, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xBF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0xFC, 0x00,
  0x7F, 0xFF, 0x1F, 0x00, 0x1F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFE, 0xFC,
  0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x9F, 0xC0, 0x01,
  0xFF, 0xE3, 0xF0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0x30, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0xFC,
  0x3F, 0xF8, 0x01, 0xFC, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFE, 0x01, 0xFB,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x06,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x3F,
  0xC0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3E, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0x83, 0xFF,
  0xF0, 0x07, 0xE7, 0xFF, 0xF1, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xBF, 0xBF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF,
  0x03, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xF8,
  0x1F, 0xF0, 0x01, 0xF8, 0x7F, 0xF8, 0x01, 0xF8, 0xFF, 0xFC, 0x01, 0xF9,
  0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0xFF,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFC,
  0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0x9F,
  0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xF8, 0x7F, 0xC0, 0x0F, 0xDF, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFE,
  0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0xC0, 0x01, 0xFC, 0x3F,
  0xF0, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0xFE, 0x3E,
  0x01, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xDF, 0x80,
  0x7F, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x3F, 0x00,
  0x0F, 0xF8, 0x7F, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0xC0,
  0x3E, 0x1F, 0xF0, 0x1F, 0x8F, 0xFC, 0x07, 0xE7, 0xFE, 0x01, 0xFB, 0xFF,
  0x80, 0x7E, 0xFF, 0xE0, 0x3F, 0xFF, 0x18, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0x01, 0xFE, 0x00, 0xE0, 0x3F, 0x80, 0x04,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0x00,
  0x03, 0xFC, 0x30, 0x00, 0xFF, 0x07, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F,
  0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0x9F, 0x80, 0x7F,
  0xFF, 0x1F, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFD, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x3F,
  0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xF7, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xBE,
  0x01, 0xFC, 0x3F, 0x80, 0xFD, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xCF, 0x80,
  0xFE, 0x0F, 0xE0, 0x7E, 0x7C, 0x07, 0xF0, 0x7F, 0x03, 0xF3, 0xE0, 0x3F,
  0x03, 0xF8, 0x3F, 0x1F, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0x87, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x3E, 0x0F, 0xC0, 0x3F,
  0x87, 0xC1, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x0F, 0x87, 0xF0, 0x0F, 0xE3,
  0xF0, 0x7C, 0x3F, 0x00, 0x3F, 0x3F, 0x03, 0xE3, 0xF8, 0x01, 0xF9, 0xF8,
  0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0xF9, 0xFC, 0x00, 0x7E, 0xFC, 0x07,
  0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x01, 0xF7,
  0xF0, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x73,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x80, 0x00, 0xFF, 0xE2, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 50, 18, 1, -49 },
  { 114, 21, 18, 27, 7, -49 },
  { 162, 39, 49, 39, 1, -49 },
  { 401, 32, 56, 34, 1, -52 },
  { 625, 44, 50, 51, 4, -49 },
  { 900, 39, 50, 41, 1, -49 },
  { 1144, 10, 18, 15, 7, -49 },
  { 1167, 23, 60, 20, 2, -49 },
  { 1340, 22, 60, 20, -5, -49 },
  { 1505, 27, 29, 33, 7, -52 },
  { 1603, 30, 32, 36, 4, -40 },
  { 1723, 14, 17, 17, -3, -8 },
  { 1753, 18, 6, 20, 1, -21 },
  { 1767, 9, 10, 17, 1, -9 },
  { 1779, 33, 49, 25, -3, -49 },
  { 1982, 30, 50, 34, 3, -49 },
  { 2170, 21, 49, 34, 8, -49 },
  { 2299, 34, 49, 34, -1, -49 },
  { 2508, 33, 50, 34, 0, -49 },
  { 2715, 33, 49, 34, 0, -49 },
  { 2918, 33, 50, 34, 1, -49 },
  { 3125, 31, 50, 34, 3, -49 },
  { 3319, 32, 49, 34, 4, -49 },
  { 3515, 32, 50, 34, 2, -49 },
  { 3715, 31, 50, 34, 2, -49 },
  { 3909, 15, 38, 17, 1, -37 },
  { 3981, 19, 46, 17, -3, -37 },
  { 4091, 30, 33, 36, 4, -41 },
  { 4215, 30, 20, 36, 4, -34 },
  { 4290, 30, 33, 36, 4, -41 },
  { 4414, 25, 50, 26, 4, -49 },
  { 4571, 48, 55, 52, 3, -49 },
  { 4901, 36, 49, 36, -4, -49 },
  { 5122, 35, 49, 37, 2, -49 },
  { 5337, 35, 50, 36, 4, -49 },
  { 5556, 37, 49, 41, 2, -49 },
  { 5783, 33, 49, 32, 2, -49 },
  { 5986, 33, 49, 30, 2, -49 },
  { 6189, 38, 50, 42, 4, -49 },
  { 6427, 41, 49, 42, 2, -49 },
  { 6679, 28, 49, 22, -2, -49 },
  { 6851, 29, 62, 18, -10, -49 },
  { 7076, 39, 49, 35, 2, -49 },
  { 7315, 24, 49, 30, 2, -49 },
  { 7462, 52, 49, 53, 2, -49 },
  { 7781, 44, 49, 44, 1, -49 },
  { 8051, 38, 50, 44, 4, -49 },
  { 8289, 34, 49, 35, 2, -49 },
  { 8498, 38, 61, 44, 4, -49 },
  { 8788, 34, 49, 36, 2, -49 },
  { 8997, 33, 50, 32, 0, -49 },
  { 9204, 30, 49, 31, 6, -49 },
  { 9388, 39, 50, 41, 4, -49 },
  { 9632, 35, 49, 35, 6, -49 },
  { 9847, 53, 49, 54, 7, -49 },
  { 10172, 43, 49, 34, -4, -49 },
  { 10436, 32, 49, 32, 6, -49 },
  { 10632, 37, 49, 32, -2, -49 },
  { 10859, 26, 60, 20, -1, -49 },
  { 11054, 13, 49, 25, 7, -49 },
  { 11134, 27, 60, 20, -5, -49 },
  { 11337, 32, 30, 35, 1, -49 },
  { 11457, 26, 4, 25, -6, 6 },
  { 11470, 11, 11, 19, 10, -52 },
  { 11486, 32, 38, 36, 3, -37 },
  { 11638, 32, 53, 36, 1, -52 },
  { 11850, 26, 38, 28, 3, -37 },
  { 11974, 35, 53, 36, 3, -52 },
  { 12206, 27, 38, 32, 3, -37 },
  { 12335, 37, 68, 20, -8, -52 },
  { 12650, 35, 53, 36, 0, -37 },
  { 12882, 32, 52, 36, 1, -52 },
  { 13090, 17, 51, 17, 1, -51 },
  { 13199, 27, 67, 17, -9, -51 },
  { 13426, 33, 52, 32, 1, -52 },
  { 13641, 18, 52, 17, 1, -52 },
  { 13758, 50, 37, 54, 1, -37 },
  { 13990, 32, 37, 36, 1, -37 },
  { 14138, 29, 38, 35, 3, -37 },
  { 14276, 35, 53, 36, -2, -37 },
  { 14508, 32, 53, 36, 3, -37 },
  { 14720, 26, 37, 25, 1, -37 },
  { 14841, 27, 38, 27, 0, -37 },
  { 14970, 21, 46, 22, 3, -45 },
  { 15091, 32, 38, 36, 3, -37 },
  { 15243, 29, 37, 30, 4, -37 },
  { 15378, 45, 37, 46, 4, -37 },
  { 15587, 36, 37, 30, -3, -37 },
  { 15754, 39, 53, 30, -6, -37 },
  { 16013, 30, 37, 27, -2, -37 },
  { 16152, 26, 60, 23, 1, -49 },
  { 16347, 6, 68, 33, 14, -52 },
  { 16398, 26, 60, 23, -3, -49 },
  { 16593, 30, 10, 36, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC68PT7B_H_
