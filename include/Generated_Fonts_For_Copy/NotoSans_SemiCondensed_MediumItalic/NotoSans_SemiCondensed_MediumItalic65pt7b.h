#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0x87, 0xF3, 0xF0, 0x7F, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE3, 0xC1, 0xC0, 0x3F, 0x87, 0x80, 0x80, 0x7F, 0x0F, 0x00,
  0x00, 0xFC, 0x1C, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x07, 0xE1, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x1F, 0xC7, 0x00, 0x00,
  0x3F, 0xDE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x77, 0xF8, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x07,
  0x0F, 0xE0, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x78,
  0x3F, 0x00, 0x00, 0xF0, 0xFE, 0x10, 0x01, 0xC1, 0xF8, 0x18, 0x03, 0x87,
  0xF0, 0x7C, 0x0F, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xC0,
  0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xF1,
  0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x7C,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x07, 0xC1, 0xF8,
  0x00, 0x3F, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0x3F, 0x1F, 0x87, 0xF8, 0xF8, 0x0F, 0x87, 0xC3, 0xFF, 0x3E, 0x07,
  0xE3, 0xE3, 0xFF, 0xEF, 0xC1, 0xF1, 0xF8, 0xFF, 0xFB, 0xF0, 0xFC, 0x7C,
  0x7E, 0x3F, 0x7F, 0xFE, 0x3E, 0x3F, 0x07, 0xDF, 0xFF, 0x1F, 0x8F, 0x81,
  0xF3, 0xFF, 0x87, 0xC7, 0xE0, 0x7C, 0x7F, 0xC3, 0xE1, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x01, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xFE, 0xFE, 0x01,
  0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0,
  0x7F, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xF0,
  0x7E, 0x00, 0x3F, 0xBF, 0x83, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0x07,
  0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x87, 0xF0,
  0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x08,
  0x03, 0xF0, 0x01, 0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xF1, 0xF0,
  0x01, 0xFF, 0xBC, 0x00, 0x7F, 0xFF, 0x87, 0xF3, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFE,
  0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0x01, 0xF8, 0x00, 0xC0, 0x3F, 0x80, 0x08, 0x03, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF0, 0x3F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFE, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF9, 0xFC, 0xFF,
  0x1F, 0x87, 0xE1, 0xF8, 0x78, 0x3F, 0x83, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x78,
  0x01, 0xFE, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x38, 0x00, 0xFE, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x3F, 0xC0, 0xE0,
  0x00, 0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x20, 0x00, 0x1F, 0xE0, 0x70, 0x00,
  0x7F, 0xC0, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x01,
  0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x0F, 0xE7, 0xFF, 0x80, 0x3F, 0x3F, 0xFF,
  0x00, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x3F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x07,
  0xFC, 0x7F, 0x00, 0x7F, 0xC3, 0xFC, 0x07, 0xFE, 0x0F, 0xF9, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xCF, 0xC0, 0x1F,
  0xFC, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x06, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xC0, 0x7F, 0x8C,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0xFF, 0x03, 0xE1, 0xF0, 0x03,
  0xFF, 0xF8, 0x1F, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0xF8, 0xF8, 0x07, 0xF8,
  0xFE, 0x07, 0xC7, 0xC0, 0x7F, 0x03, 0xE0, 0x3E, 0x7C, 0x03, 0xF0, 0x1F,
  0x01, 0xF3, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xBF, 0x03, 0xF0, 0x0F, 0xC0,
  0x7D, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xEF, 0x81, 0xF8, 0x03, 0xE0, 0x1F,
  0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xFE,
  0x03, 0xE0, 0x0F, 0x80, 0x7D, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xEF, 0x81,
  0xF0, 0x07, 0xE0, 0x1F, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF3, 0xE0, 0x7C,
  0x01, 0xF0, 0x0F, 0x9F, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0xF8, 0x1F, 0x00,
  0xFC, 0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0xE0, 0x7C, 0x3E, 0x07, 0xE0, 0xFF,
  0x07, 0xE1, 0xF0, 0x3F, 0xDF, 0x7E, 0xFE, 0x0F, 0x80, 0xFF, 0xF3, 0xFF,
  0xE0, 0x7C, 0x07, 0xFF, 0x8F, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x7F, 0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFE,
  0x00, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x0F, 0xFE,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3D, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x03,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xE0,
  0x01, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0xF8,
  0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x41, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0x7F,
  0x80, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xF0, 0x03, 0xF3,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3E, 0x01, 0xF8,
  0x7F, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0x1F,
  0x80, 0xFC, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0x00,
  0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x07,
  0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xDF,
  0x80, 0x03, 0xF0, 0x03, 0xF7, 0xE0, 0x01, 0xFC, 0x00, 0xF9, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x00, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE0,
  0x01, 0xFD, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x07, 0xF0, 0x0F,
  0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xF8, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x1F,
  0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF,
  0x00, 0x1C, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x7F, 0x80, 0x70, 0x00,
  0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x7C, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0xF9, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x80,
  0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0xF8,
  0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x03,
  0xE1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xF0,
  0x0F, 0x8F, 0xE0, 0x00, 0xFC, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x3E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x01,
  0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x9F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x00, 0xFF, 0xF0, 0xF8, 0x03,
  0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x07,
  0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0x9F, 0x80, 0x3F, 0xFE, 0x3E, 0x00, 0x7F,
  0xF8, 0x7C, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0xFC, 0x7F,
  0xF8, 0x01, 0xF9, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F,
  0xC0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x83,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF,
  0x80, 0x7E, 0x3F, 0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x30,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x06, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70,
  0x1F, 0x80, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0x7F,
  0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x07, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xDF,
  0x80, 0x0F, 0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xF1, 0xF0, 0x00, 0x3F, 0xF8,
  0x7C, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x1F, 0xE1, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x08, 0x0F, 0xF0, 0x07, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0x07, 0xC0, 0x03, 0xFF, 0xC3, 0xE0, 0x07, 0xFF,
  0xF3, 0xF0, 0x07, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFE,
  0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC,
  0x03, 0xF0, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x83, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xEF,
  0xE0, 0x03, 0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0xC1,
  0xF8, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x0C, 0x00,
  0x1F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1C,
  0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x7E, 0x3F, 0xFC, 0x01, 0xF9, 0xFF, 0xF8,
  0x07, 0xEF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0x03,
  0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC1, 0xFE,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x21,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x07, 0xEF,
  0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x01,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xF1, 0xFF, 0xF0, 0xFF, 0xFC, 0x01,
  0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x03,
  0xFF, 0x83, 0xFB, 0xE0, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0xFF, 0x80, 0x1F, 0x0F, 0xFF, 0x00, 0x7C,
  0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xFC, 0x0F, 0xDF, 0xFF, 0xF0, 0x3F, 0xFC,
  0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x03, 0xFE, 0x00, 0xFC, 0x1F, 0xF0, 0x03,
  0xF0, 0x7F, 0xC0, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC1,
  0xFF, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x00, 0xF8, 0xFF, 0xFC, 0x00, 0x3E,
  0x7F, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF,
  0xE0, 0x03, 0xF3, 0xFF, 0xF0, 0x01, 0xFC, 0xFF, 0xF8, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x7C, 0x00, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF,
  0xE7, 0xE0, 0x3F, 0xFF, 0xEF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03,
  0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF,
  0xBF, 0x80, 0x3F, 0xFE, 0x7E, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x3F, 0xC1,
  0xF8, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x3F, 0xC0, 0x7E,
  0x3F, 0xE0, 0x3E, 0x3F, 0xE0, 0x1F, 0x3F, 0xF0, 0x1F, 0xBF, 0xF8, 0x0F,
  0xDF, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xF0, 0x3F, 0x80, 0x04, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x30, 0x00, 0xFE, 0x0F, 0x00,
  0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x40, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF0, 0x01,
  0xFE, 0x0F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80, 0x7F, 0xC0, 0xFE, 0x03, 0xFF,
  0x03, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xCF, 0x80,
  0x7F, 0xFE, 0x3E, 0x00, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFB, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xF8, 0x03,
  0xF9, 0xF8, 0x03, 0xFF, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0xC7,
  0xE0, 0x1F, 0x7C, 0x03, 0xF8, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x1F, 0x80,
  0xFD, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xE7,
  0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x1F, 0x03,
  0xF0, 0x3F, 0x07, 0xE3, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x80,
  0xFC, 0x3F, 0x0F, 0x87, 0xF0, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x03, 0xF0,
  0xF8, 0x3E, 0x3F, 0x80, 0x7E, 0x3F, 0x07, 0xC7, 0xE0, 0x0F, 0xC7, 0xC0,
  0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x1F, 0x3F, 0x00, 0x3F, 0x3E, 0x03, 0xE7,
  0xE0, 0x07, 0xE7, 0xC0, 0x7D, 0xF8, 0x00, 0xFD, 0xF0, 0x0F, 0xBF, 0x00,
  0x1F, 0xBE, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x11, 0xFF, 0x00, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x80, 0x01, 0xFF, 0xC8, 0x00, 0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 47, 17, 1, -46 },
  { 101, 20, 16, 25, 7, -46 },
  { 141, 37, 46, 37, 1, -46 },
  { 354, 31, 53, 32, 1, -49 },
  { 560, 42, 48, 49, 4, -47 },
  { 812, 37, 48, 39, 1, -47 },
  { 1034, 9, 16, 14, 7, -46 },
  { 1052, 21, 57, 19, 2, -47 },
  { 1202, 22, 57, 19, -5, -47 },
  { 1359, 27, 28, 32, 6, -50 },
  { 1454, 28, 32, 34, 4, -39 },
  { 1566, 13, 17, 16, -3, -8 },
  { 1594, 17, 6, 19, 1, -20 },
  { 1607, 8, 9, 16, 1, -8 },
  { 1616, 32, 47, 24, -3, -47 },
  { 1804, 29, 48, 32, 3, -47 },
  { 1978, 20, 46, 32, 8, -46 },
  { 2093, 33, 47, 32, -1, -47 },
  { 2287, 32, 48, 32, 0, -47 },
  { 2479, 32, 47, 32, 0, -47 },
  { 2667, 31, 47, 32, 1, -46 },
  { 2850, 30, 48, 32, 3, -47 },
  { 3030, 30, 46, 32, 4, -46 },
  { 3203, 31, 48, 32, 1, -47 },
  { 3389, 29, 48, 32, 2, -47 },
  { 3563, 14, 37, 16, 1, -36 },
  { 3628, 18, 45, 16, -3, -36 },
  { 3730, 28, 31, 34, 4, -39 },
  { 3839, 28, 18, 34, 4, -32 },
  { 3902, 28, 31, 34, 4, -39 },
  { 4011, 23, 48, 25, 4, -47 },
  { 4149, 45, 53, 49, 3, -47 },
  { 4448, 34, 46, 34, -4, -46 },
  { 4644, 34, 46, 35, 1, -46 },
  { 4840, 34, 48, 34, 4, -47 },
  { 5044, 36, 46, 39, 1, -46 },
  { 5251, 32, 46, 30, 1, -46 },
  { 5435, 32, 46, 29, 1, -46 },
  { 5619, 36, 48, 40, 4, -47 },
  { 5835, 40, 46, 40, 1, -46 },
  { 6065, 27, 46, 21, -2, -46 },
  { 6221, 28, 59, 17, -10, -46 },
  { 6428, 39, 46, 34, 1, -46 },
  { 6653, 24, 46, 29, 1, -46 },
  { 6791, 51, 46, 51, 1, -46 },
  { 7085, 42, 46, 42, 1, -46 },
  { 7327, 36, 48, 42, 4, -47 },
  { 7543, 34, 46, 34, 1, -46 },
  { 7739, 36, 58, 42, 4, -47 },
  { 8000, 33, 46, 34, 1, -46 },
  { 8190, 32, 48, 30, 0, -47 },
  { 8382, 30, 46, 30, 5, -46 },
  { 8555, 37, 47, 40, 4, -46 },
  { 8773, 33, 46, 33, 6, -46 },
  { 8963, 51, 46, 52, 6, -46 },
  { 9257, 41, 46, 32, -4, -46 },
  { 9493, 30, 46, 31, 6, -46 },
  { 9666, 36, 46, 30, -2, -46 },
  { 9873, 25, 57, 19, -1, -47 },
  { 10052, 12, 47, 24, 7, -47 },
  { 10123, 26, 57, 19, -5, -47 },
  { 10309, 31, 29, 33, 1, -47 },
  { 10422, 25, 4, 24, -6, 6 },
  { 10435, 11, 11, 18, 9, -50 },
  { 10451, 31, 37, 34, 2, -36 },
  { 10595, 31, 50, 34, 1, -49 },
  { 10789, 26, 37, 27, 2, -36 },
  { 10910, 34, 50, 34, 2, -49 },
  { 11123, 27, 37, 31, 2, -36 },
  { 11248, 34, 66, 20, -7, -50 },
  { 11529, 33, 52, 34, 0, -36 },
  { 11744, 30, 49, 34, 1, -49 },
  { 11928, 17, 48, 16, 1, -48 },
  { 12030, 26, 64, 16, -8, -48 },
  { 12238, 32, 49, 30, 1, -49 },
  { 12434, 17, 49, 16, 1, -49 },
  { 12539, 48, 36, 51, 1, -36 },
  { 12755, 30, 36, 34, 1, -36 },
  { 12890, 29, 37, 33, 2, -36 },
  { 13025, 34, 51, 34, -2, -36 },
  { 13242, 31, 52, 34, 2, -36 },
  { 13444, 25, 36, 24, 1, -36 },
  { 13557, 26, 37, 26, 0, -36 },
  { 13678, 20, 44, 21, 3, -43 },
  { 13788, 30, 36, 34, 3, -35 },
  { 13923, 29, 35, 28, 3, -35 },
  { 14050, 43, 35, 44, 4, -35 },
  { 14239, 34, 35, 29, -3, -35 },
  { 14388, 38, 51, 28, -6, -35 },
  { 14631, 28, 35, 26, -2, -35 },
  { 14754, 25, 56, 22, 1, -46 },
  { 14929, 5, 64, 31, 14, -49 },
  { 14969, 25, 56, 22, -3, -46 },
  { 15144, 28, 10, 34, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC65PT7B_H_
