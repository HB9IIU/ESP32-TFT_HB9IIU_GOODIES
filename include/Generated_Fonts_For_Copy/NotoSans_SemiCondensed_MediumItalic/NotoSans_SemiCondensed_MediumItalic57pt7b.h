#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x3F, 0x0F, 0xCF, 0xC3,
  0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x10, 0x3C,
  0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xB9, 0xF8,
  0x0F, 0xC7, 0x06, 0x03, 0xF0, 0xE0, 0x00, 0x7E, 0x1C, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xE3, 0x80, 0x00,
  0xFE, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3B, 0xF8, 0x00, 0x0F, 0x3F,
  0x00, 0x01, 0xC3, 0xE0, 0x00, 0x38, 0x7E, 0x00, 0x07, 0x0F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x38, 0x7E, 0x18, 0x07, 0x0F, 0xC3, 0xC0, 0xE3, 0xF0,
  0x7F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x00, 0x7C, 0x03,
  0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x3E, 0x01, 0xF1, 0xF0, 0x03,
  0xE0, 0x1F, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0x1E, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x03, 0xC0, 0x7C, 0x3E, 0x00, 0x1E,
  0x03, 0xC3, 0xE0, 0x00, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF1,
  0xFF, 0x3C, 0x1F, 0x1F, 0x1F, 0xF9, 0xE0, 0xF9, 0xF1, 0xFF, 0xEF, 0x8F,
  0x8F, 0x9F, 0x9F, 0x7F, 0xFC, 0xF9, 0xF0, 0x79, 0xFF, 0xCF, 0x8F, 0x83,
  0xEF, 0xFC, 0x7C, 0x78, 0x1F, 0x1F, 0x87, 0xC7, 0xC0, 0xF8, 0x00, 0x7C,
  0x3E, 0x07, 0x80, 0x03, 0xE1, 0xE0, 0x3C, 0x00, 0x3E, 0x1F, 0x01, 0xE0,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x03, 0xE0, 0x0F,
  0x80, 0x78, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x1E, 0x0F,
  0x80, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x3E, 0x00,
  0x1F, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF, 0xC0,
  0x3F, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x87, 0xF0, 0x7E, 0x3F, 0x03, 0xF0,
  0x7C, 0x7E, 0x03, 0xF8, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x7C, 0x00, 0xFD,
  0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x7F,
  0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x8F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7,
  0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x01,
  0xFC, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x30, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7F, 0x1E, 0x00, 0x7F, 0xDE, 0x00,
  0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFE, 0x0F, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0x00, 0x0F, 0xCF, 0x80,
  0x1F, 0x8F, 0x80, 0x3F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x0E, 0x07, 0xE0,
  0x04, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7F, 0xBF, 0x7F, 0x9F, 0x1F, 0x1F, 0x8F, 0x0F, 0xC2, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xE0,
  0x0F, 0xC0, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0xFE, 0x00, 0xE0, 0x07, 0xE0, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x80, 0x00, 0xFE, 0x0E, 0x00, 0x1F, 0xC0, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x04, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC2, 0x00, 0x07, 0xF0, 0x70, 0x03, 0xFC, 0x0F, 0xE3, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x3F,
  0xF0, 0x1F, 0x9F, 0xFE, 0x07, 0xEF, 0xFF, 0x81, 0xF7, 0xFF, 0xF0, 0x7F,
  0xC1, 0xFC, 0x3F, 0xE0, 0x3F, 0x8F, 0xF0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF3, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC,
  0x00, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF1, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x7E, 0x07, 0xFF, 0x3E, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0x1F, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0x7E, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0x01, 0xFC, 0x20, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x07, 0x80, 0x3F, 0xFE, 0x0F, 0x0F, 0x80, 0x7F, 0xFC,
  0x0F, 0x0F, 0x00, 0xFF, 0xFC, 0x0F, 0x1F, 0x01, 0xF8, 0x7C, 0x0F, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x3E, 0x0F, 0x80,
  0x78, 0x0F, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x7C, 0x0F, 0x00, 0xF8, 0x0F,
  0x7C, 0x1F, 0x00, 0xF0, 0x1F, 0x78, 0x1E, 0x00, 0xF0, 0x1F, 0x78, 0x1E,
  0x01, 0xF0, 0x1E, 0x78, 0x3E, 0x01, 0xF0, 0x1E, 0xF8, 0x3E, 0x01, 0xE0,
  0x3E, 0xF8, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8,
  0x3E, 0x07, 0xE0, 0x78, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F,
  0xF1, 0xF0, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x78, 0x1F, 0xF8, 0xFF, 0xC0,
  0x78, 0x0F, 0xF0, 0x7F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF9,
  0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0,
  0x3F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xC0,
  0x1F, 0xE0, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x1F, 0xF8, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x7E,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3E, 0x01,
  0xFE, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8, 0x7E,
  0x00, 0x7F, 0xF8, 0xFE, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xE0, 0xFE,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x02, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x1F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xC1, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0xE0, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7C, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x3F, 0x00, 0xFC, 0x3C, 0x07, 0xC3, 0xF0,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x1F, 0x07, 0xE0, 0x1F, 0x83,
  0xE1, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE7, 0xC0,
  0xFC, 0x03, 0xF0, 0x3E, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xFF, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x7C, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x01,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x7C, 0x01, 0xFF,
  0xC0, 0x03, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0x00, 0x7D, 0xF0, 0x01, 0xF8,
  0x07, 0xEF, 0xC0, 0x0F, 0x80, 0x3F, 0x7E, 0x00, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0x07,
  0xE1, 0xF0, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x7E, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x87, 0xE0,
  0x0F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x03, 0xF1, 0xF0, 0x07, 0xE0, 0x0F,
  0x8F, 0x80, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x03, 0xF7, 0xE0, 0x0F,
  0x80, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xE0, 0x03, 0xEF,
  0x80, 0x3F, 0x00, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x03, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0x80,
  0x3E, 0x00, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7E, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0x7F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x7C, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0xF8, 0x03, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xC3, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x3C, 0x03, 0xFC, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x40, 0x01, 0xFC, 0x0F, 0x00, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xEF, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xCF, 0x80, 0x07, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x8F, 0x80,
  0x1F, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xEF, 0x80, 0x3F, 0x0F, 0x80, 0x3E,
  0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0x80, 0xFC, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x80,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x00, 0xF8, 0x7E,
  0x0F, 0x87, 0xE0, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x0F, 0x9F,
  0x80, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00,
  0x0F, 0xBE, 0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0x0F,
  0xBE, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x40, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x00, 0x3F, 0x81,
  0xE0, 0x1F, 0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0x81, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7E, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0xFF,
  0x81, 0xFE, 0x7D, 0xF0, 0x3F, 0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0x80, 0x3F,
  0xF1, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE7, 0xFE, 0x00, 0xF9, 0xFF, 0xE0,
  0x1F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0xE0,
  0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF8,
  0x07, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xF9, 0xFF, 0xF0, 0x1F, 0x1F, 0xFC, 0x03, 0xC1, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFE, 0x01, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x01, 0x81, 0xFF, 0x1F, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x03,
  0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0x7E, 0x00, 0xFF, 0xFD, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0x07, 0xF1, 0xF7, 0xC0,
  0x1F, 0xFF, 0x9E, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x7F, 0xE3, 0xE0, 0x00,
  0xFF, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xE0,
  0x3E, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7E, 0x03, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x20, 0x7F, 0x81, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xE1, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x78, 0x01, 0xFF, 0xC7, 0xC0,
  0x1F, 0xFF, 0x3E, 0x01, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFC,
  0x0F, 0xF8, 0x07, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF, 0x7C, 0x00, 0xFF, 0xF3,
  0xE0, 0x03, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x08, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x1F,
  0xC0, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE7, 0xFF, 0x00,
  0xF9, 0xFF, 0xE0, 0x1F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1,
  0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7C, 0x1F,
  0xC0, 0x0F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x08, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xF9,
  0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xFE, 0x01, 0xFC, 0x00,
  0xF8, 0xFF, 0xC0, 0xFF, 0xC0, 0x3E, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xBF,
  0xFE, 0x7F, 0xFE, 0x07, 0xDF, 0xFF, 0xBF, 0xFF, 0x81, 0xFF, 0x07, 0xFF,
  0x07, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x83, 0xE0, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x03, 0xE0, 0xFE, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x9F, 0xFE, 0x01,
  0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0x81, 0xFE, 0x03,
  0xF8, 0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xF8, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F,
  0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xF3, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x01, 0xF1, 0xFF, 0x80, 0x07, 0xCF,
  0xFF, 0x00, 0x1F, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0xC7, 0xF8, 0x03, 0xEF, 0xFF, 0xC0, 0x1F,
  0xBF, 0xFE, 0x00, 0x7E, 0x7F, 0xF0, 0x01, 0xF8, 0xFF, 0x80, 0x07, 0xC0,
  0x60, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x1F, 0xFC, 0x7C, 0x07, 0xFF,
  0xCF, 0x81, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF,
  0x7C, 0x03, 0xFF, 0xCF, 0x80, 0x3F, 0xF3, 0xF0, 0x03, 0xFC, 0x7E, 0x00,
  0x18, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0xFC, 0x0F, 0x8F, 0xF0, 0x3E, 0x7F, 0x80, 0xFB, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0x7C, 0x20, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xF8, 0xF8, 0x3F, 0x80, 0x60, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x80, 0x07, 0xE3, 0x00, 0x3F,
  0x8F, 0x83, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x10, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x07, 0xE0, 0x0F,
  0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xFC, 0x7F, 0xF0, 0x3F,
  0xFF, 0x7C, 0x07, 0xFF, 0xCF, 0x80, 0x7F, 0xF1, 0xF0, 0x07, 0xFC, 0x3E,
  0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01,
  0xF0, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0x7E,
  0x7C, 0x03, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0xF0, 0x0F, 0xC7, 0xC0, 0x7F,
  0xC0, 0x3E, 0x1F, 0x01, 0xEF, 0x01, 0xF8, 0x7C, 0x0F, 0xBC, 0x07, 0xC1,
  0xF0, 0x3E, 0xF0, 0x3F, 0x07, 0xC0, 0xF3, 0xC0, 0xFC, 0x1F, 0x07, 0xCF,
  0x03, 0xE0, 0x7C, 0x1E, 0x3C, 0x1F, 0x81, 0xF0, 0xF8, 0xF0, 0x7C, 0x07,
  0xC3, 0xE3, 0xC3, 0xF0, 0x1F, 0x1F, 0x0F, 0x0F, 0x80, 0x7C, 0x7C, 0x3C,
  0x7E, 0x01, 0xF1, 0xE0, 0xF1, 0xF8, 0x07, 0xCF, 0x83, 0xC7, 0xC0, 0x1F,
  0x3C, 0x0F, 0x3F, 0x00, 0x7D, 0xF0, 0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0xF3,
  0xE0, 0x07, 0xFE, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x0F, 0x7C, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x9F,
  0xFC, 0x00, 0x5F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0x00, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 42, 15, 1, -41 },
  { 80, 18, 15, 22, 6, -41 },
  { 114, 32, 41, 32, 1, -41 },
  { 278, 27, 46, 28, 1, -43 },
  { 434, 37, 42, 43, 4, -41 },
  { 629, 32, 42, 34, 1, -41 },
  { 797, 8, 15, 13, 6, -41 },
  { 812, 19, 50, 16, 2, -41 },
  { 931, 19, 50, 16, -4, -41 },
  { 1050, 24, 25, 28, 5, -44 },
  { 1125, 25, 28, 30, 3, -34 },
  { 1213, 12, 14, 14, -3, -7 },
  { 1234, 15, 5, 17, 1, -18 },
  { 1244, 7, 8, 14, 1, -7 },
  { 1251, 28, 41, 21, -3, -41 },
  { 1395, 26, 42, 28, 2, -41 },
  { 1532, 17, 41, 28, 7, -41 },
  { 1620, 29, 41, 28, -1, -41 },
  { 1769, 28, 42, 28, 0, -41 },
  { 1916, 28, 41, 28, 0, -41 },
  { 2060, 27, 42, 28, 1, -41 },
  { 2202, 26, 42, 28, 3, -41 },
  { 2339, 27, 41, 28, 3, -41 },
  { 2478, 27, 42, 28, 1, -41 },
  { 2620, 25, 42, 28, 2, -41 },
  { 2752, 12, 32, 14, 1, -31 },
  { 2800, 16, 38, 14, -3, -31 },
  { 2876, 25, 27, 30, 3, -34 },
  { 2961, 25, 16, 30, 3, -28 },
  { 3011, 25, 27, 30, 3, -34 },
  { 3096, 21, 42, 22, 3, -41 },
  { 3207, 40, 46, 43, 2, -41 },
  { 3437, 30, 41, 30, -3, -41 },
  { 3591, 30, 41, 31, 1, -41 },
  { 3745, 30, 42, 30, 3, -41 },
  { 3903, 32, 41, 34, 1, -41 },
  { 4067, 28, 41, 27, 1, -41 },
  { 4211, 28, 41, 25, 1, -41 },
  { 4355, 32, 42, 35, 3, -41 },
  { 4523, 35, 41, 35, 1, -41 },
  { 4703, 24, 41, 18, -2, -41 },
  { 4826, 25, 52, 15, -9, -41 },
  { 4989, 34, 41, 30, 1, -41 },
  { 5164, 20, 41, 25, 1, -41 },
  { 5267, 44, 41, 45, 1, -41 },
  { 5493, 37, 41, 37, 1, -41 },
  { 5683, 32, 42, 37, 3, -41 },
  { 5851, 29, 41, 30, 1, -41 },
  { 6000, 32, 51, 37, 3, -41 },
  { 6204, 29, 41, 30, 1, -41 },
  { 6353, 28, 42, 27, 0, -41 },
  { 6500, 26, 41, 26, 5, -41 },
  { 6634, 33, 42, 35, 3, -41 },
  { 6808, 29, 41, 29, 5, -41 },
  { 6957, 44, 41, 45, 6, -41 },
  { 7183, 35, 41, 28, -3, -41 },
  { 7363, 27, 41, 27, 5, -41 },
  { 7502, 30, 41, 27, -1, -41 },
  { 7656, 22, 50, 17, -1, -41 },
  { 7794, 11, 41, 21, 6, -41 },
  { 7851, 22, 50, 17, -4, -41 },
  { 7989, 27, 25, 29, 1, -41 },
  { 8074, 21, 4, 21, -5, 5 },
  { 8085, 10, 9, 16, 8, -44 },
  { 8097, 27, 32, 30, 2, -31 },
  { 8205, 27, 44, 30, 1, -43 },
  { 8354, 23, 32, 24, 2, -31 },
  { 8446, 30, 44, 30, 2, -43 },
  { 8611, 24, 32, 27, 2, -31 },
  { 8707, 31, 58, 17, -7, -44 },
  { 8932, 29, 45, 30, 0, -31 },
  { 9096, 27, 43, 30, 1, -43 },
  { 9242, 14, 42, 14, 1, -42 },
  { 9316, 22, 56, 14, -7, -42 },
  { 9470, 28, 43, 27, 1, -43 },
  { 9621, 15, 43, 14, 1, -43 },
  { 9702, 42, 31, 45, 1, -31 },
  { 9865, 27, 31, 30, 1, -31 },
  { 9970, 25, 32, 29, 2, -31 },
  { 10070, 30, 45, 30, -2, -31 },
  { 10239, 27, 45, 30, 2, -31 },
  { 10391, 22, 31, 21, 1, -31 },
  { 10477, 22, 32, 23, 0, -31 },
  { 10565, 17, 39, 18, 3, -38 },
  { 10648, 27, 32, 30, 2, -31 },
  { 10756, 25, 31, 25, 3, -31 },
  { 10853, 38, 31, 39, 3, -31 },
  { 11001, 30, 31, 26, -2, -31 },
  { 11118, 33, 45, 25, -5, -31 },
  { 11304, 24, 31, 23, -1, -31 },
  { 11397, 22, 50, 20, 1, -41 },
  { 11535, 5, 56, 28, 12, -43 },
  { 11570, 22, 50, 20, -3, -41 },
  { 11708, 25, 8, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC57PT7B_H_
