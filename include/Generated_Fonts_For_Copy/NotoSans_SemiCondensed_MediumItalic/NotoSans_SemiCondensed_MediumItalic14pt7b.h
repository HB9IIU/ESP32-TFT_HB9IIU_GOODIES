#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x40, 0x4C, 0x5A, 0x95, 0x20, 0x0B, 0x12, 0x12,
  0x7F, 0x34, 0x24, 0xFE, 0x28, 0x48, 0x58, 0x08, 0x10, 0xF9, 0x47, 0x06,
  0x07, 0x0A, 0x9D, 0xF0, 0x81, 0x00, 0x71, 0x69, 0x25, 0x92, 0x8A, 0xBF,
  0x74, 0x52, 0x49, 0x25, 0x23, 0x80, 0x1C, 0x36, 0x26, 0x3C, 0x18, 0x79,
  0x4A, 0xCE, 0xCE, 0x7B, 0x56, 0x18, 0x88, 0xC4, 0x21, 0x18, 0xC2, 0x10,
  0x80, 0x10, 0x84, 0x31, 0x88, 0x42, 0x31, 0x19, 0x80, 0x10, 0x4F, 0x0F,
  0x71, 0x20, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0x2D, 0x60, 0xF0, 0x70, 0x02,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x39, 0xBC, 0xF3, 0x8E,
  0x38, 0xA6, 0x93, 0xC0, 0x37, 0xA2, 0x26, 0x64, 0x4C, 0x3C, 0x4C, 0x18,
  0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xF8, 0x3C, 0x4C, 0x18, 0x23, 0x83, 0x83,
  0x06, 0x8D, 0xF0, 0x06, 0x18, 0x70, 0xA2, 0xC9, 0xB2, 0xFE, 0x08, 0x30,
  0x3E, 0x40, 0x81, 0x07, 0xC1, 0x81, 0x02, 0x8D, 0xF0, 0x1D, 0x84, 0x30,
  0xBB, 0x28, 0xA2, 0x9B, 0xC0, 0x7E, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x43,
  0x00, 0x1C, 0x4C, 0x89, 0x21, 0x8D, 0x91, 0x62, 0xCC, 0xF0, 0x3C, 0x4D,
  0x9A, 0x34, 0x6F, 0x81, 0x06, 0x19, 0xE0, 0x2C, 0x00, 0x36, 0x13, 0x00,
  0x00, 0x26, 0x4C, 0x0C, 0xEC, 0x30, 0x38, 0x30, 0xFC, 0x00, 0x3F, 0xC1,
  0xC1, 0xC7, 0x73, 0x00, 0xF4, 0xC6, 0x23, 0x23, 0x00, 0xC6, 0x00, 0x1F,
  0x10, 0xD0, 0x3B, 0xD9, 0x2D, 0x26, 0x93, 0x7A, 0x82, 0x60, 0x1F, 0x00,
  0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x32, 0x3E, 0x62, 0x42, 0xC3, 0x3E, 0x33,
  0x23, 0x22, 0x7C, 0x64, 0x46, 0x46, 0x44, 0xF8, 0x1E, 0xC5, 0x06, 0x0C,
  0x10, 0x20, 0x40, 0xC4, 0xF0, 0x3E, 0x33, 0x23, 0x21, 0x63, 0x63, 0x63,
  0x46, 0x4C, 0xF8, 0x3E, 0x60, 0x81, 0x07, 0xCC, 0x10, 0x20, 0x41, 0xF0,
  0x3E, 0x60, 0x81, 0x06, 0x0F, 0x90, 0x20, 0x41, 0x80, 0x1F, 0x72, 0x40,
  0xC0, 0xC0, 0x8E, 0x86, 0x84, 0xC4, 0x7C, 0x31, 0x98, 0x88, 0x44, 0x27,
  0xF3, 0x19, 0x88, 0x84, 0x42, 0x63, 0x00, 0x79, 0x8C, 0x42, 0x11, 0x8C,
  0x47, 0x00, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x38, 0xC0,
  0x33, 0x99, 0x09, 0x05, 0x87, 0x83, 0xC1, 0x20, 0x98, 0x4C, 0x63, 0x00,
  0x31, 0x88, 0x46, 0x31, 0x08, 0x47, 0xC0, 0x30, 0x66, 0x1C, 0xE3, 0x9C,
  0xE6, 0x94, 0xD6, 0x92, 0xB2, 0x76, 0x4C, 0x99, 0x10, 0x30, 0x98, 0x4E,
  0x65, 0x36, 0x93, 0x69, 0x14, 0x8E, 0x46, 0x63, 0x00, 0x3E, 0x62, 0x43,
  0xC3, 0xC3, 0x82, 0x82, 0x86, 0xCC, 0x78, 0x3E, 0x6C, 0x89, 0x16, 0x6F,
  0x90, 0x20, 0x41, 0x80, 0x3E, 0x62, 0x43, 0xC3, 0xC3, 0x82, 0x82, 0x86,
  0xCC, 0x78, 0x18, 0x0C, 0x3C, 0x6C, 0x89, 0x16, 0x6F, 0x12, 0x26, 0x4D,
  0x8C, 0x3E, 0x45, 0x83, 0x03, 0x03, 0x03, 0x06, 0x89, 0xF0, 0xFE, 0x60,
  0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x80, 0x63, 0x42, 0x42, 0x42, 0xC6,
  0xC6, 0x84, 0x84, 0xCC, 0x78, 0xC3, 0x8F, 0x12, 0x64, 0x8B, 0x14, 0x38,
  0x60, 0xC0, 0xC6, 0x38, 0xCF, 0x39, 0x67, 0x6D, 0x69, 0xAD, 0x3D, 0xE7,
  0x38, 0xE7, 0x08, 0xC0, 0x11, 0x89, 0x86, 0x81, 0xC0, 0xC0, 0xE0, 0x50,
  0x48, 0x66, 0x63, 0x00, 0xC6, 0x99, 0x22, 0xC7, 0x0C, 0x18, 0x30, 0x40,
  0x80, 0x3E, 0x0C, 0x30, 0x41, 0x86, 0x08, 0x20, 0xC5, 0xF0, 0x39, 0x08,
  0x46, 0x21, 0x08, 0x46, 0x21, 0xC0, 0xC9, 0x24, 0xD9, 0x24, 0x38, 0x42,
  0x31, 0x08, 0x42, 0x31, 0x09, 0xC0, 0x18, 0x30, 0xA1, 0x24, 0x58, 0xC0,
  0xF8, 0xD4, 0x35, 0xFC, 0xE3, 0x8A, 0x29, 0xBE, 0x30, 0x60, 0x81, 0x63,
  0xEC, 0xD9, 0xA3, 0x44, 0x9A, 0xE0, 0x3B, 0xF1, 0x08, 0x42, 0x5E, 0x06,
  0x0C, 0x11, 0xA7, 0xD9, 0xA3, 0x44, 0x89, 0x33, 0xE0, 0x33, 0x73, 0x3E,
  0x42, 0x3E, 0x03, 0x05, 0x0C, 0x0E, 0x1E, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x20, 0xE0, 0x1A, 0x7D, 0x9A, 0x34, 0x49, 0x93, 0x3E, 0x08,
  0x13, 0xE0, 0x30, 0x60, 0x81, 0x63, 0xEC, 0xD9, 0xA2, 0x44, 0x8B, 0x30,
  0x30, 0x22, 0x66, 0x44, 0x4C, 0x0C, 0x00, 0x82, 0x18, 0x61, 0x04, 0x10,
  0xC3, 0x08, 0xE0, 0x30, 0x60, 0x81, 0x32, 0x4D, 0x14, 0x38, 0x58, 0x93,
  0x30, 0x33, 0x22, 0x26, 0x64, 0x44, 0xC0, 0x2C, 0xCF, 0xF6, 0x65, 0x91,
  0x44, 0x51, 0x34, 0xCF, 0x32, 0x2C, 0x7D, 0x9B, 0x34, 0x48, 0x91, 0x66,
  0x31, 0xEC, 0xE3, 0x8E, 0x29, 0xBC, 0x2C, 0x6D, 0x9B, 0x34, 0x68, 0x93,
  0x7C, 0xC1, 0x02, 0x00, 0x35, 0xFC, 0xE3, 0x8A, 0x29, 0xBE, 0x10, 0x43,
  0x00, 0x2C, 0xE6, 0x18, 0x41, 0x04, 0x30, 0x3D, 0xA4, 0x18, 0x30, 0x69,
  0xBC, 0x67, 0xFC, 0xC8, 0x88, 0xE0, 0x45, 0x1C, 0xF2, 0x8A, 0x29, 0xBE,
  0x8E, 0x29, 0xA4, 0xB2, 0x8E, 0x30, 0x88, 0xCC, 0xE6, 0x55, 0x6A, 0xA7,
  0x53, 0x31, 0x98, 0x33, 0x36, 0x14, 0x18, 0x18, 0x38, 0x2C, 0xC4, 0x23,
  0x22, 0x26, 0x24, 0x2C, 0x38, 0x38, 0x30, 0x30, 0x20, 0xE0, 0x7D, 0xE1,
  0x8C, 0x21, 0x8C, 0x3C, 0x1C, 0x41, 0x0C, 0x23, 0x8C, 0x18, 0x61, 0x04,
  0x18, 0xFF, 0xFC, 0x18, 0xE1, 0x86, 0x10, 0x61, 0xCC, 0x30, 0x82, 0x38,
  0xE6, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 5, 1, -10 },
  { 9, 8, 10, 8, 0, -10 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 9, 10, 11, 1, -10 },
  { 42, 8, 10, 8, 0, -10 },
  { 52, 2, 4, 3, 1, -10 },
  { 53, 5, 12, 4, 0, -10 },
  { 61, 5, 12, 4, -1, -10 },
  { 69, 6, 6, 7, 1, -11 },
  { 74, 6, 6, 7, 1, -8 },
  { 79, 3, 4, 3, -1, -2 },
  { 81, 4, 1, 4, 0, -4 },
  { 82, 2, 2, 3, 0, -2 },
  { 83, 7, 10, 5, -1, -10 },
  { 92, 6, 10, 7, 1, -10 },
  { 100, 4, 10, 7, 2, -10 },
  { 105, 7, 10, 7, 0, -10 },
  { 114, 7, 10, 7, 0, -10 },
  { 123, 7, 10, 7, 0, -10 },
  { 132, 7, 10, 7, 0, -10 },
  { 141, 6, 10, 7, 1, -10 },
  { 149, 6, 10, 7, 1, -10 },
  { 157, 7, 10, 7, 0, -10 },
  { 166, 7, 10, 7, 0, -10 },
  { 175, 3, 8, 3, 0, -8 },
  { 178, 4, 10, 3, -1, -8 },
  { 183, 6, 6, 7, 1, -8 },
  { 188, 6, 4, 7, 1, -7 },
  { 191, 6, 6, 7, 1, -8 },
  { 196, 5, 10, 5, 1, -10 },
  { 203, 9, 11, 11, 1, -10 },
  { 216, 8, 10, 7, -1, -10 },
  { 226, 8, 10, 8, 0, -10 },
  { 236, 7, 10, 7, 1, -10 },
  { 245, 8, 10, 8, 0, -10 },
  { 255, 7, 10, 7, 0, -10 },
  { 264, 7, 10, 6, 0, -10 },
  { 273, 8, 10, 9, 1, -10 },
  { 283, 9, 10, 9, 0, -10 },
  { 295, 5, 10, 4, 0, -10 },
  { 302, 6, 13, 4, -2, -10 },
  { 312, 9, 10, 7, 0, -10 },
  { 324, 5, 10, 6, 0, -10 },
  { 331, 11, 10, 11, 0, -10 },
  { 345, 9, 10, 9, 0, -10 },
  { 357, 8, 10, 9, 1, -10 },
  { 367, 7, 10, 7, 0, -10 },
  { 376, 8, 12, 9, 1, -10 },
  { 388, 7, 10, 7, 0, -10 },
  { 397, 7, 10, 7, 0, -10 },
  { 406, 7, 10, 6, 1, -10 },
  { 415, 8, 10, 9, 1, -10 },
  { 425, 7, 10, 7, 1, -10 },
  { 434, 11, 10, 11, 1, -10 },
  { 448, 9, 10, 7, -1, -10 },
  { 460, 7, 10, 7, 1, -10 },
  { 469, 7, 10, 7, 0, -10 },
  { 478, 5, 12, 4, 0, -10 },
  { 486, 3, 10, 5, 1, -10 },
  { 490, 5, 12, 4, -1, -10 },
  { 498, 7, 6, 7, 0, -10 },
  { 504, 5, 1, 5, -1, 1 },
  { 505, 2, 3, 4, 2, -11 },
  { 506, 6, 8, 7, 1, -8 },
  { 512, 7, 11, 7, 0, -11 },
  { 522, 5, 8, 6, 1, -8 },
  { 527, 7, 11, 7, 1, -11 },
  { 537, 5, 8, 7, 1, -8 },
  { 542, 8, 14, 4, -2, -11 },
  { 556, 7, 11, 7, 0, -8 },
  { 566, 7, 11, 7, 0, -11 },
  { 576, 4, 10, 3, 0, -10 },
  { 581, 6, 13, 3, -2, -10 },
  { 591, 7, 11, 7, 0, -11 },
  { 601, 4, 11, 3, 0, -11 },
  { 607, 10, 8, 11, 0, -8 },
  { 617, 7, 8, 7, 0, -8 },
  { 624, 6, 8, 7, 1, -8 },
  { 630, 7, 11, 7, 0, -8 },
  { 640, 6, 11, 7, 1, -8 },
  { 649, 6, 8, 5, 0, -8 },
  { 655, 6, 8, 6, 0, -8 },
  { 661, 4, 9, 4, 1, -9 },
  { 666, 6, 8, 7, 1, -8 },
  { 672, 6, 8, 6, 1, -8 },
  { 678, 9, 8, 9, 1, -8 },
  { 687, 8, 8, 6, -1, -8 },
  { 695, 8, 11, 6, -1, -8 },
  { 706, 6, 8, 6, 0, -8 },
  { 712, 6, 12, 5, 0, -10 },
  { 721, 1, 14, 7, 3, -11 },
  { 723, 6, 12, 5, -1, -10 },
  { 732, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC14PT7B_H_
