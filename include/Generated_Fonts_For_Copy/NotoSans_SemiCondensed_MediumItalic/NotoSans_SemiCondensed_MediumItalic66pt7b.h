#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x3F, 0x87, 0xF9, 0xFC, 0x3F,
  0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xF9, 0xC3, 0xE0, 0x1F,
  0xC7, 0x81, 0x80, 0x7F, 0x0F, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xF8,
  0x3C, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x0F, 0xC3,
  0xC0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x3F, 0xCE, 0x00, 0x00, 0x3F, 0xDC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xEF, 0xF8,
  0x00, 0x03, 0xC7, 0xF0, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0x1C, 0x1F, 0x80, 0x00, 0x38, 0x3F, 0x00, 0x00, 0xF0, 0x7E, 0x00,
  0x01, 0xE1, 0xFC, 0x20, 0x03, 0xC3, 0xF8, 0x30, 0x07, 0x0F, 0xE0, 0x7C,
  0x1E, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x00,
  0x7E, 0x03, 0xE1, 0xF8, 0x3E, 0x0F, 0xC0, 0xFC, 0x7E, 0x1F, 0xF1, 0xF8,
  0x1F, 0x0F, 0x87, 0xFF, 0x3F, 0x07, 0xE3, 0xF1, 0xFF, 0xF7, 0xE0, 0xF8,
  0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0x1F, 0x1F, 0x87, 0xEF, 0xFF, 0xC7, 0xE3,
  0xE0, 0xFD, 0xFF, 0xF1, 0xF8, 0xFC, 0x0F, 0x9F, 0xFC, 0x3E, 0x1F, 0x01,
  0xF1, 0xFF, 0x0F, 0xC7, 0xE0, 0x3E, 0x0F, 0x03, 0xF0, 0xF8, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0xFE, 0x00, 0xFE, 0x1F,
  0xE3, 0xF8, 0x07, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x7F, 0x00,
  0x3F, 0x9F, 0xC3, 0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0xE1,
  0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x07,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF,
  0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0C,
  0x01, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xF9, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x78, 0x0F, 0xC0,
  0x07, 0x01, 0xFC, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFF, 0xF8, 0x04, 0x1F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE,
  0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xEF, 0xC7, 0xFC, 0xFC, 0xFF, 0x9F,
  0xC7, 0xF1, 0xFC, 0x7C, 0x1F, 0x83, 0x81, 0xF8, 0x20, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x30, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x7F,
  0xC0, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x80, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0xFF, 0x80, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xE3, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0x00, 0xFC, 0xFF, 0xFE, 0x03,
  0xF7, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC,
  0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF9,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0x01,
  0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0x1F, 0x80, 0x07,
  0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0E, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x81, 0xFE, 0x1C, 0x00, 0xFF, 0x10, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x20, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0xFE, 0x03, 0xF0, 0xFC, 0x00,
  0xFF, 0xFE, 0x07, 0xC3, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0x7F,
  0xFF, 0xC0, 0x7C, 0x7C, 0x03, 0xF8, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0xC0,
  0xFC, 0x07, 0xCF, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x7D, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0x7C, 0x01, 0xF8,
  0x07, 0xDF, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x7C, 0x0F, 0xC0, 0x1F, 0x00,
  0xFB, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xF0, 0x0F,
  0xBE, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF3,
  0xE0, 0x7C, 0x01, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0x07, 0xE0, 0x3F, 0x3E,
  0x07, 0xC0, 0x3F, 0x80, 0xF8, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xE0,
  0x7E, 0x07, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0xE1, 0xF8, 0x3E, 0x03,
  0xFF, 0xEF, 0xFF, 0xE0, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x03, 0xE0, 0x1F,
  0xFC, 0x7F, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xF0, 0x03, 0xFF,
  0x00, 0x1C, 0x01, 0xFF, 0x00, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x60, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x3C, 0x01, 0xFF,
  0x80, 0x00, 0x40, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8,
  0xFE, 0x00, 0x1F, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x07,
  0xFF, 0xE1, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x08,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xC7, 0xF8,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x7E, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7C, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0xC0,
  0x3F, 0x87, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x87, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xF8, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3E, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x9F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFF,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xF0,
  0x03, 0xF7, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xDF, 0xC0, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0x80, 0x1C, 0x01, 0xFE, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x40,
  0x00, 0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0x7C, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xFC, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x7F, 0x00,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07,
  0xE0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0xF0, 0xFC, 0x03, 0xFF,
  0xF1, 0xF0, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xEF,
  0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE1,
  0xF7, 0xE0, 0x3F, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xBF, 0x00, 0x7F, 0xFE,
  0x7E, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x3F, 0xF8, 0x01, 0xFC, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xF0,
  0x07, 0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x3F, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0x00, 0xFC, 0x7F, 0xFC, 0x01,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFC, 0xF8, 0x1F, 0xE0, 0x08, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x01, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0xE3, 0xF8,
  0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x3F, 0xFF, 0xEF,
  0xC0, 0x1F, 0xFD, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x00,
  0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFB, 0xF0, 0x00,
  0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x03, 0xFE, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8,
  0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xE3, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x1F, 0xE0,
  0x0F, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x04, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xFF, 0x7E,
  0x00, 0x7F, 0xFF, 0xDF, 0x80, 0x3F, 0xFB, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0x80, 0x0F,
  0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xF8, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE,
  0x3F, 0xF8, 0x01, 0xFC, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xF8, 0x07, 0xEF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x07,
  0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFC, 0x01, 0xF8, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x01, 0xF3, 0xFF, 0xF9, 0xFF, 0xFF, 0x03, 0xF7, 0xE7, 0xFD,
  0xF9, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xE0, 0x07, 0xE3,
  0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xE0, 0x1F, 0x3F, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x00,
  0xFE, 0x0F, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xF3, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x0F, 0xC3, 0xFF, 0x80, 0x03, 0xF1, 0xFF, 0xF0, 0x00, 0xFC, 0xFF,
  0xFC, 0x00, 0x3E, 0x7F, 0xFF, 0x80, 0x1F, 0xBF, 0x3F, 0xE0, 0x07, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xC0,
  0x0F, 0xDF, 0xFF, 0xE0, 0x03, 0xF3, 0xFF, 0xF0, 0x01, 0xFC, 0x7F, 0xF8,
  0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0xF1,
  0xF0, 0x0F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xEF, 0xFF,
  0x81, 0xFE, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0xC1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x07,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF,
  0xC0, 0x3F, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0x3F, 0x00, 0x7F, 0xFC, 0xFE,
  0x00, 0x7F, 0xF1, 0xFC, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x1C, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0xC0, 0x7E, 0x3F, 0xE0, 0x3F, 0x3F, 0xF0,
  0x1F, 0x3F, 0xF0, 0x1F, 0xBF, 0xF8, 0x0F, 0xDF, 0x84, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xE0,
  0x7F, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x80,
  0x01, 0xFC, 0x30, 0x00, 0xFF, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x04, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xC0, 0x7F, 0xF0, 0x3F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF,
  0xDF, 0x80, 0x7F, 0xFF, 0x3F, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xF0,
  0xF8, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x0F, 0xC0,
  0x3E, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x0F, 0xC0, 0x7E,
  0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0x0F, 0x83, 0xF8, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x0F, 0x87, 0xF0, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x00, 0xFC,
  0x7E, 0x0F, 0x8F, 0xE0, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x0F,
  0x9F, 0x80, 0x0F, 0xDF, 0x80, 0xF9, 0xF8, 0x00, 0xFD, 0xF0, 0x0F, 0xBF,
  0x00, 0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xD8,
  0x00, 0x7F, 0xFC, 0x80, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 48, 17, 1, -47 },
  { 103, 21, 17, 26, 7, -47 },
  { 148, 38, 47, 38, 1, -47 },
  { 372, 31, 54, 33, 1, -50 },
  { 582, 43, 49, 50, 4, -48 },
  { 846, 37, 49, 40, 1, -48 },
  { 1073, 9, 17, 15, 7, -47 },
  { 1093, 22, 57, 19, 2, -47 },
  { 1250, 22, 57, 19, -5, -47 },
  { 1407, 27, 28, 32, 6, -50 },
  { 1502, 29, 32, 35, 4, -39 },
  { 1618, 13, 17, 16, -3, -8 },
  { 1646, 17, 6, 20, 1, -21 },
  { 1659, 9, 10, 16, 1, -9 },
  { 1671, 32, 47, 24, -3, -47 },
  { 1859, 29, 49, 33, 3, -48 },
  { 2037, 20, 47, 33, 8, -47 },
  { 2155, 33, 48, 33, -1, -48 },
  { 2353, 32, 49, 33, 0, -48 },
  { 2549, 32, 47, 33, 0, -47 },
  { 2737, 32, 48, 33, 1, -47 },
  { 2929, 30, 49, 33, 3, -48 },
  { 3113, 31, 47, 33, 4, -47 },
  { 3296, 31, 49, 33, 2, -48 },
  { 3486, 30, 49, 33, 2, -48 },
  { 3670, 14, 37, 16, 1, -36 },
  { 3735, 18, 45, 16, -3, -36 },
  { 3837, 29, 32, 35, 4, -40 },
  { 3953, 29, 19, 35, 4, -33 },
  { 4022, 29, 32, 35, 4, -40 },
  { 4138, 24, 49, 26, 4, -48 },
  { 4285, 46, 53, 50, 3, -47 },
  { 4590, 35, 47, 35, -4, -47 },
  { 4796, 34, 47, 36, 2, -47 },
  { 4996, 34, 49, 35, 4, -48 },
  { 5205, 36, 47, 40, 2, -47 },
  { 5417, 32, 47, 31, 2, -47 },
  { 5605, 32, 47, 29, 2, -47 },
  { 5793, 37, 49, 41, 4, -48 },
  { 6020, 40, 47, 41, 2, -47 },
  { 6255, 27, 47, 21, -2, -47 },
  { 6414, 28, 60, 17, -10, -47 },
  { 6624, 38, 47, 34, 2, -47 },
  { 6848, 23, 47, 29, 2, -47 },
  { 6984, 50, 47, 52, 2, -47 },
  { 7278, 43, 47, 43, 1, -47 },
  { 7531, 37, 49, 43, 4, -48 },
  { 7758, 33, 47, 34, 2, -47 },
  { 7952, 37, 59, 43, 4, -48 },
  { 8225, 33, 47, 35, 2, -47 },
  { 8419, 32, 49, 31, 0, -48 },
  { 8615, 29, 47, 30, 6, -47 },
  { 8786, 37, 48, 40, 4, -47 },
  { 9008, 34, 47, 34, 6, -47 },
  { 9208, 52, 47, 52, 6, -47 },
  { 9514, 42, 47, 33, -4, -47 },
  { 9761, 31, 47, 31, 6, -47 },
  { 9944, 36, 47, 31, -2, -47 },
  { 10156, 25, 58, 19, -1, -47 },
  { 10338, 13, 47, 24, 7, -47 },
  { 10415, 26, 58, 19, -5, -47 },
  { 10604, 31, 28, 34, 1, -47 },
  { 10713, 25, 4, 24, -6, 6 },
  { 10726, 11, 11, 19, 10, -51 },
  { 10742, 31, 37, 35, 3, -36 },
  { 10886, 31, 51, 35, 1, -50 },
  { 11084, 25, 37, 27, 3, -36 },
  { 11200, 34, 51, 35, 3, -50 },
  { 11417, 27, 37, 31, 3, -36 },
  { 11542, 36, 66, 20, -8, -50 },
  { 11839, 34, 52, 35, 0, -36 },
  { 12060, 31, 50, 35, 1, -50 },
  { 12254, 17, 49, 16, 1, -49 },
  { 12359, 26, 65, 16, -8, -49 },
  { 12571, 32, 50, 31, 1, -50 },
  { 12771, 17, 50, 16, 1, -50 },
  { 12878, 48, 36, 52, 1, -36 },
  { 13094, 31, 36, 35, 1, -36 },
  { 13234, 28, 37, 34, 3, -36 },
  { 13364, 34, 52, 35, -2, -36 },
  { 13585, 31, 52, 35, 3, -36 },
  { 13787, 25, 36, 24, 1, -36 },
  { 13900, 26, 37, 27, 0, -36 },
  { 14021, 20, 45, 21, 3, -44 },
  { 14134, 31, 37, 35, 3, -36 },
  { 14278, 29, 36, 29, 3, -36 },
  { 14409, 44, 36, 45, 4, -36 },
  { 14607, 35, 36, 30, -3, -36 },
  { 14765, 38, 52, 29, -6, -36 },
  { 15012, 29, 36, 26, -2, -36 },
  { 15143, 26, 57, 23, 1, -47 },
  { 15329, 5, 66, 32, 14, -50 },
  { 15371, 25, 57, 23, -3, -47 },
  { 15550, 29, 9, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC66PT7B_H_
