#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF3, 0x8F, 0xC0, 0x1F, 0xE3, 0xC0,
  0xE0, 0x0F, 0xE1, 0xE0, 0x10, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0xF0, 0x78,
  0x00, 0x03, 0xF8, 0x78, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0xFE, 0x1E,
  0x00, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x0F, 0xF7,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x03, 0xCF, 0xF0, 0x00,
  0x01, 0xE3, 0xFC, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0xF0, 0x7F, 0x00,
  0x00, 0x78, 0x3F, 0x80, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x1E, 0x0F, 0xC0,
  0x00, 0x0E, 0x0F, 0xE0, 0x40, 0x0F, 0x07, 0xF0, 0x3C, 0x07, 0x8F, 0xF0,
  0x1F, 0xC3, 0xDF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x03, 0xF1, 0xF8,
  0x7F, 0xF3, 0xF0, 0x3F, 0x0F, 0x87, 0xFF, 0x8F, 0x81, 0xF8, 0xFC, 0x7F,
  0xFE, 0x7C, 0x1F, 0x8F, 0xC7, 0xFF, 0xF3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F,
  0xDF, 0xFF, 0xC7, 0xE3, 0xF0, 0x7E, 0x7F, 0xFC, 0x7E, 0x3F, 0x03, 0xF3,
  0xFF, 0xC3, 0xF1, 0xF8, 0x0F, 0x8F, 0xFC, 0x3F, 0x0F, 0x80, 0x7C, 0x1F,
  0x83, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x87,
  0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xC1, 0xFC, 0x00, 0x7F, 0xBF, 0x83,
  0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x06, 0x00, 0xFC, 0x00, 0x78, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xFE, 0xF8, 0x01,
  0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0xFE, 0x3E, 0x00, 0x1F,
  0xC3, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x0E, 0x01, 0xFC, 0x00, 0x60, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x1E, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x3F, 0x3F, 0xF3, 0xF8, 0xFF, 0x1F, 0xC7,
  0xE0, 0xFE, 0x1E, 0x07, 0xE0, 0x60, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0x00,
  0x1E, 0x00, 0x3F, 0xC0, 0x06, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x07, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x30, 0x00, 0x3F, 0x80,
  0x10, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x30, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x0F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x60,
  0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF8, 0x06, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x1F, 0x8F, 0xFF,
  0x80, 0x3F, 0x9F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xBF, 0x80, 0x7F, 0xFE,
  0x7F, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x04, 0x00, 0x3F, 0xE0, 0x0F, 0x87, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x03,
  0xFE, 0x1C, 0x00, 0xFF, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF3, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xFF, 0xF8,
  0x1F, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0x7F, 0x03, 0xF0,
  0x1F, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x3F, 0x01, 0xF8, 0x03, 0xE0,
  0x1F, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x7C, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x7C, 0x07, 0xC0, 0x0F, 0xC0,
  0x3E, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0x7C, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0xF8, 0x0F, 0x80, 0x3F, 0x00,
  0xF8, 0xF8, 0x0F, 0x80, 0x7F, 0x01, 0xF8, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF0, 0xF8, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0xF8, 0x0F, 0xE3, 0xEF, 0x8F,
  0xE0, 0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x81, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x1F,
  0xC0, 0x07, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x03, 0xFF, 0x00, 0x1C, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF,
  0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x78, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0xE1,
  0xFE, 0x00, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xF8,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x1F, 0xDF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF,
  0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x7F,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xF8, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F,
  0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xDF, 0x80, 0x01, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x03, 0xF8, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7E,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x80, 0x03, 0xFB, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x00,
  0x3C, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x20, 0x00, 0x07,
  0xF8, 0x06, 0x00, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xBF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x01,
  0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x07, 0xC3, 0xF8, 0x00, 0x3F, 0x8F,
  0xC0, 0x1F, 0x1F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x7C, 0x7F, 0x00, 0x03,
  0xF9, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xCF, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x7F,
  0xFC, 0x3F, 0x00, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x7F, 0x03, 0xFF,
  0xFF, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC7,
  0xEF, 0xC0, 0x7F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF,
  0x1F, 0x80, 0x1F, 0xFE, 0x1F, 0x80, 0x0F, 0xF8, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0xFC, 0x7F, 0xFC,
  0x00, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0x80,
  0x3E, 0x3F, 0xFF, 0x80, 0x3F, 0x0F, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x04, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x0F, 0xFF,
  0xE7, 0xF0, 0x01, 0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xF7, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x87, 0xEF, 0xC0,
  0x07, 0xFF, 0xFD, 0xF8, 0x00, 0x7F, 0xFF, 0x9F, 0x80, 0x03, 0xFF, 0xF1,
  0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x07, 0xFC,
  0x7F, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x02, 0x07, 0xF8, 0x00, 0x60, 0x7F, 0xC0, 0x3E, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x18, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x0F,
  0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0x80,
  0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x7E, 0x00, 0x3F, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xF3, 0xF8, 0x00, 0x3F,
  0xFC, 0x7F, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x06, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x1F, 0xE0, 0x07, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE,
  0x1F, 0xF8, 0x00, 0xFC, 0x7F, 0xFC, 0x01, 0xFC, 0xFF, 0xFE, 0x01, 0xFD,
  0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0x7F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xF9,
  0xFE, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xE1,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0x7F, 0xBF, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0xF8, 0x01, 0xF8, 0x7F, 0xFC,
  0x01, 0xF8, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xFF,
  0x01, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0x07, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0x0F, 0xFF,
  0x80, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0xC0, 0x03, 0xF7,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xF0,
  0x00, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0xC0, 0x01, 0xFC, 0x3F,
  0xF0, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x7F,
  0xFE, 0x3F, 0x00, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x3F, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF,
  0x3F, 0x80, 0x1F, 0xFE, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x01, 0xC0,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x07,
  0xF8, 0x03, 0xE1, 0xFF, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xFC, 0x03,
  0xF7, 0xFF, 0x00, 0x7E, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0x01, 0xF0, 0x3F, 0x80, 0x04, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x7F, 0x87,
  0x00, 0x1F, 0xF0, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0x1F, 0x80,
  0x3F, 0xFE, 0x1F, 0x80, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xDF, 0x80, 0x7E,
  0x0F, 0xE0, 0x3F, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0,
  0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x9F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7C, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0x87, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xC1, 0xF8, 0xFE, 0x00, 0x7E, 0x3F,
  0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xF8, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0,
  0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x07,
  0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0x80, 0x7E,
  0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7D, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF, 0xF8,
  0x00, 0x37, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x80, 0x00, 0x7F, 0xE2, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 50, 18, 1, -49 },
  { 114, 22, 18, 27, 7, -49 },
  { 164, 39, 49, 39, 1, -49 },
  { 403, 33, 56, 34, 1, -52 },
  { 634, 45, 51, 52, 4, -50 },
  { 921, 39, 51, 41, 1, -50 },
  { 1170, 10, 18, 15, 7, -49 },
  { 1193, 23, 60, 20, 2, -49 },
  { 1366, 23, 61, 20, -5, -50 },
  { 1542, 28, 30, 34, 7, -53 },
  { 1647, 30, 33, 36, 4, -41 },
  { 1771, 14, 17, 17, -3, -8 },
  { 1801, 18, 7, 21, 1, -22 },
  { 1817, 9, 10, 17, 1, -9 },
  { 1829, 34, 49, 25, -3, -49 },
  { 2038, 31, 51, 34, 3, -50 },
  { 2236, 21, 49, 34, 8, -49 },
  { 2365, 34, 50, 34, -1, -50 },
  { 2578, 33, 51, 34, 0, -50 },
  { 2789, 34, 49, 34, 0, -49 },
  { 2998, 33, 50, 34, 1, -49 },
  { 3205, 32, 51, 34, 3, -50 },
  { 3409, 32, 49, 34, 4, -49 },
  { 3605, 32, 51, 34, 2, -50 },
  { 3809, 31, 51, 34, 2, -50 },
  { 4007, 15, 39, 17, 1, -38 },
  { 4081, 20, 47, 17, -4, -38 },
  { 4199, 30, 34, 36, 4, -42 },
  { 4327, 30, 19, 36, 4, -34 },
  { 4399, 30, 34, 36, 4, -42 },
  { 4527, 25, 51, 27, 4, -50 },
  { 4687, 48, 55, 52, 3, -49 },
  { 5017, 36, 49, 36, -4, -49 },
  { 5238, 35, 49, 38, 2, -49 },
  { 5453, 36, 51, 36, 4, -50 },
  { 5683, 38, 49, 41, 2, -49 },
  { 5916, 33, 49, 32, 2, -49 },
  { 6119, 33, 49, 31, 2, -49 },
  { 6322, 39, 51, 43, 4, -50 },
  { 6571, 41, 49, 43, 2, -49 },
  { 6823, 28, 49, 22, -2, -49 },
  { 6995, 30, 63, 18, -11, -49 },
  { 7232, 40, 49, 36, 2, -49 },
  { 7477, 24, 49, 30, 2, -49 },
  { 7624, 53, 49, 54, 2, -49 },
  { 7949, 44, 49, 45, 2, -49 },
  { 8219, 39, 51, 45, 4, -50 },
  { 8468, 35, 49, 36, 2, -49 },
  { 8683, 39, 62, 45, 4, -50 },
  { 8986, 34, 49, 37, 2, -49 },
  { 9195, 34, 51, 32, 0, -50 },
  { 9412, 31, 49, 31, 6, -49 },
  { 9602, 39, 50, 42, 4, -49 },
  { 9846, 35, 49, 35, 6, -49 },
  { 10061, 54, 49, 55, 7, -49 },
  { 10392, 43, 49, 34, -4, -49 },
  { 10656, 33, 49, 33, 6, -49 },
  { 10859, 38, 49, 32, -2, -49 },
  { 11092, 26, 60, 20, -1, -49 },
  { 11287, 14, 49, 25, 7, -49 },
  { 11373, 27, 60, 20, -5, -49 },
  { 11576, 32, 29, 35, 2, -49 },
  { 11692, 26, 5, 25, -6, 6 },
  { 11709, 12, 11, 19, 10, -53 },
  { 11726, 32, 39, 36, 3, -38 },
  { 11882, 33, 53, 36, 1, -52 },
  { 12101, 27, 39, 29, 3, -38 },
  { 12233, 36, 53, 37, 3, -52 },
  { 12472, 28, 39, 33, 3, -38 },
  { 12609, 37, 70, 21, -8, -53 },
  { 12933, 35, 55, 37, 0, -38 },
  { 13174, 32, 52, 36, 1, -52 },
  { 13382, 18, 51, 17, 1, -51 },
  { 13497, 28, 68, 17, -9, -51 },
  { 13735, 34, 52, 32, 1, -52 },
  { 13956, 18, 52, 17, 1, -52 },
  { 14073, 51, 38, 55, 1, -38 },
  { 14316, 32, 38, 36, 1, -38 },
  { 14468, 30, 39, 35, 3, -38 },
  { 14615, 36, 54, 36, -2, -38 },
  { 14858, 32, 55, 36, 3, -38 },
  { 15078, 27, 38, 25, 1, -38 },
  { 15207, 27, 39, 28, 0, -38 },
  { 15339, 21, 46, 22, 3, -45 },
  { 15460, 32, 38, 36, 3, -37 },
  { 15612, 29, 37, 30, 4, -37 },
  { 15747, 46, 37, 47, 4, -37 },
  { 15960, 36, 37, 31, -3, -37 },
  { 16127, 40, 54, 30, -6, -37 },
  { 16397, 30, 37, 27, -2, -37 },
  { 16536, 27, 60, 24, 1, -49 },
  { 16739, 6, 69, 33, 14, -53 },
  { 16791, 26, 60, 24, -3, -49 },
  { 16986, 30, 10, 36, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC69PT7B_H_
