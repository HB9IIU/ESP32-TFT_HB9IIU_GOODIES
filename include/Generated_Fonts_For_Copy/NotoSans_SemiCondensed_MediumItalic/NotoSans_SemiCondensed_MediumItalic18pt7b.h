#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCC, 0x63, 0x18, 0x84, 0x60, 0x01, 0xCC, 0x00, 0xCF, 0x6D,
  0xA6, 0x90, 0x04, 0xC1, 0x90, 0x32, 0x04, 0xD7, 0xFC, 0x32, 0x04, 0xC0,
  0x90, 0xFF, 0x84, 0x40, 0x98, 0x12, 0x06, 0xC0, 0x02, 0x01, 0x07, 0xE6,
  0xA3, 0x41, 0xA0, 0xE0, 0x3C, 0x0F, 0x05, 0x82, 0xDA, 0xCF, 0xC0, 0x80,
  0x40, 0x38, 0x66, 0x84, 0x4C, 0x8C, 0x98, 0xC9, 0x0D, 0xA6, 0xD6, 0xB7,
  0x5B, 0x09, 0x31, 0x93, 0x13, 0x22, 0x16, 0x61, 0xC0, 0x0F, 0x06, 0xE1,
  0x98, 0x44, 0x1B, 0x07, 0x81, 0xC1, 0xF3, 0x66, 0xF1, 0xEC, 0x31, 0x9E,
  0x7D, 0xC0, 0xFE, 0x80, 0x0C, 0x43, 0x18, 0x61, 0x0C, 0x30, 0x82, 0x08,
  0x20, 0x82, 0x0C, 0x10, 0x18, 0x60, 0x82, 0x0C, 0x30, 0xC2, 0x18, 0x61,
  0x8C, 0x31, 0x84, 0x30, 0x18, 0x32, 0x47, 0xF3, 0xEF, 0x32, 0x26, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x36, 0x6C, 0x7F, 0xC0,
  0xF8, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x0C, 0x00, 0x1E, 0x3E, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC6,
  0xC6, 0xC6, 0xCC, 0xDC, 0x78, 0x0C, 0xE7, 0xB6, 0x18, 0x61, 0x0C, 0x30,
  0xC2, 0x18, 0x60, 0x1F, 0x1F, 0x88, 0x60, 0x30, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x1F, 0xCF, 0xE0, 0x1F, 0x1F, 0xC0, 0x60, 0x30, 0x30,
  0x30, 0x70, 0x0C, 0x03, 0x01, 0x81, 0x99, 0xCF, 0xC0, 0x03, 0x81, 0x81,
  0x41, 0xE1, 0xB0, 0x98, 0xC8, 0xCC, 0xC6, 0xFF, 0x81, 0x80, 0x80, 0xC0,
  0x1F, 0x8F, 0xC4, 0x06, 0x03, 0x01, 0xF0, 0xFC, 0x06, 0x03, 0x01, 0x81,
  0xD9, 0xCF, 0xC0, 0x0F, 0x1F, 0x30, 0x60, 0x60, 0xDC, 0xE6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xCC, 0x78, 0x7F, 0x7F, 0x03, 0x06, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0x0F, 0x0D, 0xCC, 0x66, 0x33, 0x10, 0xF0,
  0x70, 0xEC, 0x63, 0x61, 0xB0, 0xCC, 0xC7, 0xC0, 0x0E, 0x1F, 0x8C, 0x6C,
  0x36, 0x1B, 0x1D, 0xCC, 0x7E, 0x03, 0x01, 0x01, 0x93, 0x8F, 0x80, 0x33,
  0x20, 0x00, 0x00, 0xEC, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x33, 0x19, 0x80,
  0x01, 0x07, 0x1C, 0x70, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x0E, 0x38, 0xE0, 0x80, 0x7C,
  0xF8, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x07,
  0xC1, 0xC6, 0x30, 0x36, 0x01, 0x47, 0x9C, 0x89, 0x99, 0x99, 0x11, 0x91,
  0x39, 0x32, 0x9D, 0xCC, 0x00, 0x40, 0x03, 0xF0, 0x0C, 0x00, 0x03, 0x01,
  0xC1, 0xE0, 0xB0, 0xD8, 0x4C, 0x66, 0x23, 0x3F, 0x98, 0xD8, 0x6C, 0x3C,
  0x08, 0x1F, 0x07, 0xE1, 0x0C, 0xC3, 0x30, 0x8C, 0xE3, 0xE0, 0x8E, 0x61,
  0x98, 0x66, 0x39, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xCC, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0E, 0xC3, 0xE0, 0x1F, 0x07, 0xE1,
  0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0x83, 0x60, 0xD8, 0x66, 0x39, 0xFC,
  0xFC, 0x00, 0x1F, 0x8F, 0xC4, 0x06, 0x03, 0x01, 0xF8, 0xFC, 0x40, 0x60,
  0x30, 0x18, 0x0F, 0xCF, 0xE0, 0x1F, 0x8F, 0xC4, 0x06, 0x03, 0x01, 0x80,
  0xFC, 0x7C, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x00, 0x0F, 0xC7, 0xF3, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x7B, 0x1E, 0xC1, 0xB0, 0x6C, 0x11, 0xDC, 0x3F,
  0x00, 0x18, 0x63, 0x0C, 0x41, 0x98, 0x33, 0x04, 0x7F, 0x8F, 0xF1, 0x06,
  0x60, 0xCC, 0x31, 0x86, 0x30, 0xCC, 0x18, 0x1F, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0xF0,
  0x40, 0x18, 0xE3, 0x18, 0x46, 0x19, 0x83, 0x60, 0x78, 0x0F, 0x01, 0xB0,
  0x66, 0x0C, 0xC1, 0x8C, 0x31, 0x8C, 0x30, 0x18, 0x30, 0x41, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x83, 0xFF, 0xE0, 0x1C, 0x1C, 0x70, 0x71, 0xC3,
  0xCF, 0x0F, 0x3C, 0x68, 0xD1, 0xE2, 0x4D, 0x89, 0x36, 0x65, 0x99, 0x96,
  0x46, 0x73, 0x11, 0x8C, 0xC6, 0x30, 0x18, 0x31, 0xC3, 0x1C, 0x23, 0xC6,
  0x34, 0x63, 0x66, 0x36, 0x62, 0x24, 0x63, 0xC6, 0x3C, 0x63, 0xC4, 0x1C,
  0xC1, 0x80, 0x0F, 0x07, 0xE3, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x6C, 0x39, 0xDC, 0x3E, 0x00, 0x1F, 0x07, 0xE1, 0x18, 0xC3,
  0x30, 0x8C, 0x63, 0x78, 0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x00,
  0x0F, 0x07, 0xE3, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x6C, 0x39, 0xDC, 0x3E, 0x03, 0x00, 0x60, 0x1C, 0x1F, 0x0F, 0xC4, 0x66,
  0x13, 0x19, 0x8C, 0xFC, 0x7C, 0x66, 0x33, 0x18, 0xCC, 0x6C, 0x30, 0x0F,
  0x9F, 0x8C, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x01, 0x99,
  0xCF, 0xC0, 0xFF, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0x30, 0xCC, 0x32, 0x0D, 0x83, 0x61, 0x98, 0x66, 0x1B,
  0x06, 0xC1, 0xB0, 0xCC, 0x33, 0xB8, 0x7C, 0x00, 0x81, 0xE1, 0xB0, 0xD8,
  0xCC, 0x66, 0x63, 0x31, 0xB0, 0xD8, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0xC3,
  0x0F, 0x1C, 0x6C, 0x71, 0xB3, 0xC4, 0xCF, 0x33, 0x2C, 0xCD, 0xB6, 0x34,
  0xD8, 0xF3, 0x43, 0x8F, 0x0A, 0x38, 0x38, 0xE0, 0xC3, 0x80, 0x18, 0x63,
  0x18, 0x23, 0x06, 0xC0, 0xF0, 0x0C, 0x01, 0x80, 0x70, 0x1B, 0x06, 0x60,
  0xCC, 0x31, 0x8C, 0x18, 0xC3, 0xC6, 0xC6, 0xCC, 0x58, 0x58, 0x70, 0x60,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0x3F, 0x9F, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xCF, 0xE0, 0x1E, 0x38, 0x41, 0x83,
  0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x3C, 0x70, 0xDB, 0x64,
  0x93, 0x6D, 0x92, 0x1E, 0x38, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30,
  0x40, 0x83, 0x06, 0x3C, 0x70, 0x0C, 0x06, 0x07, 0x82, 0x43, 0x21, 0x19,
  0x85, 0x83, 0xFE, 0xD9, 0x80, 0x19, 0x7F, 0x63, 0xC3, 0xC2, 0xC6, 0xC6,
  0xCE, 0xDE, 0xF4, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x71, 0xFC, 0xC6, 0x63,
  0x61, 0xB0, 0xD8, 0xCC, 0x67, 0x66, 0xE0, 0x1E, 0xF9, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC8, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x21, 0xB3, 0xF9, 0x8D,
  0x86, 0xC2, 0x63, 0x31, 0x99, 0xCD, 0xC7, 0xA0, 0x1C, 0xFD, 0x9E, 0x3F,
  0xDE, 0x20, 0x60, 0xC4, 0xF8, 0x01, 0xC1, 0xE0, 0x60, 0x18, 0x0F, 0x07,
  0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x38, 0x00, 0x0C, 0x9F, 0xCC, 0x6C, 0x36, 0x13, 0x19, 0x8C,
  0xCE, 0x6E, 0x3D, 0x01, 0x80, 0xC8, 0xC7, 0xC0, 0x18, 0x0C, 0x04, 0x06,
  0x03, 0x71, 0xFC, 0xC6, 0x63, 0x61, 0x31, 0x98, 0xCC, 0x64, 0x36, 0x30,
  0x18, 0x80, 0x63, 0x18, 0x8C, 0x63, 0x18, 0x8C, 0x00, 0x06, 0x08, 0x00,
  0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x30, 0xE0,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x19, 0x98, 0xD8, 0x58, 0x78, 0x3E, 0x1B,
  0x0C, 0x84, 0x66, 0x30, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x18, 0xC4,
  0x60, 0x37, 0x39, 0xFB, 0xCC, 0x62, 0x63, 0x16, 0x31, 0xB1, 0x8D, 0x8C,
  0x6C, 0x62, 0x42, 0x36, 0x31, 0x80, 0x37, 0x1F, 0xCC, 0x66, 0x36, 0x13,
  0x19, 0x8C, 0xC6, 0x43, 0x63, 0x00, 0x1C, 0x7E, 0x62, 0xC3, 0xC3, 0xC2,
  0xC6, 0xC6, 0xCC, 0x78, 0x1B, 0x87, 0xF1, 0x8C, 0x63, 0x30, 0xCC, 0x33,
  0x18, 0xC6, 0x3B, 0x1B, 0x86, 0x01, 0x80, 0x60, 0x30, 0x00, 0x19, 0x7F,
  0x63, 0xC3, 0xC2, 0xC6, 0xC6, 0xCE, 0xDC, 0xF4, 0x0C, 0x0C, 0x0C, 0x18,
  0x36, 0x7C, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x80, 0x1C, 0x7D, 0x83,
  0x03, 0x03, 0x83, 0x06, 0x9D, 0xF0, 0x31, 0x1F, 0xF6, 0x31, 0x18, 0xC6,
  0x35, 0xE0, 0x63, 0x63, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0xCE, 0xDC, 0xF4,
  0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0x70, 0x70, 0x60, 0xC6, 0x3C,
  0xE2, 0xCA, 0x6C, 0xA6, 0xDA, 0xCD, 0x2C, 0xF2, 0x8E, 0x38, 0xE3, 0x0E,
  0x30, 0x31, 0xC6, 0x61, 0xB0, 0x38, 0x0E, 0x03, 0x01, 0xE0, 0xD8, 0x66,
  0x38, 0xC0, 0x18, 0x63, 0x18, 0x63, 0x0C, 0xC1, 0x98, 0x16, 0x02, 0xC0,
  0x50, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x81, 0xE0, 0x00, 0x3E, 0x7C,
  0x30, 0x61, 0x86, 0x08, 0x30, 0xC1, 0xF8, 0x06, 0x1C, 0x60, 0xC1, 0x83,
  0x0C, 0x70, 0xE0, 0x60, 0x81, 0x06, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xC0,
  0x18, 0x38, 0x30, 0x60, 0xC1, 0x02, 0x07, 0x0E, 0x30, 0x41, 0x83, 0x06,
  0x38, 0x60, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 11, 13, 10, 0, -13 },
  { 32, 9, 15, 9, 0, -14 },
  { 49, 12, 13, 14, 1, -13 },
  { 69, 10, 13, 11, 0, -13 },
  { 86, 2, 5, 4, 2, -13 },
  { 88, 6, 16, 5, 1, -13 },
  { 100, 6, 16, 5, -1, -13 },
  { 112, 7, 8, 9, 2, -14 },
  { 119, 8, 9, 9, 1, -11 },
  { 128, 4, 4, 4, -1, -2 },
  { 130, 5, 2, 5, 0, -6 },
  { 132, 3, 2, 4, 0, -2 },
  { 133, 9, 13, 7, -1, -13 },
  { 148, 8, 13, 9, 1, -13 },
  { 161, 6, 13, 9, 2, -13 },
  { 171, 9, 13, 9, 0, -13 },
  { 186, 9, 13, 9, 0, -13 },
  { 201, 9, 13, 9, 0, -13 },
  { 216, 9, 13, 9, 0, -13 },
  { 231, 8, 13, 9, 1, -13 },
  { 244, 8, 13, 9, 1, -13 },
  { 257, 9, 13, 9, 0, -13 },
  { 272, 9, 13, 9, 0, -13 },
  { 287, 4, 10, 4, 0, -10 },
  { 292, 5, 12, 4, -1, -10 },
  { 300, 8, 9, 9, 1, -11 },
  { 309, 8, 5, 9, 1, -9 },
  { 314, 8, 9, 9, 1, -11 },
  { 323, 7, 13, 7, 1, -13 },
  { 335, 12, 15, 14, 1, -13 },
  { 358, 9, 13, 9, -1, -13 },
  { 373, 10, 13, 10, 0, -13 },
  { 390, 9, 13, 9, 1, -13 },
  { 405, 10, 13, 11, 0, -13 },
  { 422, 9, 13, 8, 0, -13 },
  { 437, 9, 13, 8, 0, -13 },
  { 452, 10, 13, 11, 1, -13 },
  { 469, 11, 13, 11, 0, -13 },
  { 487, 8, 13, 6, -1, -13 },
  { 500, 8, 17, 5, -3, -13 },
  { 517, 11, 13, 9, 0, -13 },
  { 535, 7, 13, 8, 0, -13 },
  { 547, 14, 13, 14, 0, -13 },
  { 570, 12, 13, 12, 0, -13 },
  { 590, 10, 13, 12, 1, -13 },
  { 607, 10, 13, 9, 0, -13 },
  { 624, 10, 16, 12, 1, -13 },
  { 644, 9, 13, 10, 0, -13 },
  { 659, 9, 13, 8, 0, -13 },
  { 674, 8, 13, 8, 2, -13 },
  { 687, 10, 13, 11, 1, -13 },
  { 704, 9, 13, 9, 2, -13 },
  { 719, 14, 13, 14, 2, -13 },
  { 742, 11, 13, 9, -1, -13 },
  { 760, 8, 13, 8, 2, -13 },
  { 773, 9, 13, 8, 0, -13 },
  { 788, 7, 16, 5, 0, -13 },
  { 802, 3, 13, 7, 2, -13 },
  { 807, 7, 16, 5, -1, -13 },
  { 821, 9, 8, 9, 0, -13 },
  { 830, 7, 1, 7, -2, 2 },
  { 831, 3, 3, 5, 3, -14 },
  { 833, 8, 10, 9, 1, -10 },
  { 843, 9, 14, 9, 0, -14 },
  { 859, 7, 10, 7, 1, -10 },
  { 868, 9, 14, 10, 1, -14 },
  { 884, 7, 10, 8, 1, -10 },
  { 893, 10, 18, 5, -2, -14 },
  { 916, 9, 14, 10, 0, -10 },
  { 932, 9, 14, 9, 0, -14 },
  { 948, 5, 13, 4, 0, -13 },
  { 957, 7, 17, 4, -2, -13 },
  { 972, 9, 14, 8, 0, -14 },
  { 988, 5, 14, 4, 0, -14 },
  { 997, 13, 10, 14, 0, -10 },
  { 1014, 9, 10, 9, 0, -10 },
  { 1026, 8, 10, 9, 1, -10 },
  { 1036, 10, 14, 9, -1, -10 },
  { 1054, 8, 14, 10, 1, -10 },
  { 1068, 7, 10, 7, 0, -10 },
  { 1077, 7, 10, 7, 0, -10 },
  { 1086, 5, 12, 6, 1, -12 },
  { 1094, 8, 10, 9, 1, -10 },
  { 1104, 8, 10, 8, 1, -10 },
  { 1114, 12, 10, 12, 1, -10 },
  { 1129, 10, 10, 8, -1, -10 },
  { 1142, 11, 14, 8, -2, -10 },
  { 1162, 7, 10, 7, 0, -10 },
  { 1171, 7, 16, 6, 0, -13 },
  { 1185, 1, 18, 9, 4, -14 },
  { 1188, 7, 16, 6, -1, -13 },
  { 1202, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC18PT7B_H_
