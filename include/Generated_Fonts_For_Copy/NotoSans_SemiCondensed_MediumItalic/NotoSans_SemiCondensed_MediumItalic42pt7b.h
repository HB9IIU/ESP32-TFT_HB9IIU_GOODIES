#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x10, 0x00, 0x3C, 0x7C, 0xF1, 0xE3,
  0xC7, 0x9E, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x8E, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE1, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83,
  0x80, 0x03, 0x83, 0x80, 0x03, 0x87, 0x80, 0x07, 0x07, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFD, 0x9E, 0x0F, 0x18, 0x40, 0xF3, 0x80, 0x1E,
  0x38, 0x01, 0xE3, 0x00, 0x1F, 0x30, 0x00, 0xFB, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0xEF, 0x80, 0x0C, 0x78, 0x00, 0xC7, 0x80, 0x1C, 0x78, 0x81, 0xCF,
  0x8C, 0x18, 0xF0, 0xFD, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x07, 0x83, 0xFC, 0x01, 0xE0, 0xFF, 0xC0, 0x38, 0x1E, 0x78, 0x0F,
  0x07, 0x87, 0x03, 0xC0, 0xE0, 0xE0, 0x70, 0x1C, 0x1C, 0x1E, 0x07, 0x83,
  0x87, 0x80, 0xF0, 0xF0, 0xE0, 0x1C, 0x1E, 0x3C, 0x03, 0x83, 0x8F, 0x00,
  0x70, 0x71, 0xC0, 0x0E, 0x1E, 0x79, 0xF9, 0xC3, 0x9E, 0x7F, 0xB8, 0xF3,
  0x9F, 0xFF, 0xFC, 0xF3, 0x8F, 0x7F, 0x1C, 0xF1, 0xEF, 0xC7, 0x1C, 0x3C,
  0x01, 0xE7, 0x87, 0x80, 0x38, 0xF0, 0xF0, 0x0E, 0x1C, 0x1E, 0x03, 0xC3,
  0x83, 0x80, 0x70, 0x70, 0x70, 0x1C, 0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC0,
  0xE0, 0x78, 0x70, 0x38, 0x07, 0x1E, 0x0F, 0x00, 0xFF, 0x81, 0xC0, 0x1F,
  0xE0, 0x70, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x3E,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0x1F, 0x78, 0x1E, 0x7C, 0xF8, 0x79, 0xF0, 0xF8, 0xF3,
  0xC1, 0xF3, 0xEF, 0x81, 0xF7, 0x9E, 0x01, 0xFE, 0x3C, 0x03, 0xFC, 0x78,
  0x03, 0xF0, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0xC3, 0xF1, 0xFF, 0x83, 0xFF,
  0xFF, 0x83, 0xFF, 0x8F, 0x83, 0xFC, 0x1F, 0x80, 0x3C, 0xF3, 0xDE, 0x79,
  0xE7, 0x9C, 0x71, 0xCE, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x06,
  0x0E, 0x03, 0xC7, 0x03, 0xFB, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0x81, 0xFF,
  0xC1, 0xF8, 0x21, 0xFC, 0x01, 0xE7, 0x01, 0xE3, 0x81, 0xF1, 0xE0, 0x70,
  0x70, 0x10, 0x3C, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F, 0x3F, 0x0F, 0x83, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03,
  0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x1F, 0x0F, 0xCF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC,
  0x1F, 0xE1, 0xFF, 0x3F, 0x7B, 0xF7, 0xCF, 0x3C, 0x61, 0xE2, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE3, 0xF0, 0x1C, 0x0F, 0x80, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x3C,
  0x3F, 0x03, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x88, 0x01, 0xF8, 0xF0, 0x7F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1D, 0xE0,
  0x03, 0xDE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C,
  0x03, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0x78, 0x38, 0x0F, 0x87, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE2, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x81,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x08,
  0x03, 0xF0, 0xF0, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x10, 0x7E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x7E, 0x07, 0x9F, 0xE0, 0xF7, 0xFE, 0x1F, 0xEF, 0xE3,
  0xF0, 0x7C, 0xFC, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1F,
  0x07, 0xC1, 0xF1, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C,
  0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xBF, 0x03, 0xE1, 0xF0,
  0x7C, 0x0F, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x07,
  0xCF, 0x00, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x7C, 0x1F, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0,
  0x3E, 0x78, 0x0F, 0xCF, 0x83, 0xF8, 0xFD, 0xFE, 0x1F, 0xFB, 0xC1, 0xFE,
  0x78, 0x1F, 0x9F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x83, 0x07, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xFC, 0x3E, 0x0F,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0x80, 0x80,
  0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x10, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x1E, 0x03, 0xF0, 0x38,
  0xE0, 0x7F, 0xE1, 0xCF, 0x07, 0xFF, 0x0E, 0x70, 0x78, 0x70, 0x77, 0x87,
  0x83, 0x83, 0xB8, 0x38, 0x1C, 0x1D, 0xC3, 0xC1, 0xE0, 0xFE, 0x1C, 0x0E,
  0x07, 0xE1, 0xE0, 0x70, 0x7F, 0x0F, 0x07, 0x83, 0xB8, 0x70, 0x3C, 0x1D,
  0xC3, 0x81, 0xC1, 0xEE, 0x1C, 0x1E, 0x0E, 0x70, 0xF0, 0xF0, 0xF3, 0x87,
  0xDD, 0xCF, 0x1C, 0x1F, 0xCF, 0xF0, 0xE0, 0x7C, 0x3F, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x08, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF0, 0x07, 0x83, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xC0, 0xFC,
  0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x3E,
  0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x07, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x83,
  0xE0, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x3E, 0x07, 0xE0, 0x08, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x02, 0x03, 0xFC, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x0F, 0xC0, 0xF0,
  0x0F, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F,
  0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x78, 0x07, 0xE0, 0xF0, 0x3F, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFE, 0x7E, 0x07, 0xF0, 0x04, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x07, 0xFC, 0x78, 0x07, 0xFC, 0x78, 0x0F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3F,
  0xCF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0,
  0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x81, 0xE0, 0x1F, 0x00, 0xF0, 0x1F,
  0x00, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xC7,
  0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x9E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0xF0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x07, 0xC0,
  0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1E,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xDE, 0x07, 0x78, 0x03, 0xDE, 0x0F, 0x78,
  0x07, 0xBC, 0x0F, 0x78, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x38,
  0x0F, 0x3C, 0x1E, 0x38, 0x1E, 0x7C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x38,
  0x3C, 0x78, 0x1E, 0x38, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x78, 0x3C, 0x3C,
  0x78, 0xF0, 0x3C, 0x3C, 0xF0, 0xF0, 0x3C, 0x3C, 0xF0, 0xF0, 0x3C, 0x3D,
  0xE0, 0xF0, 0x3C, 0x3D, 0xE1, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0x78, 0x3F,
  0xC1, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0xF0, 0x1F,
  0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x01, 0xF8, 0x01, 0xE0,
  0x7F, 0x00, 0x3C, 0x0F, 0xF0, 0x07, 0x81, 0xFE, 0x01, 0xE0, 0x3F, 0xC0,
  0x3C, 0x0F, 0x3C, 0x07, 0x81, 0xE7, 0x80, 0xF0, 0x3C, 0xF0, 0x1E, 0x07,
  0x9E, 0x07, 0x80, 0xF1, 0xE0, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x87, 0x83,
  0xC0, 0xF0, 0x78, 0xF8, 0x1E, 0x0F, 0x1E, 0x03, 0xC1, 0xE3, 0xC0, 0xF0,
  0x3C, 0x78, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x0F, 0x78,
  0x1F, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x03, 0xFC, 0x0F, 0x00,
  0x7F, 0x01, 0xE0, 0x07, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x81,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3E, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x78, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x83,
  0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03,
  0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C,
  0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xF9, 0xFE, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x78,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x3F,
  0x9F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x7C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xC0,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x78, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xF7, 0xE0, 0x7C, 0x02, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x86, 0x00, 0xF8, 0x3F,
  0x3F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x1F,
  0x03, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF,
  0x00, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C,
  0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0,
  0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0xF8, 0x01, 0xF0, 0x07, 0xBC, 0x01, 0xF8, 0x07, 0xDE, 0x00, 0xFC, 0x03,
  0xCF, 0x00, 0x7E, 0x01, 0xE7, 0x80, 0x7F, 0x01, 0xF3, 0xC0, 0x3F, 0x80,
  0xF1, 0xE0, 0x3F, 0xC0, 0xF8, 0xF0, 0x1D, 0xE0, 0x78, 0x78, 0x1E, 0xF0,
  0x3C, 0x3C, 0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x07, 0x9E,
  0x1F, 0x07, 0x83, 0x8F, 0x0F, 0x03, 0xC3, 0xC7, 0x87, 0x81, 0xE1, 0xC3,
  0xC7, 0x80, 0xF1, 0xE1, 0xE3, 0xC0, 0x78, 0xF0, 0xF3, 0xC0, 0x3C, 0xF0,
  0x79, 0xE0, 0x1E, 0x78, 0x3D, 0xF0, 0x0F, 0x38, 0x1E, 0xF0, 0x07, 0xBC,
  0x0F, 0x78, 0x03, 0xDC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF1, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF8,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x78,
  0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x3C, 0x3C,
  0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xBC, 0x00, 0xF7, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C,
  0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x38, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0,
  0x0E, 0x78, 0x01, 0xFE, 0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1,
  0xF1, 0xE1, 0xC1, 0xC3, 0x80, 0x01, 0xF0, 0xF0, 0x7F, 0xCE, 0x0F, 0xFD,
  0xE1, 0xFF, 0xFE, 0x1F, 0x07, 0xE3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0,
  0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x03, 0xF0, 0xF0, 0x3F, 0x0F, 0x8F, 0xF0, 0xFF, 0xEE, 0x07, 0xFD, 0xE0,
  0x3F, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0xF0, 0x0F, 0x3F, 0xC0, 0xF7, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFC, 0x1E, 0x1F, 0x81, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F,
  0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03,
  0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0xFE, 0x3F, 0x0F, 0xFF, 0xE0, 0xE7, 0xFC, 0x0E, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x02, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x08, 0xFC, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x8F, 0x01,
  0xFF, 0x78, 0x1F, 0xFB, 0xC1, 0xFF, 0xFE, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F, 0x8F,
  0xE0, 0x7F, 0xF7, 0x01, 0xFF, 0x38, 0x07, 0xE3, 0xC0, 0x00, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC1, 0xF1, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x1E, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x0F, 0xFE,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x01, 0x1F, 0x83, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x60, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x3C, 0x07, 0xFC, 0xE0, 0x3F, 0xF7, 0x81, 0xFF, 0xFE, 0x07, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x1E, 0x01, 0xF0,
  0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x3F,
  0x03, 0xC1, 0xFC, 0x0F, 0x8F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xDE, 0x00,
  0xFC, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0xC0, 0x3E, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF1, 0xF0, 0x3C, 0xFF, 0x07, 0xBF, 0xF0, 0xFF,
  0xFE, 0x1F, 0x83, 0xC7, 0xE0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xC0,
  0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xCF, 0x80, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x03, 0xC0,
  0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x1F,
  0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x1F,
  0x01, 0xE3, 0xE0, 0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x07, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0x0F, 0x1F, 0x01, 0xF0, 0x3C, 0xFF, 0x1F, 0xE0, 0xF7,
  0xFC, 0xFF, 0xC3, 0xBF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF8, 0x3C, 0x7E, 0x07,
  0xC0, 0xF1, 0xF0, 0x1F, 0x03, 0xC7, 0xC0, 0xF8, 0x0F, 0x1E, 0x03, 0xE0,
  0x3C, 0xF8, 0x0F, 0x00, 0xF3, 0xE0, 0x3C, 0x07, 0xCF, 0x00, 0xF0, 0x1E,
  0x3C, 0x07, 0xC0, 0x78, 0xF0, 0x1E, 0x01, 0xE7, 0xC0, 0x78, 0x07, 0x9E,
  0x01, 0xE0, 0x3E, 0x78, 0x07, 0x80, 0xF1, 0xE0, 0x3E, 0x03, 0xC7, 0x80,
  0xF0, 0x0F, 0x3E, 0x03, 0xC0, 0x7C, 0xF0, 0x0F, 0x01, 0xE3, 0xC0, 0x3C,
  0x07, 0x8F, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x1F, 0x81, 0xE7, 0xF8, 0x3D,
  0xFF, 0x87, 0x7F, 0xF1, 0xFC, 0x1E, 0x3F, 0x03, 0xC7, 0xC0, 0x78, 0xF8,
  0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x00,
  0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x07,
  0x8F, 0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x83, 0xE3, 0xF1, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xC7, 0xC0, 0x0F, 0x3F, 0xC0, 0x3D,
  0xFF, 0x00, 0xEF, 0x7E, 0x03, 0xF0, 0x78, 0x1F, 0x81, 0xE0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0,
  0x3C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xE3, 0xF0,
  0x3D, 0xFF, 0x80, 0xF7, 0xFC, 0x03, 0xCF, 0xE0, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0xF0, 0x7F, 0xCE, 0x0F, 0xFD, 0xE1, 0xFF, 0xFE, 0x1F, 0x07,
  0xE3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80,
  0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0,
  0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x3F, 0x0F,
  0x8F, 0xE0, 0xFF, 0xFE, 0x07, 0xFD, 0xE0, 0x3F, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x1F, 0x0F, 0x3F, 0x0F, 0x7E, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xC3, 0xF3, 0xE1, 0xE0, 0x20, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x20,
  0x1F, 0x1C, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0xFD, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF0, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x79, 0xF0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F,
  0x1E, 0x07, 0xE3, 0xC1, 0xFC, 0x7C, 0x77, 0x0F, 0xFE, 0xE0, 0xFF, 0xBC,
  0x0F, 0xC7, 0x80, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E,
  0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x07,
  0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0x78, 0x1F, 0x81, 0xEF, 0x07, 0xF0, 0x79,
  0xE0, 0xFE, 0x0F, 0x3C, 0x3F, 0xC3, 0xE7, 0x87, 0x78, 0x78, 0xF1, 0xEF,
  0x0F, 0x1E, 0x39, 0xE3, 0xC3, 0xC7, 0x3C, 0x78, 0x79, 0xE7, 0x9E, 0x0F,
  0x38, 0xF3, 0xC1, 0xEF, 0x1E, 0xF0, 0x3D, 0xC3, 0xDE, 0x07, 0xF8, 0x7B,
  0xC0, 0xEF, 0x0F, 0xF0, 0x1D, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7E,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x7C,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1F, 0x7C, 0x00, 0x3D, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDF, 0x00,
  0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xE0, 0x3E, 0x07, 0x81, 0xF0,
  0x1E, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0xC0, 0x00,
  0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xDF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7F, 0x80,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFD, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 31, 11, 1, -30 },
  { 44, 14, 11, 16, 4, -30 },
  { 64, 24, 30, 24, 1, -30 },
  { 154, 20, 34, 21, 1, -32 },
  { 239, 27, 30, 32, 3, -30 },
  { 341, 23, 30, 25, 1, -30 },
  { 428, 6, 11, 9, 4, -30 },
  { 437, 14, 37, 12, 1, -30 },
  { 502, 14, 37, 12, -3, -30 },
  { 567, 17, 18, 20, 4, -32 },
  { 606, 19, 20, 22, 2, -25 },
  { 654, 9, 11, 10, -2, -5 },
  { 667, 10, 4, 13, 1, -13 },
  { 672, 5, 6, 10, 1, -5 },
  { 676, 21, 30, 15, -2, -30 },
  { 755, 18, 30, 21, 2, -30 },
  { 823, 13, 30, 21, 5, -30 },
  { 872, 21, 30, 21, -1, -30 },
  { 951, 20, 30, 21, 0, -30 },
  { 1026, 20, 30, 21, 0, -30 },
  { 1101, 20, 30, 21, 1, -30 },
  { 1176, 19, 30, 21, 2, -30 },
  { 1248, 20, 30, 21, 2, -30 },
  { 1323, 20, 30, 21, 1, -30 },
  { 1398, 19, 30, 21, 1, -30 },
  { 1470, 10, 24, 10, 0, -23 },
  { 1500, 12, 29, 10, -2, -23 },
  { 1544, 19, 20, 22, 2, -25 },
  { 1592, 19, 12, 22, 2, -21 },
  { 1621, 19, 20, 22, 2, -25 },
  { 1669, 16, 31, 16, 2, -30 },
  { 1731, 29, 34, 32, 2, -30 },
  { 1855, 23, 30, 22, -3, -30 },
  { 1942, 22, 30, 23, 1, -30 },
  { 2025, 22, 30, 22, 2, -30 },
  { 2108, 23, 30, 25, 1, -30 },
  { 2195, 20, 30, 20, 1, -30 },
  { 2270, 20, 30, 19, 1, -30 },
  { 2345, 24, 30, 26, 2, -30 },
  { 2435, 25, 30, 26, 1, -30 },
  { 2529, 17, 30, 13, -1, -30 },
  { 2593, 18, 38, 11, -6, -30 },
  { 2679, 25, 30, 22, 1, -30 },
  { 2773, 15, 30, 18, 1, -30 },
  { 2830, 32, 30, 33, 1, -30 },
  { 2950, 27, 30, 27, 1, -30 },
  { 3052, 24, 30, 27, 2, -30 },
  { 3142, 21, 30, 22, 1, -30 },
  { 3221, 24, 37, 27, 2, -30 },
  { 3332, 21, 30, 22, 1, -30 },
  { 3411, 21, 30, 20, 0, -30 },
  { 3490, 19, 30, 19, 4, -30 },
  { 3562, 23, 30, 26, 3, -30 },
  { 3649, 21, 30, 21, 4, -30 },
  { 3728, 33, 30, 33, 4, -30 },
  { 3852, 26, 30, 21, -2, -30 },
  { 3950, 20, 30, 20, 4, -30 },
  { 4025, 23, 30, 20, -1, -30 },
  { 4112, 17, 37, 12, -1, -30 },
  { 4191, 8, 30, 15, 4, -30 },
  { 4221, 16, 37, 12, -3, -30 },
  { 4295, 19, 18, 21, 1, -30 },
  { 4338, 16, 2, 15, -4, 4 },
  { 4342, 7, 7, 12, 6, -32 },
  { 4349, 20, 23, 22, 2, -23 },
  { 4407, 20, 32, 22, 1, -32 },
  { 4487, 16, 23, 17, 2, -23 },
  { 4533, 21, 32, 22, 2, -32 },
  { 4617, 17, 23, 20, 2, -23 },
  { 4666, 23, 42, 13, -5, -32 },
  { 4787, 22, 33, 22, 0, -23 },
  { 4878, 19, 32, 22, 1, -32 },
  { 4954, 10, 31, 10, 1, -31 },
  { 4993, 16, 41, 10, -5, -31 },
  { 5075, 20, 32, 20, 1, -32 },
  { 5155, 11, 32, 10, 1, -32 },
  { 5199, 30, 23, 33, 1, -23 },
  { 5286, 19, 23, 22, 1, -23 },
  { 5341, 18, 23, 22, 2, -23 },
  { 5393, 22, 33, 22, -1, -23 },
  { 5484, 20, 33, 22, 2, -23 },
  { 5567, 16, 23, 15, 1, -23 },
  { 5613, 17, 23, 17, 0, -23 },
  { 5662, 13, 28, 13, 2, -28 },
  { 5708, 19, 23, 22, 2, -23 },
  { 5763, 18, 23, 18, 2, -23 },
  { 5815, 27, 23, 28, 3, -23 },
  { 5893, 22, 23, 19, -2, -23 },
  { 5957, 24, 33, 18, -4, -23 },
  { 6056, 18, 23, 17, -1, -23 },
  { 6108, 17, 37, 14, 0, -30 },
  { 6187, 3, 42, 20, 9, -32 },
  { 6203, 16, 37, 14, -2, -30 },
  { 6277, 19, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC42PT7B_H_
