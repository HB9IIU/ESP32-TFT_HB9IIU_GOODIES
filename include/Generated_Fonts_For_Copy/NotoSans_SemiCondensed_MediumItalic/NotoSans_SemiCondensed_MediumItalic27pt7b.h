#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0x77, 0x67, 0xE6, 0xE6,
  0xC6, 0xC6, 0xCC, 0x01, 0x8E, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x18, 0x03,
  0x18, 0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0C,
  0x60, 0x7F, 0xFC, 0x7F, 0xFC, 0x98, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x31,
  0xC0, 0x31, 0x80, 0x31, 0x80, 0x00, 0x80, 0x18, 0x01, 0x80, 0xFF, 0x1F,
  0xF3, 0x92, 0x3B, 0x03, 0x30, 0x3A, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x4C, 0x04, 0xE0, 0xCE, 0x8D, 0xCF, 0xFC, 0xFF, 0x83, 0xE0, 0x18,
  0x01, 0x80, 0x18, 0x00, 0x08, 0x00, 0x1F, 0x03, 0x9D, 0xC1, 0x8C, 0x61,
  0x8E, 0x31, 0x86, 0x38, 0xC3, 0x1C, 0xC1, 0x8C, 0xC0, 0xC6, 0x67, 0x67,
  0x6F, 0xFF, 0x66, 0x7F, 0x36, 0x32, 0x33, 0x18, 0x39, 0x8C, 0x19, 0xC6,
  0x18, 0xC7, 0x1C, 0x63, 0x0C, 0x31, 0x8C, 0x1F, 0x8E, 0x07, 0x80, 0x01,
  0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x38,
  0x0E, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x0B, 0xF8, 0x6E, 0x39, 0xDC,
  0x3B, 0x30, 0x7E, 0x60, 0x78, 0xC0, 0xE1, 0xC7, 0xE3, 0xFF, 0xE3, 0xF1,
  0xC0, 0x76, 0xEE, 0xCC, 0xC0, 0x03, 0x83, 0x03, 0x83, 0x81, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x83, 0x83, 0x80, 0x04, 0x00, 0xC0,
  0x18, 0x63, 0x0F, 0x40, 0xFF, 0xC3, 0xF9, 0xF0, 0x76, 0x1C, 0xE1, 0x8C,
  0x01, 0x40, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x39, 0xDC, 0xE6, 0x63,
  0x00, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x7E, 0x0F, 0xE1, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07,
  0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCF, 0x38, 0x7F, 0x03, 0xE0, 0x07, 0x87, 0x8F, 0xCF, 0xEE, 0x62,
  0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0x87, 0xFE, 0x18, 0x70, 0x83,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0x80, 0x7F, 0x87, 0xFE, 0x10, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x03, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE6, 0x0F, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3B, 0x01, 0xB8, 0x19, 0xC1, 0xCC, 0x1C,
  0x60, 0xC7, 0x0C, 0x38, 0xE1, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF8, 0x7F, 0xC3, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF0, 0x3F, 0xE0, 0x8F, 0x00, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0xC1, 0xE7, 0xFE, 0x1F, 0xC0,
  0x00, 0x60, 0x1F, 0xC1, 0xFC, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x77, 0xC3, 0xFF, 0x1E, 0x39, 0xE1, 0xCE, 0x06, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xE1, 0xC3, 0x9E, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x3C, 0x00, 0x01, 0x80, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x33,
  0x83, 0x38, 0x71, 0xCF, 0x1D, 0xE0, 0xF8, 0x1F, 0x87, 0x9C, 0x71, 0xCE,
  0x0E, 0xC0, 0xEC, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0x83, 0xF0, 0x01, 0x00,
  0xFC, 0x1F, 0xE3, 0x87, 0x30, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77,
  0x0F, 0x79, 0xE3, 0xF6, 0x1E, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x88,
  0x70, 0xFE, 0x0F, 0xC0, 0x0C, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x73, 0xCE, 0x00, 0x06, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x86, 0x1C, 0x30, 0xE1, 0x83, 0x00, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x38, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x60, 0x08, 0x00, 0x02, 0x1F, 0xE3,
  0xFC, 0x87, 0x00, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xC0, 0x60,
  0x38, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x1C, 0x07, 0x06, 0x00, 0x61, 0x80, 0x06, 0x60, 0xF8,
  0xCC, 0x7F, 0x1B, 0x1C, 0x63, 0x63, 0x0C, 0x6C, 0xE3, 0x0F, 0x18, 0x61,
  0xE3, 0x0C, 0x6C, 0x63, 0x8D, 0x8C, 0x73, 0x31, 0xF7, 0xE7, 0x1E, 0x70,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x10, 0x1F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0D, 0xC0, 0x3B, 0x80,
  0x67, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x18, 0x70, 0x7F, 0xE0, 0xFF,
  0xC3, 0x83, 0x86, 0x03, 0x1C, 0x06, 0x38, 0x0C, 0xE0, 0x1B, 0xC0, 0x38,
  0x0F, 0xF0, 0x7F, 0xE1, 0xC3, 0x87, 0x07, 0x18, 0x1C, 0xE0, 0x63, 0x83,
  0x8E, 0x3C, 0x3F, 0xE0, 0xFF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xC6, 0x07, 0x38, 0x3C, 0xE3, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xC0,
  0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC3, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F,
  0xF0, 0x71, 0xF0, 0xE0, 0xE1, 0x81, 0xC7, 0x01, 0x8E, 0x03, 0x9C, 0x07,
  0x38, 0x0C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x18,
  0x1C, 0x70, 0x78, 0xE7, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0xFF,
  0x87, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1,
  0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x87, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFE, 0x1F, 0xF0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x63, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x87, 0xE7, 0x0F, 0xCC, 0x03, 0x98,
  0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0xF0, 0xE1, 0xFF, 0xC0, 0xFF,
  0x00, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0,
  0x70, 0xE0, 0x70, 0x0F, 0xE0, 0xF8, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0x0C, 0x0E, 0x38, 0x38, 0x70, 0xE0,
  0xE3, 0x81, 0x8E, 0x07, 0x3C, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x38, 0x18, 0x70, 0x70, 0xE0,
  0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0xC0, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x3F, 0x1F, 0x03, 0x63, 0xB0, 0x76, 0x3B, 0x06, 0xE3, 0xB0, 0xEE,
  0x33, 0x0C, 0xE3, 0x31, 0xCC, 0x73, 0x19, 0xC7, 0x33, 0x9C, 0x73, 0x31,
  0xC6, 0x3F, 0x1C, 0x63, 0xE1, 0x8E, 0x3E, 0x38, 0xE3, 0xC3, 0x8C, 0x1C,
  0x38, 0xC1, 0x83, 0x80, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0xC0, 0xC3, 0xE0,
  0xE1, 0xB0, 0x71, 0xD8, 0x38, 0xEE, 0x18, 0x77, 0x0C, 0x31, 0x8E, 0x18,
  0xE7, 0x1C, 0x73, 0x8E, 0x19, 0x87, 0x0C, 0xC3, 0x07, 0xE1, 0x83, 0xF1,
  0xC0, 0xF8, 0xE0, 0x78, 0x70, 0x3C, 0x30, 0x0E, 0x00, 0x00, 0x80, 0x0F,
  0xE0, 0x3F, 0xE0, 0xE1, 0xE3, 0x81, 0xCF, 0x01, 0xDC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x37, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0xB0,
  0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xE3, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x87, 0x1E, 0x38, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07,
  0x38, 0x71, 0xFF, 0x9F, 0xF0, 0xFC, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x80, 0x0F, 0xE0, 0x3F, 0xE0,
  0xE1, 0xE3, 0x81, 0xCF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x37, 0x00, 0xEC, 0x01, 0xD8, 0x03, 0xB0, 0x0E, 0x70, 0x1C,
  0xE0, 0x71, 0xE3, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xE0, 0xFF, 0x87, 0x1E, 0x38, 0x71,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x38, 0xF1, 0xFF, 0x1F, 0xE0, 0xE7,
  0x07, 0x18, 0x38, 0xE1, 0x87, 0x1C, 0x18, 0xE0, 0xE7, 0x07, 0x30, 0x3C,
  0x00, 0xC0, 0x3F, 0xC3, 0xFE, 0x3C, 0x21, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE6, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0x9C, 0x06, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0x8E, 0x07, 0x18, 0x0E, 0x30, 0x1C, 0x70, 0x70, 0xF1, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xE0, 0x1D, 0x80, 0xE6, 0x03, 0x98, 0x1C, 0x60, 0x71, 0x83,
  0x87, 0x0E, 0x1C, 0x30, 0x71, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xC0, 0x77,
  0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xC0, 0x60, 0x3E, 0x07, 0x03, 0xB0, 0x3C, 0x1D, 0x83, 0xE1, 0xCC, 0x1F,
  0x0E, 0x61, 0xF8, 0xE3, 0x0D, 0xC7, 0x18, 0xEE, 0x30, 0xC6, 0x73, 0x86,
  0x33, 0x9C, 0x33, 0x9D, 0xC1, 0x98, 0xEE, 0x0D, 0xC7, 0x60, 0x6C, 0x3F,
  0x03, 0x61, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x38,
  0x1E, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38,
  0x03, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0x38, 0xE0, 0x3B, 0x83, 0x9C, 0x38, 0xE1, 0xC7, 0x1C,
  0x18, 0xE0, 0xCE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x10, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xE0, 0xFC, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF8, 0x3F, 0x00, 0xC7, 0x39, 0xC6, 0x31, 0x8C,
  0x73, 0x9C, 0x63, 0x18, 0xC7, 0x39, 0xC6, 0x07, 0xE0, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC1,
  0xF8, 0x3F, 0x00, 0x03, 0x00, 0x70, 0x0F, 0x80, 0xD8, 0x1D, 0x81, 0x8C,
  0x38, 0xC3, 0x0E, 0x70, 0x66, 0x06, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xEE,
  0x73, 0x10, 0x07, 0x18, 0xFD, 0xCF, 0xFC, 0x70, 0xE7, 0x07, 0x38, 0x39,
  0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x3C, 0x3F,
  0x61, 0xF3, 0x00, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x73, 0x83, 0xBE, 0x1F, 0xF8, 0xF1, 0xC7, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x73, 0x83, 0x9E, 0x38, 0xDF, 0x8E,
  0xF8, 0x00, 0x07, 0x81, 0xFC, 0xFF, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x10, 0xFE, 0x0F, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x73, 0x87,
  0xEE, 0x3F, 0xF0, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x8E,
  0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8E, 0x3C, 0x1F, 0xB0, 0x7C, 0xC0,
  0x07, 0x81, 0xF8, 0x77, 0x9C, 0x77, 0x0E, 0xE1, 0xD9, 0xF7, 0xFC, 0xFC,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0x08, 0xFF, 0x0F, 0xE0, 0x00, 0x18, 0x01,
  0xF0, 0x0F, 0xC0, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x03, 0xFC, 0x0F,
  0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x8C, 0x3F,
  0x71, 0xFF, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x03, 0x9C, 0x0C, 0x70,
  0x71, 0xC1, 0xC7, 0x0F, 0x1C, 0x3C, 0x71, 0xE0, 0xFF, 0x83, 0xEE, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x08, 0x3C, 0x3F, 0xE0, 0xFF, 0x00, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x73, 0x83, 0xBE, 0x1F,
  0xF8, 0xF1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x18, 0xE1, 0xC6, 0x0E,
  0x70, 0x73, 0x83, 0x9C, 0x18, 0xC1, 0xCE, 0x0E, 0x00, 0x06, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70,
  0xE1, 0x87, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0xF8, 0x3C, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC1,
  0xC7, 0x0E, 0x1C, 0x70, 0x73, 0x81, 0x9C, 0x0E, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x0E, 0xE0, 0x71, 0x81, 0xC7, 0x07, 0x1C, 0x18, 0x38, 0xE0,
  0xE0, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3,
  0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x00, 0x1C, 0xE1, 0xE1, 0xDF,
  0x3F, 0x1B, 0xFF, 0xF1, 0xE3, 0xC7, 0x1C, 0x38, 0x73, 0x83, 0x87, 0x38,
  0x30, 0x73, 0x87, 0x07, 0x30, 0x70, 0x63, 0x07, 0x0E, 0x70, 0x70, 0xE7,
  0x06, 0x0E, 0x70, 0xE0, 0xE6, 0x0E, 0x0C, 0xE0, 0xE1, 0xC0, 0x1C, 0xE0,
  0xEF, 0xC6, 0xFE, 0x3C, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x38,
  0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x73, 0x83, 0x80, 0x07,
  0x81, 0xFC, 0x3F, 0xE3, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0x70,
  0x3B, 0xE0, 0xDB, 0xC3, 0xC7, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07,
  0x18, 0x1C, 0x60, 0x73, 0x83, 0x8E, 0x0E, 0x3C, 0x70, 0xDF, 0x83, 0x7C,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07,
  0x18, 0xFD, 0xCF, 0xFC, 0x70, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x0C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x3C, 0x3F, 0xE1, 0xF7, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1C, 0xE3,
  0xBC, 0x6F, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x83, 0xFC, 0xF7, 0x1C,
  0x03, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x70, 0x0E, 0x01, 0xC8,
  0x39, 0xFE, 0x3F, 0x80, 0x0C, 0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xFC, 0x7C, 0x38, 0x39,
  0xC1, 0xCE, 0x0C, 0x60, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x0C, 0x60,
  0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x3C, 0x7F, 0x61, 0xF3, 0x00, 0xE0,
  0x76, 0x07, 0x60, 0xE6, 0x0E, 0x61, 0xC6, 0x1C, 0x63, 0x86, 0x38, 0x77,
  0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x38, 0x00, 0xC1, 0xC1,
  0xE0, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0xEC, 0x6C, 0x76, 0x36, 0x33, 0x3B,
  0x39, 0x99, 0x98, 0xDC, 0xDC, 0x6C, 0x6C, 0x36, 0x36, 0x1E, 0x1F, 0x0F,
  0x0F, 0x07, 0x87, 0x83, 0x83, 0x80, 0x1C, 0x1C, 0x70, 0xE0, 0xE3, 0x83,
  0x9C, 0x0E, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x01,
  0xDC, 0x0E, 0x70, 0x38, 0xC1, 0xC3, 0x8E, 0x0E, 0x00, 0x1C, 0x0E, 0x18,
  0x1C, 0x30, 0x70, 0x60, 0xE0, 0xC3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0xE0, 0x1D, 0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xE0, 0x78, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0x81, 0xE0, 0x30, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0xC0, 0x7C, 0x07, 0x07, 0xC3, 0x80, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x3C, 0x0E, 0x00, 0x7E, 0x1F, 0xFF, 0xC3,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 8, 7, 11, 3, -19 },
  { 27, 16, 19, 15, 0, -19 },
  { 65, 12, 23, 13, 1, -21 },
  { 100, 17, 20, 20, 2, -20 },
  { 143, 15, 20, 16, 1, -20 },
  { 181, 4, 7, 6, 3, -19 },
  { 185, 9, 23, 8, 1, -19 },
  { 211, 9, 23, 8, -2, -19 },
  { 237, 11, 12, 13, 3, -21 },
  { 254, 11, 13, 14, 2, -16 },
  { 272, 5, 7, 7, -1, -3 },
  { 277, 6, 2, 8, 1, -8 },
  { 279, 4, 3, 7, 0, -3 },
  { 281, 13, 19, 10, -1, -19 },
  { 312, 12, 20, 13, 1, -20 },
  { 342, 9, 19, 13, 3, -19 },
  { 364, 13, 20, 13, 0, -20 },
  { 397, 13, 20, 13, 0, -20 },
  { 430, 13, 19, 13, 0, -19 },
  { 461, 13, 19, 13, 0, -19 },
  { 492, 13, 20, 13, 1, -20 },
  { 525, 13, 19, 13, 1, -19 },
  { 556, 12, 20, 13, 1, -20 },
  { 586, 12, 20, 13, 1, -20 },
  { 616, 6, 15, 7, 0, -15 },
  { 628, 7, 19, 7, -1, -15 },
  { 645, 12, 13, 14, 1, -16 },
  { 665, 11, 7, 14, 2, -13 },
  { 675, 11, 13, 14, 2, -16 },
  { 693, 10, 20, 11, 1, -20 },
  { 718, 19, 21, 21, 1, -19 },
  { 768, 15, 19, 14, -2, -19 },
  { 804, 14, 19, 15, 1, -19 },
  { 838, 14, 20, 14, 2, -20 },
  { 873, 15, 19, 16, 1, -19 },
  { 909, 13, 19, 13, 1, -19 },
  { 940, 13, 19, 12, 1, -19 },
  { 971, 15, 20, 17, 2, -20 },
  { 1009, 16, 19, 17, 1, -19 },
  { 1047, 11, 19, 9, -1, -19 },
  { 1074, 12, 24, 7, -4, -19 },
  { 1110, 15, 19, 14, 1, -19 },
  { 1146, 9, 19, 12, 1, -19 },
  { 1168, 20, 19, 21, 1, -19 },
  { 1216, 17, 19, 18, 1, -19 },
  { 1257, 15, 20, 17, 2, -20 },
  { 1295, 13, 19, 14, 1, -19 },
  { 1326, 15, 25, 17, 2, -20 },
  { 1373, 13, 19, 14, 1, -19 },
  { 1404, 13, 20, 13, 0, -20 },
  { 1437, 12, 19, 12, 2, -19 },
  { 1466, 15, 19, 16, 2, -19 },
  { 1502, 14, 19, 14, 2, -19 },
  { 1536, 21, 19, 21, 3, -19 },
  { 1586, 16, 19, 13, -1, -19 },
  { 1624, 13, 19, 13, 2, -19 },
  { 1655, 15, 19, 13, -1, -19 },
  { 1691, 11, 23, 8, -1, -19 },
  { 1723, 5, 19, 10, 3, -19 },
  { 1735, 11, 23, 8, -2, -19 },
  { 1767, 12, 11, 14, 1, -19 },
  { 1784, 10, 2, 10, -2, 2 },
  { 1787, 4, 5, 8, 4, -21 },
  { 1790, 13, 15, 14, 1, -15 },
  { 1815, 13, 21, 14, 0, -21 },
  { 1850, 11, 15, 11, 1, -15 },
  { 1871, 14, 21, 14, 1, -21 },
  { 1908, 11, 15, 13, 1, -15 },
  { 1929, 14, 27, 8, -3, -21 },
  { 1977, 14, 21, 14, 0, -15 },
  { 2014, 13, 21, 14, 0, -21 },
  { 2049, 7, 20, 7, 0, -20 },
  { 2067, 10, 26, 7, -3, -20 },
  { 2100, 14, 21, 13, 0, -21 },
  { 2137, 7, 21, 7, 0, -21 },
  { 2156, 20, 15, 21, 0, -15 },
  { 2194, 13, 15, 14, 0, -15 },
  { 2219, 12, 15, 14, 1, -15 },
  { 2242, 14, 21, 14, -1, -15 },
  { 2279, 13, 21, 14, 1, -15 },
  { 2314, 11, 15, 10, 0, -15 },
  { 2335, 11, 15, 11, 0, -15 },
  { 2356, 8, 18, 9, 1, -18 },
  { 2374, 13, 15, 14, 1, -15 },
  { 2399, 12, 15, 12, 1, -15 },
  { 2422, 17, 15, 18, 2, -15 },
  { 2454, 14, 15, 12, -1, -15 },
  { 2481, 15, 21, 12, -2, -15 },
  { 2521, 12, 15, 11, -1, -15 },
  { 2544, 11, 23, 9, 0, -19 },
  { 2576, 2, 27, 13, 6, -21 },
  { 2583, 10, 23, 9, -1, -19 },
  { 2612, 12, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC27PT7B_H_
