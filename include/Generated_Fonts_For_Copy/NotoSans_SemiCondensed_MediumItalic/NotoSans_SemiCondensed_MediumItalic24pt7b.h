#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x80,
  0x00, 0x18, 0x78, 0xE0, 0x77, 0x67, 0x66, 0x66, 0x66, 0xC4, 0x03, 0x18,
  0x0C, 0x40, 0x33, 0x01, 0x8C, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x18,
  0x0C, 0xC0, 0x33, 0x07, 0xFF, 0xBF, 0xFC, 0x19, 0x80, 0xC6, 0x03, 0x18,
  0x0C, 0xC0, 0x63, 0x00, 0x00, 0x80, 0x18, 0x07, 0xF1, 0xFE, 0x19, 0x21,
  0xB0, 0x3B, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x6C, 0x04, 0xC0,
  0x4C, 0x45, 0xCF, 0xF8, 0x3E, 0x00, 0x80, 0x18, 0x00, 0x3C, 0x0C, 0xF8,
  0x33, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0x19, 0x98, 0x23, 0x32, 0x46, 0xDF,
  0xDB, 0x77, 0xE6, 0xCC, 0x1B, 0x18, 0x66, 0x30, 0xCC, 0x63, 0x19, 0x8C,
  0x33, 0x18, 0x7C, 0x60, 0x78, 0x07, 0xE0, 0x3F, 0x80, 0xC7, 0x03, 0x18,
  0x0C, 0x60, 0x33, 0x80, 0xFC, 0x01, 0xC0, 0x1F, 0x00, 0xEC, 0x77, 0x39,
  0x98, 0x7E, 0xE1, 0xF3, 0x83, 0x86, 0x1E, 0x1F, 0xFC, 0x3F, 0x38, 0x76,
  0x66, 0x6C, 0x07, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x70, 0x60, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x06,
  0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06,
  0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xE0, 0x06, 0x01, 0x84, 0x63,
  0xD0, 0x3F, 0xC7, 0x73, 0xE1, 0xD8, 0x23, 0x00, 0x80, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x39, 0x9C, 0xC6, 0x60, 0x7E, 0xFB, 0xF0, 0x6F, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00,
  0x0F, 0x83, 0xF8, 0xE3, 0x18, 0x77, 0x0E, 0xE1, 0xD8, 0x3F, 0x07, 0xE0,
  0xDC, 0x1B, 0x07, 0x60, 0xEC, 0x19, 0x87, 0x39, 0xC3, 0xF0, 0x7C, 0x00,
  0x0E, 0x3D, 0xFF, 0x6C, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86,
  0x0C, 0x38, 0x70, 0x0F, 0xC1, 0xFE, 0x18, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x08, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0xF8, 0x0F, 0x01, 0x3C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x83, 0xCF, 0xF8, 0xFE, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x36, 0x07, 0xE0, 0x6C, 0x0C, 0xC1, 0x8C, 0x39, 0xC3, 0x1C, 0x61, 0x8F,
  0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x0F, 0xF0, 0xFF,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x1E, 0x03, 0xF8, 0x13, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x83, 0xCF, 0xF8, 0x7F, 0x00, 0x07,
  0xE1, 0xFC, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x19, 0xC3, 0xFC, 0xF1, 0xDC,
  0x3B, 0x87, 0x70, 0xEC, 0x1D, 0xC3, 0x38, 0xE3, 0xF8, 0x3E, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x00, 0x0F, 0xC3, 0xFC, 0xE3, 0x98, 0x33, 0x0E, 0x71, 0x86, 0x70, 0xF8,
  0x3F, 0x0E, 0x73, 0x86, 0x60, 0xEC, 0x1D, 0x83, 0x38, 0xE7, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xF8, 0xC3, 0x38, 0x66, 0x0E, 0xC1, 0xD8, 0x33, 0x0E,
  0x73, 0xCF, 0xF8, 0x77, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC7, 0xF0, 0xF8,
  0x00, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x00, 0x0C, 0x3C,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0x87, 0x0C, 0x38, 0x60,
  0x00, 0x60, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x03, 0x00, 0x00, 0x3F, 0x3F, 0xC8, 0xE0, 0x30, 0x18,
  0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x04,
  0x1B, 0x8F, 0xCD, 0x8C, 0xC6, 0xCC, 0x63, 0xC6, 0x31, 0xE6, 0x18, 0xB3,
  0x18, 0xD9, 0x8C, 0x6C, 0xEE, 0x66, 0x3D, 0xE3, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x36, 0x03, 0x60, 0x76, 0x06, 0x60, 0xE6, 0x0C, 0x71, 0xC7, 0x1F, 0xF3,
  0xFF, 0x30, 0x77, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x30, 0x1F, 0xC1, 0xFE,
  0x18, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0xE3, 0xFC, 0x7F, 0x87, 0x1C,
  0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCF, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x87, 0x84, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC1, 0x07,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x06, 0x1C, 0x70, 0x63, 0x83, 0x98,
  0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x3B, 0x81, 0x98, 0x1C, 0xC0, 0xEE, 0x0E,
  0x70, 0xF3, 0x9F, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0xFC, 0x7F, 0x8E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x8F, 0xF1, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xE0,
  0x8F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x61, 0xFB, 0x87,
  0xCE, 0x03, 0x38, 0x1C, 0xE0, 0x71, 0x81, 0xC7, 0x06, 0x0F, 0xF8, 0x1F,
  0xE0, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0xCE, 0x06, 0x38, 0x18, 0xC0, 0xE3,
  0x03, 0x8F, 0xFC, 0x7F, 0xF1, 0xC0, 0xC6, 0x07, 0x18, 0x1C, 0xE0, 0x63,
  0x81, 0x8E, 0x06, 0x30, 0x38, 0xC0, 0xE0, 0x0F, 0xC3, 0xE0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x81, 0xF0, 0xFE, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x5E, 0x0F, 0x80, 0xC0, 0x00,
  0x1C, 0x3C, 0x61, 0xC1, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xCE, 0x03, 0x70,
  0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x06, 0x70, 0x18, 0xC0, 0xE3, 0x83, 0x8E,
  0x0E, 0x18, 0x30, 0x70, 0xC1, 0xC0, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x36, 0x0D, 0x8D, 0x83,
  0x63, 0x61, 0xB8, 0xD8, 0x6C, 0x76, 0x33, 0x19, 0x8C, 0xC6, 0x66, 0x71,
  0x99, 0x9C, 0xE6, 0xC6, 0x38, 0xF1, 0x8C, 0x38, 0x63, 0x0E, 0x38, 0xC3,
  0x0E, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x78, 0x31, 0xF0, 0x63, 0x60, 0xC6,
  0xE3, 0x8C, 0xC7, 0x19, 0x8C, 0x73, 0x18, 0xC7, 0x31, 0x86, 0xE3, 0x0D,
  0x8E, 0x1F, 0x1C, 0x1E, 0x30, 0x3C, 0x60, 0x78, 0xC0, 0xE0, 0x07, 0xF0,
  0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xD8, 0x07,
  0x60, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x31, 0x81, 0xC7, 0x0E,
  0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xFE, 0x18, 0xE3, 0x87, 0x38, 0x73,
  0x07, 0x30, 0x63, 0x0E, 0x7F, 0xC7, 0xF8, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0x8E,
  0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xD8, 0x07, 0x60, 0x1F, 0x80, 0x6E,
  0x01, 0xB8, 0x0E, 0xE0, 0x31, 0x81, 0xC7, 0x0E, 0x0F, 0xF0, 0x1F, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xC1, 0xFE, 0x18, 0xE3,
  0x87, 0x38, 0x73, 0x06, 0x30, 0xE3, 0x1E, 0x7F, 0xC7, 0xF0, 0x63, 0x06,
  0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x8C, 0x1C, 0xC1, 0xC0, 0x0F, 0xF1, 0xFE,
  0x1C, 0x23, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x83, 0x8F, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x1C,
  0x1C, 0x60, 0x73, 0x81, 0x8E, 0x06, 0x38, 0x18, 0xC0, 0xE3, 0x03, 0x9C,
  0x0C, 0x70, 0x31, 0x81, 0xC6, 0x07, 0x18, 0x1C, 0xE0, 0x63, 0x83, 0x87,
  0x1C, 0x1F, 0xF0, 0x3F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0,
  0xC6, 0x1C, 0x61, 0x86, 0x38, 0x63, 0x06, 0x70, 0x66, 0x06, 0xE0, 0x6C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1B,
  0x87, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x19, 0xC6, 0xC7, 0x38, 0xD8, 0xC7,
  0x33, 0x38, 0xE6, 0x66, 0x1D, 0xCC, 0xC1, 0xB1, 0xB8, 0x36, 0x36, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x1C, 0x1E, 0x03, 0x83, 0x80, 0x60, 0x70, 0x00,
  0x0C, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x66, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0xEE, 0x01, 0x8C,
  0x07, 0x18, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0x60, 0xE0, 0xFC, 0x19, 0x87,
  0x30, 0xC6, 0x38, 0xEE, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0,
  0x0F, 0x87, 0xC7, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x1F, 0x0F, 0x00,
  0xCC, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x33, 0x30, 0x07, 0xC3, 0xE0,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC1, 0xE0, 0xF8, 0x00,
  0x06, 0x01, 0xC0, 0x3C, 0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x63, 0x06, 0xE0,
  0xD8, 0x1C, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x0F, 0x67, 0xEC, 0xE7, 0xB8,
  0x76, 0x0D, 0xC1, 0xB8, 0x36, 0x0E, 0xC1, 0xD8, 0x73, 0x8E, 0x7E, 0xC7,
  0x98, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x9C, 0x1F, 0xE1,
  0xC7, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x30, 0x67, 0x0E, 0x70, 0xE7,
  0x1C, 0x7F, 0x8C, 0xF0, 0x0F, 0x9F, 0xCE, 0x0E, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x38, 0x4F, 0xC3, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0xF6, 0x3F, 0x63, 0x9E, 0x70, 0xE6, 0x0C, 0xE0, 0xCE,
  0x0C, 0xC1, 0xCC, 0x1C, 0xC3, 0x8E, 0x38, 0xFD, 0x87, 0x98, 0x0F, 0x8F,
  0xE3, 0x1D, 0xC7, 0x61, 0xBB, 0xEF, 0xF3, 0x00, 0xC0, 0x30, 0x0E, 0x11,
  0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x03,
  0xF0, 0x3F, 0x80, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x5C, 0x03, 0xE0, 0x1C, 0x00, 0x07, 0xB1, 0xFB, 0x1C, 0xF3, 0x87,
  0x30, 0x67, 0x06, 0x70, 0x66, 0x0E, 0x60, 0xE6, 0x1C, 0x73, 0xC7, 0xEC,
  0x3D, 0xC0, 0x18, 0x01, 0x80, 0x38, 0xC7, 0x0F, 0xF0, 0x3C, 0x00, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x9E, 0x1F, 0xE1, 0xC7, 0x38,
  0x73, 0x86, 0x30, 0x63, 0x06, 0x30, 0xE7, 0x0E, 0x70, 0xC6, 0x0C, 0x60,
  0xCE, 0x1C, 0x0C, 0x30, 0xC0, 0x00, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31,
  0xC7, 0x18, 0x63, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x01, 0x85, 0xC3, 0xC1, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x87, 0x18, 0xE1, 0x9C, 0x3B, 0x83, 0xF0, 0x36, 0x03,
  0xE0, 0x3F, 0x07, 0x30, 0x63, 0x86, 0x38, 0x61, 0x8E, 0x1C, 0x0E, 0x18,
  0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30,
  0x61, 0xC0, 0x1B, 0xC7, 0x87, 0xFB, 0xF1, 0xC7, 0x9C, 0xE1, 0xC7, 0x38,
  0x61, 0xCC, 0x18, 0x73, 0x0E, 0x18, 0xC3, 0x86, 0x70, 0xC1, 0x9C, 0x30,
  0xE6, 0x0C, 0x31, 0x87, 0x0C, 0xE1, 0x83, 0x00, 0x1B, 0xE1, 0xFE, 0x1C,
  0x73, 0x87, 0x38, 0x63, 0x06, 0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0C, 0x60,
  0xC6, 0x1C, 0xE1, 0xC0, 0x0F, 0x8F, 0xF3, 0x9D, 0xC3, 0x60, 0xF8, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x0C, 0xE0, 0x7F,
  0x83, 0x8E, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0x60, 0xE3, 0x06, 0x38, 0x71,
  0xC3, 0x8E, 0x38, 0x7F, 0x87, 0x78, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x00, 0x0F, 0x67, 0xEC, 0xE7, 0xB8, 0x76, 0x0D, 0xC1,
  0xB8, 0x36, 0x0E, 0xC1, 0xD8, 0x73, 0x8E, 0x7E, 0xC7, 0xB8, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x00, 0x1B, 0xC7, 0xE1, 0xE0, 0xF0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00,
  0x1F, 0x9F, 0xCC, 0x26, 0x03, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xA1,
  0xDF, 0xCF, 0xC0, 0x18, 0x30, 0xE3, 0xFF, 0xE6, 0x1C, 0x38, 0x60, 0xC1,
  0x87, 0x0E, 0x1C, 0x3E, 0x3C, 0x30, 0x66, 0x0D, 0xC3, 0xB8, 0x76, 0x0C,
  0xC1, 0x98, 0x77, 0x0E, 0xE1, 0x98, 0x73, 0x9E, 0x7E, 0xC7, 0x98, 0xE0,
  0xFC, 0x3B, 0x86, 0x31, 0xC6, 0x30, 0xCE, 0x19, 0x83, 0x70, 0x6C, 0x0D,
  0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE1, 0xC3, 0xE3, 0xC7, 0xE3, 0xC6, 0x66,
  0xCE, 0x66, 0xCC, 0x66, 0xCC, 0x6C, 0xD8, 0x6C, 0xD8, 0x78, 0xF8, 0x78,
  0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x18, 0x38, 0xE3, 0x83, 0x38,
  0x1B, 0x80, 0xF8, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1F, 0x00, 0xDC, 0x0C,
  0x60, 0xE3, 0x8E, 0x1C, 0x00, 0x1C, 0x1C, 0x70, 0xE0, 0xC3, 0x03, 0x1C,
  0x0C, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xF0,
  0x03, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xC1, 0xE0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x1E, 0x0E, 0x00, 0xC0,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xF0, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xC0, 0xE1, 0xE0, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x1C, 0x0C, 0x1E, 0x0C, 0x00, 0x7C, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 8, 6, 9, 2, -17 },
  { 22, 14, 17, 14, 0, -17 },
  { 52, 12, 19, 12, 0, -18 },
  { 81, 15, 17, 18, 2, -17 },
  { 113, 14, 17, 14, 0, -17 },
  { 143, 4, 6, 5, 2, -17 },
  { 146, 8, 21, 7, 1, -17 },
  { 167, 8, 21, 7, -2, -17 },
  { 188, 10, 10, 12, 2, -18 },
  { 201, 11, 11, 13, 1, -14 },
  { 217, 5, 6, 6, -1, -3 },
  { 221, 7, 3, 7, 0, -8 },
  { 224, 4, 3, 6, 0, -3 },
  { 226, 12, 17, 9, -1, -17 },
  { 252, 11, 17, 12, 1, -17 },
  { 276, 7, 17, 12, 3, -17 },
  { 291, 12, 17, 12, 0, -17 },
  { 317, 12, 17, 12, 0, -17 },
  { 343, 12, 17, 12, 0, -17 },
  { 369, 12, 17, 12, 0, -17 },
  { 395, 11, 17, 12, 1, -17 },
  { 419, 12, 17, 12, 1, -17 },
  { 445, 11, 17, 12, 1, -17 },
  { 469, 11, 17, 12, 1, -17 },
  { 493, 5, 13, 6, 0, -13 },
  { 502, 7, 16, 6, -1, -13 },
  { 516, 11, 11, 13, 1, -14 },
  { 532, 11, 7, 13, 1, -12 },
  { 542, 11, 11, 13, 1, -14 },
  { 558, 9, 17, 9, 1, -17 },
  { 578, 17, 19, 18, 1, -17 },
  { 619, 12, 17, 13, -1, -17 },
  { 645, 12, 17, 13, 1, -17 },
  { 671, 13, 17, 13, 1, -17 },
  { 699, 13, 17, 14, 1, -17 },
  { 727, 11, 17, 11, 1, -17 },
  { 751, 11, 17, 11, 1, -17 },
  { 775, 14, 17, 15, 1, -17 },
  { 805, 14, 17, 15, 1, -17 },
  { 835, 10, 17, 8, -1, -17 },
  { 857, 11, 22, 6, -4, -17 },
  { 888, 14, 17, 12, 1, -17 },
  { 918, 8, 17, 11, 1, -17 },
  { 935, 18, 17, 19, 1, -17 },
  { 974, 15, 17, 16, 1, -17 },
  { 1006, 14, 17, 15, 1, -17 },
  { 1036, 12, 17, 13, 1, -17 },
  { 1062, 14, 21, 15, 1, -17 },
  { 1099, 12, 17, 13, 1, -17 },
  { 1125, 12, 17, 11, 0, -17 },
  { 1151, 11, 17, 11, 2, -17 },
  { 1175, 14, 17, 15, 1, -17 },
  { 1205, 12, 17, 12, 2, -17 },
  { 1231, 19, 17, 19, 2, -17 },
  { 1272, 15, 17, 12, -1, -17 },
  { 1304, 11, 17, 11, 2, -17 },
  { 1328, 13, 17, 11, -1, -17 },
  { 1356, 9, 21, 7, 0, -17 },
  { 1380, 4, 17, 9, 3, -17 },
  { 1389, 10, 21, 7, -2, -17 },
  { 1416, 11, 10, 12, 1, -17 },
  { 1430, 9, 2, 9, -2, 2 },
  { 1433, 5, 3, 7, 3, -18 },
  { 1435, 11, 13, 13, 1, -13 },
  { 1453, 12, 18, 13, 0, -18 },
  { 1480, 9, 13, 10, 1, -13 },
  { 1495, 12, 18, 13, 1, -18 },
  { 1522, 10, 13, 11, 1, -13 },
  { 1539, 13, 24, 7, -3, -18 },
  { 1578, 12, 19, 13, 0, -13 },
  { 1607, 12, 18, 13, 0, -18 },
  { 1634, 6, 18, 6, 0, -18 },
  { 1648, 9, 24, 6, -3, -18 },
  { 1675, 12, 18, 11, 0, -18 },
  { 1702, 7, 18, 6, 0, -18 },
  { 1718, 18, 13, 19, 0, -13 },
  { 1748, 12, 13, 13, 0, -13 },
  { 1768, 10, 13, 12, 1, -13 },
  { 1785, 13, 19, 13, -1, -13 },
  { 1816, 11, 19, 13, 1, -13 },
  { 1843, 10, 13, 9, 0, -13 },
  { 1860, 9, 13, 10, 0, -13 },
  { 1875, 7, 16, 8, 1, -16 },
  { 1889, 11, 13, 13, 1, -13 },
  { 1907, 11, 13, 10, 1, -13 },
  { 1925, 16, 13, 16, 1, -13 },
  { 1951, 13, 13, 11, -1, -13 },
  { 1973, 14, 19, 10, -2, -13 },
  { 2007, 11, 13, 10, -1, -13 },
  { 2025, 10, 21, 8, 0, -17 },
  { 2052, 2, 24, 12, 5, -18 },
  { 2058, 9, 21, 8, -1, -17 },
  { 2082, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC24PT7B_H_
