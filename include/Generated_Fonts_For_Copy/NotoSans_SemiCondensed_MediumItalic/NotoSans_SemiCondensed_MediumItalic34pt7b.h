#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC3, 0xE0, 0xE0, 0x39, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x1C, 0xE3,
  0x98, 0x63, 0x1C, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x07, 0x0C,
  0x00, 0xE1, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0x81, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0xE1, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x30, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0x8E, 0x00,
  0x61, 0xC0, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03,
  0x8E, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFC, 0x07, 0xFF,
  0x0F, 0xFE, 0x1E, 0x46, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0x38,
  0x03, 0x3C, 0x03, 0x3C, 0x03, 0x38, 0x82, 0x78, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x08, 0x7E, 0x01, 0xC1, 0xFC, 0x06, 0x0E, 0x70, 0x38, 0x70, 0xC1, 0xC1,
  0xC3, 0x06, 0x07, 0x1C, 0x38, 0x18, 0x71, 0xC0, 0xE1, 0xC6, 0x03, 0x87,
  0x38, 0x0E, 0x39, 0xC7, 0x38, 0xE6, 0x7E, 0xE7, 0x3B, 0xFD, 0xFD, 0xCE,
  0x77, 0xE7, 0x71, 0xC6, 0x39, 0xC7, 0x01, 0xC6, 0x1C, 0x07, 0x38, 0x70,
  0x38, 0xE1, 0xC1, 0xC3, 0x86, 0x07, 0x0E, 0x38, 0x38, 0x38, 0xE1, 0xC0,
  0xE7, 0x07, 0x01, 0xF8, 0x38, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x80,
  0x0F, 0xF8, 0x03, 0xCF, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80,
  0x78, 0xF0, 0x0F, 0x3C, 0x00, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x83, 0xCF, 0x78, 0x73, 0xC7, 0x1E, 0xF0, 0xF3, 0x9C,
  0x0F, 0xF3, 0x81, 0xFC, 0x70, 0x1F, 0x0E, 0x03, 0xC1, 0xE0, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0x78, 0x3F, 0x87, 0x80, 0x77, 0xFE, 0xEE, 0xCC, 0xC0,
  0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x10, 0x60, 0x71, 0x83, 0xFE, 0x13, 0xFF,
  0xC1, 0xFF, 0x0F, 0x84, 0x7E, 0x03, 0xDC, 0x1E, 0x30, 0x30, 0xE0, 0x43,
  0x80, 0x08, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x3C, 0x71,
  0xE3, 0x87, 0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0x7B, 0xFE, 0xE0, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x60, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xBE, 0x0F, 0x0E, 0x1E,
  0x0E, 0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x78, 0x70, 0xF0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x1F, 0x80, 0x03, 0xC1, 0xF0, 0xFC, 0xFF, 0x7F, 0xBC, 0xE6, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x18, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xF9, 0xF0, 0x30, 0x78, 0x10, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFC, 0x00, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xFF, 0x07, 0x9F, 0x04,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x3C, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x80, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0x9E,
  0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x81, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0,
  0xE0, 0xE0, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0xFF, 0x07, 0xFE,
  0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x80, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x3C, 0x03, 0xFC,
  0x0F, 0xF8, 0x3E, 0x10, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xCF, 0xC7, 0xFF, 0xCF, 0xEF, 0x9F, 0x07, 0x3C, 0x0E,
  0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1E,
  0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0x1F, 0x1E, 0x0F, 0x1E, 0x07, 0x1C, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0E, 0x0E, 0x1E, 0x0F, 0x7C, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3C,
  0x78, 0x78, 0x38, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xF0, 0x78, 0xFD, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x60, 0x07,
  0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xE1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xC0, 0xF3, 0xC3, 0xE7, 0xFF, 0xC7,
  0xF7, 0x07, 0xCE, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x04, 0x0F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x78, 0xF8, 0x70, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0x38,
  0x00, 0x40, 0x00, 0x03, 0x03, 0xFE, 0x7F, 0xF3, 0xDF, 0x20, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xF0, 0x3C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C,
  0x0F, 0x87, 0x1C, 0x3F, 0xC3, 0x38, 0x7F, 0xC3, 0x30, 0xE1, 0xC3, 0x70,
  0xE1, 0xC3, 0x71, 0xC1, 0x87, 0x71, 0xC3, 0x87, 0x61, 0x83, 0x87, 0xE3,
  0x83, 0x86, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x0C, 0xE3, 0x8F, 0x1C, 0xE1,
  0xFB, 0xF8, 0x60, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1D, 0xC0, 0x07, 0x78, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x38,
  0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xE0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8E, 0x0F, 0x87, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xC0, 0xF0, 0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03,
  0x8E, 0x03, 0xC7, 0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x80, 0x87, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x02,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0x83, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x80,
  0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x1E, 0x00,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x01, 0xE1, 0xC0, 0x7C, 0x38, 0x1F, 0x07, 0x0F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x0F, 0xFF,
  0x83, 0xFB, 0xE0, 0xF8, 0x04, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xF9,
  0xE0, 0x7F, 0x3C, 0x1F, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3,
  0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x80, 0xF0, 0xF8, 0x1C, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x04, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x01,
  0xF0, 0x70, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xE1,
  0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x1D,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xEE, 0x00, 0x3C, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80, 0x70, 0x78, 0x07, 0x03, 0x80,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0xE0, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x0E, 0xE1, 0xFC, 0x07, 0xF8, 0x77, 0x01, 0xDC,
  0x1D, 0xC0, 0xF7, 0x07, 0x70, 0x39, 0xC1, 0xCC, 0x1E, 0xF0, 0xF3, 0x87,
  0x3C, 0x38, 0xE3, 0xCE, 0x0E, 0x38, 0xE3, 0x83, 0x8E, 0x78, 0xE0, 0xE3,
  0x9C, 0x78, 0x78, 0xEF, 0x1C, 0x1C, 0x3B, 0x87, 0x07, 0x0F, 0xE1, 0xC1,
  0xC3, 0xF0, 0xF0, 0x70, 0xFC, 0x3C, 0x3C, 0x3E, 0x0E, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xE0, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xE0, 0xFC, 0x03,
  0x83, 0xF0, 0x1E, 0x0F, 0xC0, 0x78, 0x3F, 0x01, 0xC1, 0xFE, 0x07, 0x07,
  0x38, 0x1C, 0x1C, 0xE0, 0xF0, 0x73, 0xC3, 0x81, 0xC7, 0x0E, 0x0F, 0x1C,
  0x38, 0x38, 0x70, 0xE0, 0xE0, 0xE7, 0x83, 0x83, 0x9C, 0x0E, 0x0E, 0x70,
  0x78, 0x3D, 0xC1, 0xC0, 0x77, 0x07, 0x01, 0xFC, 0x1C, 0x07, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x0E, 0x00, 0xF8, 0x38, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xF7, 0xE0, 0xF0, 0x3C, 0x3C, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF0,
  0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xE1, 0xF0, 0xE0, 0x78, 0x70, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x03, 0xC7, 0x87, 0xC3,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xF7, 0xE0, 0xF0,
  0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x77, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07,
  0xCF, 0x00, 0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xF0,
  0xE0, 0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0E, 0x07,
  0x87, 0x07, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xE3, 0xC0, 0x70,
  0xE0, 0x78, 0x70, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF0, 0x10, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC6, 0x03, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x03, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x83, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0xF0, 0xE0, 0x78, 0x70,
  0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x8F, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x01,
  0xFE, 0x03, 0xC0, 0x3B, 0xC0, 0x78, 0x0F, 0x78, 0x1F, 0x01, 0xCF, 0x03,
  0xE0, 0x79, 0xE0, 0xFC, 0x0E, 0x3C, 0x1F, 0x83, 0xC7, 0x83, 0xF0, 0x78,
  0xF0, 0xEE, 0x0E, 0x1E, 0x1D, 0xC3, 0xC3, 0xC7, 0x38, 0x70, 0x78, 0xE3,
  0x1E, 0x07, 0x38, 0x63, 0x80, 0xE7, 0x0C, 0x70, 0x1C, 0xE1, 0x9E, 0x03,
  0xB8, 0x33, 0x80, 0x77, 0x06, 0xF0, 0x0F, 0xC0, 0xDC, 0x01, 0xF8, 0x1B,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80,
  0x70, 0x38, 0x03, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x03, 0x9E,
  0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80,
  0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC3, 0x80, 0x3C, 0x1C, 0x01, 0xC0,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x1C, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0xF0,
  0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x38,
  0xE0, 0x39, 0xE0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xE3, 0x8E, 0x38,
  0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x1C, 0x71, 0xC7, 0x03, 0xF8, 0x1F, 0x81, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x81, 0xFC,
  0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0x70, 0x06, 0x70, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38,
  0x1C, 0x70, 0x0C, 0x70, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1,
  0xC7, 0x8E, 0x1C, 0x01, 0x80, 0x07, 0xE7, 0x0F, 0xF7, 0x1F, 0x3F, 0x1E,
  0x1F, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xF0,
  0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0x7F,
  0xF8, 0x7F, 0xB8, 0x3F, 0x38, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x30, 0x1E, 0xFC, 0x1D,
  0xFE, 0x1F, 0x9E, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38,
  0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0,
  0x3C, 0xF8, 0x78, 0xFF, 0xF8, 0xEF, 0xF0, 0xC7, 0xC0, 0x00, 0xE0, 0x1F,
  0xF0, 0xFF, 0x87, 0xC6, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x08, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x06,
  0x1C, 0x07, 0xE7, 0x03, 0xFD, 0xC1, 0xF3, 0xF0, 0x78, 0x7C, 0x3C, 0x0E,
  0x0E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x0F,
  0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x81, 0xFF,
  0xE0, 0x7F, 0xB8, 0x0F, 0xCE, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7,
  0x8F, 0x1C, 0x1C, 0xF0, 0x73, 0x83, 0xDE, 0x1E, 0x77, 0xF9, 0xFF, 0x8F,
  0xF8, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x04, 0x7E, 0xF0,
  0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0xFD, 0xC1, 0xFE, 0xE1, 0xF3, 0xF0, 0xF0, 0xF8, 0xF0, 0x38, 0x70, 0x1C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0x8F, 0x01, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F, 0xEE, 0x07,
  0xEF, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE1, 0x01, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x1C, 0x1E, 0xFC,
  0x3B, 0xFC, 0x7E, 0x78, 0xF0, 0x73, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C,
  0x0F, 0x38, 0x1E, 0xF0, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x03, 0xDE, 0x07,
  0xBC, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF0, 0x07, 0x0F, 0x0F, 0x06,
  0x00, 0x00, 0x00, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x1C, 0x1E, 0x1C,
  0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0xC0, 0x7D, 0xC0, 0x71, 0xE0, 0x71, 0xE0, 0xF0, 0xE0, 0xF0,
  0xF0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x00, 0x00, 0x30, 0x08, 0x1C, 0xFC, 0x7E, 0x1D, 0xFE, 0xFF, 0x1F, 0x9F,
  0xCF, 0x1E, 0x0F, 0x87, 0x3E, 0x0F, 0x07, 0x3C, 0x1E, 0x07, 0x3C, 0x1E,
  0x07, 0x38, 0x1E, 0x0F, 0x38, 0x1C, 0x0F, 0x78, 0x1C, 0x0E, 0x78, 0x3C,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x38, 0x1E, 0xF0, 0x38, 0x1E, 0xF0, 0x38,
  0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0x70, 0x3C, 0x00, 0x1C,
  0x0E, 0x7E, 0x0E, 0xFF, 0x0F, 0xCF, 0x0F, 0x87, 0x1F, 0x07, 0x1E, 0x07,
  0x1E, 0x07, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0xF0, 0x3C,
  0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE3, 0xC1, 0xE7, 0x81, 0xDE,
  0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xDE, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x00, 0x0C, 0x01, 0xCF, 0xC0, 0x77, 0xF8, 0x1F, 0x9E, 0x07, 0x83, 0xC3,
  0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xE1, 0xE0,
  0x38, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC3, 0xC0, 0xF0, 0xF8, 0x78,
  0x3F, 0xFE, 0x0E, 0xFF, 0x03, 0x9F, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xF7, 0x0F, 0xF7, 0x1F, 0x3F, 0x1E, 0x1F, 0x3C,
  0x1E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0x7F, 0xF8, 0x7F,
  0xB8, 0x3F, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0xE7, 0x87, 0x7C,
  0x3F, 0xE1, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x3C, 0x73, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0x90, 0x3C, 0xF7, 0xE7, 0xFE, 0x3F, 0xE0, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0xFF, 0xFF, 0xE3, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF8, 0xFE, 0x1F,
  0x80, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0x70, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xF8, 0x7F, 0xB8, 0x3E,
  0x38, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCF,
  0x0E, 0x3C, 0x78, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x1F,
  0xC1, 0xF0, 0x7B, 0x83, 0xE0, 0xE7, 0x07, 0xC3, 0xCE, 0x1F, 0x87, 0x1C,
  0x3F, 0x0E, 0x38, 0xEE, 0x3C, 0x71, 0xDC, 0x70, 0xE7, 0x39, 0xE1, 0xCE,
  0x73, 0x83, 0x98, 0xEF, 0x07, 0x71, 0xDC, 0x0E, 0xE3, 0xB8, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0x7C,
  0x00, 0x0E, 0x07, 0x87, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x7B, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0x70, 0x70,
  0x38, 0x78, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x1E, 0x07, 0x01, 0xC0,
  0x78, 0x3C, 0x07, 0x83, 0x80, 0x78, 0x78, 0x03, 0x87, 0x00, 0x38, 0xF0,
  0x03, 0x8E, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xB8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xF8, 0x07, 0x00, 0x3F, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xE0,
  0x3F, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x7E,
  0x03, 0xFF, 0x9F, 0xBF, 0xFC, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 24, 9, 0, -24 },
  { 28, 11, 9, 13, 3, -24 },
  { 41, 19, 24, 19, 1, -24 },
  { 98, 16, 28, 17, 1, -26 },
  { 154, 22, 25, 26, 2, -25 },
  { 223, 19, 25, 20, 1, -25 },
  { 283, 4, 9, 8, 4, -24 },
  { 288, 11, 29, 10, 1, -24 },
  { 328, 12, 29, 10, -3, -24 },
  { 372, 14, 15, 17, 3, -26 },
  { 399, 15, 16, 18, 2, -20 },
  { 429, 7, 8, 8, -2, -4 },
  { 436, 8, 3, 10, 1, -11 },
  { 439, 5, 4, 8, 0, -4 },
  { 442, 17, 24, 12, -2, -24 },
  { 493, 16, 25, 17, 1, -25 },
  { 543, 10, 24, 17, 4, -24 },
  { 573, 17, 25, 17, -1, -25 },
  { 627, 16, 25, 17, 0, -25 },
  { 677, 17, 24, 17, 0, -24 },
  { 728, 16, 24, 17, 1, -24 },
  { 776, 15, 25, 17, 2, -25 },
  { 823, 16, 24, 17, 2, -24 },
  { 871, 16, 25, 17, 1, -25 },
  { 921, 15, 25, 17, 1, -25 },
  { 968, 8, 19, 8, 0, -19 },
  { 987, 10, 23, 8, -2, -19 },
  { 1016, 15, 16, 18, 2, -20 },
  { 1046, 15, 10, 18, 2, -17 },
  { 1065, 15, 16, 18, 2, -20 },
  { 1095, 12, 25, 13, 2, -25 },
  { 1133, 24, 27, 26, 1, -24 },
  { 1214, 18, 24, 18, -2, -24 },
  { 1268, 17, 24, 19, 1, -24 },
  { 1319, 18, 25, 18, 2, -25 },
  { 1376, 19, 24, 20, 1, -24 },
  { 1433, 16, 24, 16, 1, -24 },
  { 1481, 16, 24, 15, 1, -24 },
  { 1529, 19, 25, 21, 2, -25 },
  { 1589, 20, 24, 21, 1, -24 },
  { 1649, 14, 24, 11, -1, -24 },
  { 1691, 15, 31, 9, -5, -24 },
  { 1750, 20, 24, 18, 1, -24 },
  { 1810, 12, 24, 15, 1, -24 },
  { 1846, 26, 24, 27, 1, -24 },
  { 1924, 22, 24, 22, 1, -24 },
  { 1990, 19, 25, 22, 2, -25 },
  { 2050, 17, 24, 18, 1, -24 },
  { 2101, 19, 31, 22, 2, -25 },
  { 2175, 17, 24, 18, 1, -24 },
  { 2226, 17, 25, 16, 0, -25 },
  { 2280, 15, 24, 15, 3, -24 },
  { 2325, 19, 24, 21, 2, -24 },
  { 2382, 17, 24, 17, 3, -24 },
  { 2433, 27, 24, 27, 3, -24 },
  { 2514, 21, 24, 17, -2, -24 },
  { 2577, 16, 24, 16, 3, -24 },
  { 2625, 19, 24, 16, -1, -24 },
  { 2682, 14, 29, 10, -1, -24 },
  { 2733, 6, 24, 12, 4, -24 },
  { 2751, 13, 29, 10, -2, -24 },
  { 2799, 16, 14, 17, 1, -24 },
  { 2827, 13, 2, 12, -3, 3 },
  { 2831, 6, 5, 10, 5, -26 },
  { 2835, 16, 19, 18, 1, -19 },
  { 2873, 16, 26, 18, 1, -26 },
  { 2925, 14, 19, 14, 1, -19 },
  { 2959, 18, 26, 18, 1, -26 },
  { 3018, 14, 19, 16, 1, -19 },
  { 3052, 18, 34, 10, -4, -26 },
  { 3129, 17, 27, 18, 0, -19 },
  { 3187, 15, 26, 18, 1, -26 },
  { 3236, 8, 25, 8, 1, -25 },
  { 3261, 13, 33, 8, -4, -25 },
  { 3315, 16, 26, 16, 1, -26 },
  { 3367, 9, 26, 8, 0, -26 },
  { 3397, 24, 19, 27, 1, -19 },
  { 3454, 16, 19, 18, 0, -19 },
  { 3492, 15, 19, 17, 1, -19 },
  { 3528, 18, 27, 18, -1, -19 },
  { 3589, 16, 27, 18, 1, -19 },
  { 3643, 13, 19, 12, 1, -19 },
  { 3674, 13, 19, 14, 0, -19 },
  { 3705, 10, 22, 11, 2, -22 },
  { 3733, 16, 18, 18, 1, -18 },
  { 3769, 14, 18, 15, 2, -18 },
  { 3801, 23, 18, 23, 2, -18 },
  { 3853, 17, 18, 15, -1, -18 },
  { 3892, 20, 26, 15, -3, -18 },
  { 3957, 15, 18, 13, -1, -18 },
  { 3991, 14, 29, 12, 0, -24 },
  { 4042, 3, 34, 16, 7, -26 },
  { 4055, 13, 29, 12, -2, -24 },
  { 4103, 15, 4, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC34PT7B_H_
