#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0x8C, 0x63, 0x10, 0x8C, 0x00, 0x39, 0x80, 0xDE, 0xE5, 0x20,
  0x0C, 0x82, 0x60, 0x91, 0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0x26, 0x09,
  0x06, 0x41, 0x30, 0x04, 0x04, 0x1F, 0x35, 0x28, 0x38, 0x1C, 0x0E, 0x0A,
  0x12, 0xD6, 0xFC, 0x10, 0x30, 0x78, 0xC9, 0x13, 0x26, 0x65, 0x89, 0xA1,
  0x2F, 0xFF, 0x48, 0x59, 0x1B, 0x22, 0x4C, 0x8D, 0x31, 0xE0, 0x0F, 0x06,
  0xC1, 0x30, 0x4C, 0x1E, 0x06, 0x03, 0xCD, 0x92, 0xC7, 0xB0, 0xC6, 0x71,
  0xF6, 0xFA, 0x19, 0x88, 0xC4, 0x63, 0x10, 0x84, 0x21, 0x08, 0x63, 0x00,
  0x18, 0xC2, 0x10, 0x84, 0x23, 0x18, 0x8C, 0x66, 0x22, 0x00, 0x18, 0x23,
  0x43, 0xF7, 0x1B, 0x12, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08,
  0x36, 0x6C, 0xF8, 0xF0, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x18, 0x00, 0x3E, 0x6D, 0x8A, 0x1C, 0x38, 0xF1,
  0xC3, 0x85, 0x1B, 0x63, 0x80, 0x1B, 0xFF, 0x21, 0x18, 0xC6, 0x23, 0x18,
  0xC0, 0x1F, 0x33, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE,
  0xFE, 0x3F, 0x33, 0x03, 0x03, 0x06, 0x1C, 0x2E, 0x06, 0x02, 0x06, 0x8E,
  0xFC, 0x03, 0x07, 0x0F, 0x0A, 0x12, 0x36, 0x66, 0x46, 0xFF, 0x04, 0x0C,
  0x0C, 0x1F, 0x10, 0x30, 0x30, 0x28, 0x7E, 0x06, 0x03, 0x02, 0x06, 0xCE,
  0xFC, 0x1F, 0x30, 0x60, 0x60, 0xD8, 0xFC, 0xC6, 0xC6, 0x86, 0xC4, 0xCC,
  0x78, 0x7F, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x1F, 0x33, 0x31, 0x31, 0x37, 0x1C, 0x36, 0x66, 0xC3, 0xC2, 0x66,
  0x7C, 0x1E, 0x33, 0x23, 0x63, 0x63, 0x63, 0x3F, 0x12, 0x06, 0x06, 0x9C,
  0xF8, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x62,
  0x30, 0x02, 0x1C, 0xE7, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00, 0x07, 0xF0,
  0x81, 0xC0, 0xE0, 0x30, 0xE7, 0x38, 0x40, 0x7D, 0x30, 0xC3, 0x18, 0xC6,
  0x10, 0x00, 0x0C, 0x30, 0x0F, 0xC1, 0x86, 0x20, 0x24, 0x7B, 0xCD, 0x39,
  0x93, 0x91, 0x29, 0x32, 0x93, 0x69, 0xDC, 0x80, 0x04, 0x00, 0x7F, 0x00,
  0x80, 0x03, 0x03, 0x81, 0x41, 0xA0, 0x90, 0xC8, 0x46, 0x7F, 0x31, 0xB0,
  0xD8, 0x78, 0x30, 0x1F, 0x08, 0xCC, 0x66, 0x33, 0x19, 0xF0, 0x8C, 0xC6,
  0x61, 0x31, 0x93, 0xDF, 0x80, 0x1F, 0x9C, 0x9C, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x19, 0x0F, 0x80, 0x1F, 0x04, 0xE3, 0x0C, 0xC3,
  0x30, 0xCC, 0x32, 0x0D, 0x86, 0x61, 0x98, 0xC7, 0xE3, 0xF0, 0x1F, 0x88,
  0x0C, 0x06, 0x03, 0x01, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0x1F, 0x80,
  0x1F, 0x88, 0x0C, 0x06, 0x03, 0x01, 0xF0, 0xF8, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x00, 0x1F, 0x9C, 0x5C, 0x0C, 0x0C, 0x06, 0x3F, 0x1F, 0x82, 0xC3,
  0x61, 0x99, 0xC7, 0xC0, 0x18, 0x62, 0x08, 0xC3, 0x18, 0x63, 0x0C, 0x7F,
  0x08, 0x23, 0x0C, 0x61, 0x8C, 0x31, 0x04, 0x61, 0x80, 0x1E, 0x18, 0x30,
  0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC7, 0xC0, 0x03, 0x02, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0xF0, 0x18,
  0xC4, 0x63, 0x30, 0xD8, 0x3C, 0x0B, 0x03, 0xC1, 0x90, 0x66, 0x19, 0x84,
  0x23, 0x0C, 0x18, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x87, 0xFF, 0x18,
  0x1C, 0x60, 0xE3, 0xC3, 0x8F, 0x1E, 0x3C, 0x58, 0xB3, 0x42, 0xCB, 0x1B,
  0x6C, 0x65, 0x31, 0x9C, 0x84, 0x62, 0x31, 0x98, 0x18, 0x23, 0x0C, 0xF1,
  0x9E, 0x23, 0x44, 0x4D, 0x89, 0xB3, 0x36, 0x62, 0x8C, 0x71, 0x0E, 0x60,
  0xC0, 0x1F, 0x0C, 0x66, 0x09, 0x83, 0xC0, 0xF0, 0x2C, 0x1B, 0x06, 0xC1,
  0xB0, 0xC6, 0x61, 0xF0, 0x1F, 0x09, 0xCC, 0x66, 0x33, 0x19, 0x98, 0xF8,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x00, 0x1F, 0x0C, 0x66, 0x09, 0x83, 0xC0,
  0xF0, 0x2C, 0x1B, 0x06, 0xC1, 0xB0, 0xC6, 0x61, 0xF0, 0x0C, 0x01, 0x80,
  0x60, 0x1F, 0x09, 0xCC, 0x66, 0x33, 0x19, 0x38, 0xF8, 0xC8, 0x66, 0x33,
  0x10, 0x98, 0x60, 0x1F, 0x31, 0x30, 0x20, 0x30, 0x38, 0x0C, 0x06, 0x06,
  0x06, 0xCC, 0xF8, 0x7F, 0x98, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x30, 0xD8, 0x26, 0x19, 0x86, 0x61, 0x90, 0x4C, 0x33,
  0x0C, 0xC3, 0x30, 0x8E, 0xE1, 0xF0, 0x83, 0x82, 0x86, 0x84, 0x8C, 0xC8,
  0xD8, 0xD0, 0xF0, 0xE0, 0xE0, 0xC0, 0x86, 0x1C, 0x31, 0xA3, 0x8D, 0x14,
  0x49, 0xA6, 0x4D, 0x32, 0x4B, 0x16, 0x58, 0xA2, 0x87, 0x1C, 0x30, 0xC1,
  0x86, 0x00, 0x18, 0xE3, 0x18, 0x26, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x12, 0x06, 0x61, 0x8C, 0x61, 0x80, 0x87, 0xC6, 0xCC, 0xD8, 0xD8,
  0x70, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x3F, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x3F, 0x9F, 0x80, 0x1C, 0x43, 0x0C,
  0x20, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x8E, 0x00, 0x9B, 0x6C, 0x92,
  0x6D, 0xB0, 0x1C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x33,
  0x8E, 0x00, 0x0C, 0x0C, 0x14, 0x36, 0x22, 0x63, 0xC1, 0x7F, 0xFC, 0xCC,
  0x80, 0x3B, 0x66, 0xC6, 0xC6, 0xC6, 0x86, 0x8C, 0xDC, 0xFC, 0x18, 0x10,
  0x30, 0x30, 0x3F, 0x33, 0x31, 0x61, 0x63, 0x63, 0x63, 0x66, 0xDC, 0x3D,
  0x9C, 0x30, 0xC2, 0x08, 0x32, 0x78, 0x01, 0x80, 0x80, 0xC0, 0x63, 0xB3,
  0x33, 0x19, 0x8C, 0xC6, 0x43, 0x23, 0x1B, 0x8F, 0xC0, 0x3C, 0xCF, 0x1E,
  0x6F, 0x90, 0x20, 0x64, 0x78, 0x03, 0x83, 0x41, 0x00, 0x81, 0xF0, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC1, 0x60, 0xE0,
  0x00, 0x1D, 0x99, 0x98, 0xCC, 0x66, 0x32, 0x19, 0x18, 0xDC, 0x7E, 0x03,
  0x01, 0x11, 0x8F, 0x80, 0x18, 0x10, 0x30, 0x30, 0x3F, 0x33, 0x33, 0x63,
  0x63, 0x63, 0x42, 0x46, 0xC6, 0x10, 0xC0, 0x03, 0x18, 0x8C, 0x63, 0x10,
  0x8C, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x40,
  0x83, 0x06, 0x0C, 0x70, 0xE0, 0x18, 0x08, 0x0C, 0x06, 0x13, 0x31, 0xB0,
  0xB0, 0xF0, 0x78, 0x36, 0x13, 0x08, 0x8C, 0x60, 0x18, 0x8C, 0x63, 0x18,
  0x8C, 0x63, 0x10, 0x8C, 0x00, 0x3F, 0x71, 0x9C, 0xCC, 0xC6, 0xC6, 0x26,
  0x31, 0x31, 0x19, 0x18, 0xC8, 0xC6, 0xC6, 0x20, 0x3F, 0x3B, 0x33, 0x63,
  0x63, 0x63, 0x62, 0x46, 0xC6, 0x3C, 0xCF, 0x1E, 0x38, 0x70, 0xE1, 0x66,
  0x78, 0x1F, 0x8C, 0xC6, 0x26, 0x13, 0x19, 0x8C, 0xC6, 0x66, 0x6E, 0x30,
  0x18, 0x08, 0x0C, 0x00, 0x3F, 0x66, 0xC6, 0xC6, 0xC6, 0x86, 0x8C, 0xDC,
  0xFC, 0x0C, 0x08, 0x08, 0x18, 0x3E, 0x70, 0xC3, 0x06, 0x0C, 0x10, 0x20,
  0xC0, 0x3E, 0xC9, 0x83, 0x83, 0x81, 0x83, 0x4E, 0xF8, 0x23, 0x3E, 0xC4,
  0x63, 0x18, 0xC6, 0x38, 0x63, 0x42, 0x46, 0xC6, 0xC6, 0xC4, 0x8C, 0xDC,
  0xFC, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x3C, 0x30, 0x60, 0xCE, 0x79, 0xCF,
  0x7B, 0x6B, 0x6D, 0x69, 0xEF, 0x39, 0xC7, 0x38, 0xC6, 0x00, 0x31, 0x8D,
  0x87, 0x81, 0x80, 0xC0, 0xE0, 0xD8, 0xCC, 0xE6, 0x00, 0x31, 0x98, 0x8C,
  0xC6, 0x43, 0x60, 0xA0, 0x70, 0x30, 0x18, 0x08, 0x0C, 0x1C, 0x0C, 0x00,
  0x3E, 0x98, 0x30, 0xC3, 0x04, 0x18, 0x60, 0xF8, 0x0E, 0x30, 0x60, 0xC1,
  0x02, 0x1C, 0x70, 0x20, 0x40, 0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF,
  0x80, 0x18, 0x18, 0x30, 0x40, 0x81, 0x03, 0x07, 0x18, 0x20, 0xC1, 0x83,
  0x1C, 0x30, 0x00, 0xF3, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 7, 2, -12 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 8, 14, 8, 0, -13 },
  { 41, 11, 12, 13, 1, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 2, 4, 4, 2, -12 },
  { 74, 5, 15, 5, 1, -12 },
  { 84, 5, 15, 5, -1, -12 },
  { 94, 7, 7, 8, 2, -13 },
  { 101, 7, 8, 9, 1, -10 },
  { 108, 4, 4, 4, -1, -2 },
  { 110, 5, 1, 5, 0, -5 },
  { 111, 2, 2, 4, 0, -2 },
  { 112, 9, 12, 6, -1, -12 },
  { 126, 7, 12, 8, 1, -12 },
  { 137, 5, 12, 8, 2, -12 },
  { 145, 8, 12, 8, 0, -12 },
  { 157, 8, 12, 8, 0, -12 },
  { 169, 8, 12, 8, 0, -12 },
  { 181, 8, 12, 8, 0, -12 },
  { 193, 8, 12, 8, 1, -12 },
  { 205, 8, 12, 8, 1, -12 },
  { 217, 8, 12, 8, 0, -12 },
  { 229, 8, 12, 8, 0, -12 },
  { 241, 4, 9, 4, 0, -9 },
  { 246, 5, 11, 4, -1, -9 },
  { 253, 7, 8, 9, 1, -10 },
  { 260, 7, 4, 9, 1, -8 },
  { 264, 7, 8, 9, 1, -10 },
  { 271, 6, 12, 7, 1, -12 },
  { 280, 12, 14, 13, 1, -12 },
  { 301, 9, 12, 9, -1, -12 },
  { 315, 9, 12, 9, 0, -12 },
  { 329, 9, 12, 9, 1, -12 },
  { 343, 10, 12, 10, 0, -12 },
  { 358, 9, 12, 8, 0, -12 },
  { 372, 9, 12, 8, 0, -12 },
  { 386, 9, 12, 10, 1, -12 },
  { 400, 11, 12, 10, 0, -12 },
  { 417, 7, 12, 5, -1, -12 },
  { 428, 8, 15, 4, -3, -12 },
  { 443, 10, 12, 9, 0, -12 },
  { 458, 6, 12, 7, 0, -12 },
  { 467, 14, 12, 13, 0, -12 },
  { 488, 11, 12, 11, 0, -12 },
  { 505, 10, 12, 11, 1, -12 },
  { 520, 9, 12, 9, 0, -12 },
  { 534, 10, 15, 11, 1, -12 },
  { 553, 9, 12, 9, 0, -12 },
  { 567, 8, 12, 8, 0, -12 },
  { 579, 8, 12, 8, 1, -12 },
  { 591, 10, 12, 10, 1, -12 },
  { 606, 8, 12, 9, 2, -12 },
  { 618, 13, 12, 14, 2, -12 },
  { 638, 11, 12, 8, -1, -12 },
  { 655, 8, 12, 8, 2, -12 },
  { 667, 9, 12, 8, 0, -12 },
  { 681, 6, 15, 5, 0, -12 },
  { 693, 3, 12, 6, 2, -12 },
  { 698, 6, 15, 5, -1, -12 },
  { 710, 8, 7, 9, 0, -12 },
  { 717, 7, 2, 6, -2, 1 },
  { 719, 3, 3, 5, 2, -13 },
  { 721, 8, 9, 9, 1, -9 },
  { 730, 8, 13, 9, 0, -13 },
  { 743, 6, 9, 7, 1, -9 },
  { 750, 9, 13, 9, 1, -13 },
  { 765, 7, 9, 8, 1, -9 },
  { 773, 9, 17, 5, -2, -13 },
  { 793, 9, 13, 9, 0, -9 },
  { 808, 8, 13, 9, 0, -13 },
  { 821, 5, 13, 4, 0, -13 },
  { 830, 7, 17, 4, -2, -13 },
  { 845, 9, 13, 8, 0, -13 },
  { 860, 5, 13, 4, 0, -13 },
  { 869, 13, 9, 13, 0, -9 },
  { 884, 8, 9, 9, 0, -9 },
  { 893, 7, 9, 9, 1, -9 },
  { 901, 9, 13, 9, -1, -9 },
  { 916, 8, 13, 9, 1, -9 },
  { 929, 7, 9, 6, 0, -9 },
  { 937, 7, 9, 7, 0, -9 },
  { 945, 5, 11, 5, 1, -11 },
  { 952, 8, 9, 9, 1, -9 },
  { 961, 7, 9, 7, 1, -9 },
  { 969, 11, 9, 12, 1, -9 },
  { 982, 9, 9, 8, -1, -9 },
  { 993, 9, 13, 7, -1, -9 },
  { 1008, 7, 9, 7, 0, -9 },
  { 1016, 7, 15, 6, 0, -12 },
  { 1030, 1, 17, 8, 4, -13 },
  { 1033, 7, 15, 6, -1, -12 },
  { 1047, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC17PT7B_H_
