#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F,
  0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x9E, 0x3F, 0x00, 0x7F,
  0x87, 0x81, 0xC0, 0x1F, 0xC1, 0xE0, 0x20, 0x07, 0xF0, 0xF0, 0x00, 0x01,
  0xF8, 0x3C, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x00, 0x7F, 0x1E, 0x00,
  0x00, 0x1F, 0xE7, 0x80, 0x00, 0x07, 0xFD, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x79, 0xFE, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x00, 0x0F, 0x0F, 0xE0,
  0x00, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x00, 0x3C, 0x1F,
  0x80, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0x20, 0x01, 0xE0,
  0xFE, 0x06, 0x00, 0x78, 0x7F, 0x01, 0xF0, 0x3C, 0x3F, 0xC0, 0x7F, 0xCF,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x00, 0x3E,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE1, 0xF8, 0x3F, 0x83, 0xE0,
  0x3F, 0x0F, 0xC3, 0xFF, 0x8F, 0x80, 0xFC, 0x3F, 0x1F, 0xFF, 0x3E, 0x07,
  0xE1, 0xF8, 0xFF, 0xFC, 0xFC, 0x1F, 0x8F, 0xC7, 0xFF, 0xFB, 0xF0, 0xFC,
  0x3F, 0x1F, 0xC7, 0xEF, 0xFF, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0xFF, 0x8F,
  0xC3, 0xF0, 0x3E, 0x7F, 0xFC, 0x3F, 0x1F, 0x80, 0xFC, 0xFF, 0xE1, 0xF8,
  0x7E, 0x03, 0xF1, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0xFF, 0x00, 0xFE, 0x0F, 0xF8,
  0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x7F,
  0x80, 0x1F, 0xE7, 0xF0, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7D, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x1F, 0x80, 0x06,
  0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0xF1,
  0xE0, 0x01, 0xFF, 0xEF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x87, 0xE0, 0x07, 0xF8, 0x3F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x80,
  0x0C, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0x7F, 0x3F, 0xF9, 0xFC, 0x7F, 0x87, 0xF0, 0xFC, 0x3F, 0x83, 0xC0, 0xFE,
  0x06, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x01, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x18,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x08, 0x00,
  0x00, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x08,
  0x00, 0x01, 0xFF, 0x03, 0x00, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x04, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0xF8, 0x01, 0xFE, 0x7F, 0xFE,
  0x00, 0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x1F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x07,
  0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F,
  0xC0, 0x01, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xF9, 0xFC, 0x01,
  0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xC3, 0xF8, 0x00, 0x06, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x07, 0xFE, 0x00, 0xFE,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xF8, 0x38, 0x00, 0xFF, 0x08, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0xE0,
  0x3E, 0x07, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x7E, 0x01, 0xFE, 0x07,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x00,
  0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0x00, 0xF8, 0x03, 0xE7, 0xE0, 0x7E, 0x00, 0x7E, 0x00, 0xF9, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xBF, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xCF, 0xC0, 0xFC, 0x00, 0xFC, 0x01, 0xF3, 0xF0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x03, 0xF8, 0x07, 0xC3,
  0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x7F, 0x81, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0xBF, 0x7E, 0xFF,
  0x03, 0xF0, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC7, 0xFF,
  0xC0, 0x3F, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x18, 0x00,
  0xFF, 0xC0, 0x00, 0x40, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x03, 0xFF, 0x80,
  0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x38, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xCF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xEF,
  0xE0, 0x00, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x1F,
  0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xF9, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x01,
  0xFB, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xC3, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xE0,
  0x07, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x01, 0x00, 0x00, 0x7F,
  0xC0, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xDF, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF9, 0xF8,
  0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC7, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x3F, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0x87, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x7E,
  0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0xE7, 0xE0, 0x03, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xCF, 0xE0,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xC0, 0x0F, 0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF,
  0xFB, 0xF8, 0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8,
  0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFE,
  0x0F, 0xE0, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF,
  0x81, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xF8,
  0xFC, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xE0, 0x07,
  0xF3, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xFC, 0x7F, 0xF0, 0x1F, 0xBF, 0xFF, 0xF8, 0x07, 0xE7,
  0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x3F,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xC0, 0x7F, 0xC0, 0x08,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x40,
  0x7F, 0xC0, 0x1C, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0x80, 0x01,
  0xFF, 0xF1, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFF, 0x7F,
  0x00, 0x1F, 0xFF, 0xFB, 0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xE7,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x7E, 0x00, 0x0F, 0xFF, 0xF3, 0xF0, 0x00,
  0x7F, 0xFF, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xFE, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0xCF, 0xE0, 0x07, 0xFC, 0x7F, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x20, 0x7F, 0x80, 0x07, 0x03, 0xFF, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x81, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x41, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x83, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x07, 0xFF, 0xC3, 0xF0,
  0x01, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xFF,
  0x7E, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xCF, 0xDF, 0x80, 0x0F, 0xFF, 0xFB, 0xF8, 0x00,
  0xFF, 0xFF, 0xBF, 0x80, 0x07, 0xFF, 0xF3, 0xF8, 0x00, 0x3F, 0xFC, 0x3F,
  0x80, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF,
  0x00, 0x3F, 0x3F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x03, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x80,
  0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x08, 0x3F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xCF, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x1F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFF, 0x01, 0xFB, 0xF0, 0xFF, 0x7E,
  0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x0F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xE0, 0x1F,
  0x9F, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xFC, 0x07, 0xEF, 0xE3, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x80, 0x1F, 0xC0,
  0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xC3, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xE1, 0xFF, 0xF0,
  0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x03, 0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x9F,
  0xFF, 0xF8, 0x00, 0xFD, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xDF, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xFF,
  0x00, 0x0F, 0xE1, 0xFF, 0xE0, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xC0, 0x0F, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF,
  0xFB, 0xF8, 0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8,
  0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFE,
  0x0F, 0xE0, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0x81, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF3, 0xF7,
  0xE0, 0x1F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xF9,
  0xFC, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x03, 0xC0,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x83, 0xFC, 0x03, 0xF1, 0xFF, 0x80, 0x7E, 0x7F, 0xF0, 0x1F, 0xCF,
  0xFC, 0x03, 0xF3, 0xFF, 0x80, 0x7E, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x0C,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x0F, 0xF0,
  0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x18, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xCF, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0,
  0x1F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xE0, 0xF8,
  0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x40, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFB, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xEF, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x3F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7C, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xE0,
  0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x00, 0x3F,
  0x3F, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xF8, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x02, 0x3F, 0xFC, 0x00, 0x05, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x80, 0x00, 0xFF, 0xF9, 0x00, 0x00,
  0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 52, 18, 1, -51 },
  { 125, 23, 19, 28, 7, -51 },
  { 180, 40, 51, 40, 1, -51 },
  { 435, 34, 58, 35, 1, -54 },
  { 682, 46, 52, 53, 5, -51 },
  { 981, 40, 52, 43, 1, -51 },
  { 1241, 10, 19, 16, 7, -51 },
  { 1265, 24, 62, 20, 2, -51 },
  { 1451, 23, 62, 21, -5, -51 },
  { 1630, 29, 30, 35, 7, -54 },
  { 1739, 31, 34, 37, 4, -42 },
  { 1871, 14, 17, 17, -3, -8 },
  { 1901, 18, 6, 21, 1, -22 },
  { 1915, 9, 10, 17, 1, -9 },
  { 1927, 35, 51, 26, -3, -51 },
  { 2151, 32, 52, 35, 3, -51 },
  { 2359, 22, 51, 35, 8, -51 },
  { 2500, 35, 51, 35, -1, -51 },
  { 2724, 34, 52, 35, 0, -51 },
  { 2945, 35, 51, 35, 0, -51 },
  { 3169, 34, 52, 35, 1, -51 },
  { 3390, 33, 52, 35, 3, -51 },
  { 3605, 33, 51, 35, 4, -51 },
  { 3816, 33, 52, 35, 2, -51 },
  { 4031, 32, 52, 35, 2, -51 },
  { 4239, 15, 40, 18, 1, -39 },
  { 4314, 20, 48, 18, -4, -39 },
  { 4434, 31, 35, 37, 4, -43 },
  { 4570, 31, 20, 37, 4, -35 },
  { 4648, 31, 35, 37, 4, -43 },
  { 4784, 26, 52, 28, 4, -51 },
  { 4953, 50, 57, 54, 3, -51 },
  { 5310, 37, 51, 37, -4, -51 },
  { 5546, 37, 51, 39, 2, -51 },
  { 5782, 37, 52, 37, 4, -51 },
  { 6023, 39, 51, 43, 2, -51 },
  { 6272, 34, 51, 33, 2, -51 },
  { 6489, 34, 51, 31, 2, -51 },
  { 6706, 40, 52, 44, 4, -51 },
  { 6966, 43, 51, 44, 2, -51 },
  { 7241, 29, 51, 23, -2, -51 },
  { 7426, 31, 65, 19, -11, -51 },
  { 7678, 41, 51, 37, 2, -51 },
  { 7940, 25, 51, 31, 2, -51 },
  { 8100, 54, 51, 56, 2, -51 },
  { 8445, 45, 51, 46, 2, -51 },
  { 8732, 40, 52, 46, 4, -51 },
  { 8992, 36, 51, 37, 2, -51 },
  { 9222, 40, 63, 46, 4, -51 },
  { 9537, 35, 51, 38, 2, -51 },
  { 9761, 35, 52, 33, 0, -51 },
  { 9989, 32, 51, 32, 6, -51 },
  { 10193, 41, 52, 43, 4, -51 },
  { 10460, 37, 51, 36, 6, -51 },
  { 10696, 55, 51, 56, 7, -51 },
  { 11047, 44, 51, 35, -4, -51 },
  { 11328, 34, 51, 33, 6, -51 },
  { 11545, 39, 51, 33, -2, -51 },
  { 11794, 27, 62, 21, -1, -51 },
  { 12004, 14, 51, 26, 7, -51 },
  { 12094, 28, 62, 21, -5, -51 },
  { 12311, 33, 31, 36, 2, -51 },
  { 12439, 27, 5, 26, -6, 6 },
  { 12456, 12, 11, 20, 10, -54 },
  { 12473, 33, 40, 37, 3, -39 },
  { 12638, 34, 55, 37, 1, -54 },
  { 12872, 28, 40, 29, 3, -39 },
  { 13012, 37, 55, 38, 3, -54 },
  { 13267, 29, 40, 33, 3, -39 },
  { 13412, 38, 71, 21, -8, -54 },
  { 13750, 36, 56, 38, 0, -39 },
  { 14002, 33, 54, 37, 1, -54 },
  { 14225, 18, 53, 17, 1, -53 },
  { 14345, 28, 70, 17, -9, -53 },
  { 14590, 35, 54, 33, 1, -54 },
  { 14827, 19, 54, 17, 1, -54 },
  { 14956, 52, 39, 56, 1, -39 },
  { 15210, 33, 39, 37, 1, -39 },
  { 15371, 31, 40, 37, 3, -39 },
  { 15526, 37, 56, 37, -2, -39 },
  { 15785, 33, 56, 37, 3, -39 },
  { 16016, 27, 39, 26, 1, -39 },
  { 16148, 28, 40, 29, 0, -39 },
  { 16288, 22, 48, 23, 3, -47 },
  { 16420, 33, 39, 37, 3, -38 },
  { 16581, 30, 38, 31, 4, -38 },
  { 16724, 47, 38, 48, 4, -38 },
  { 16948, 37, 38, 32, -3, -38 },
  { 17124, 41, 55, 31, -6, -38 },
  { 17406, 31, 38, 28, -2, -38 },
  { 17554, 28, 62, 24, 1, -51 },
  { 17771, 6, 71, 34, 15, -54 },
  { 17825, 27, 62, 24, -3, -51 },
  { 18035, 31, 10, 37, 4, -30 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC71PT7B_H_
