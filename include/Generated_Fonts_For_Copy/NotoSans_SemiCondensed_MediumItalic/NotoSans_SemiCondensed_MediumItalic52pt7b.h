#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x10, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xC1, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x07, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFB, 0x9E, 0x03, 0xF3, 0x83, 0x01, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0xF8, 0x70, 0x00, 0x7C, 0x38, 0x00, 0x3F, 0x38, 0x00, 0x0F, 0x9C, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x37,
  0xF0, 0x00, 0x39, 0xF8, 0x00, 0x1C, 0x7C, 0x00, 0x0E, 0x3E, 0x00, 0x07,
  0x1F, 0x00, 0x07, 0x0F, 0x80, 0x03, 0x87, 0xC3, 0x01, 0xC7, 0xE1, 0xE0,
  0xE7, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x7F, 0xE0, 0x03, 0xE0, 0x3F,
  0xF8, 0x00, 0xF0, 0x1F, 0x1E, 0x00, 0x78, 0x07, 0x87, 0xC0, 0x3E, 0x03,
  0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x3E,
  0x00, 0x78, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x87, 0x80, 0x0F, 0x83, 0xE3,
  0xE0, 0x03, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3C, 0x78, 0xFF, 0x3E, 0x1F,
  0x3E, 0x7F, 0xEF, 0x87, 0x8F, 0x3F, 0xF9, 0xE3, 0xE7, 0x8F, 0x1F, 0x7F,
  0xF3, 0xE7, 0x83, 0xCF, 0xF8, 0xF1, 0xE0, 0xF3, 0xFC, 0x78, 0xF0, 0x3C,
  0x3C, 0x3E, 0x3C, 0x0F, 0x00, 0x0F, 0x1F, 0x03, 0xC0, 0x07, 0x87, 0xC0,
  0xF0, 0x03, 0xE1, 0xE0, 0x7C, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0x78, 0x1E,
  0x07, 0x80, 0x3E, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0xF8, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x78,
  0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x7F, 0xF0, 0x0F, 0x00, 0x0F, 0xF8, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03,
  0xEF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0x8F, 0xEF, 0xC0, 0xFC, 0x7E, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0x7E, 0x7E,
  0x07, 0xE3, 0xE3, 0xE0, 0x3F, 0x3F, 0x3F, 0x00, 0xFD, 0xF1, 0xF0, 0x03,
  0xFF, 0x0F, 0x80, 0x1F, 0xF8, 0x7C, 0x00, 0x7F, 0x83, 0xE0, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x01, 0xFF, 0xF0, 0xFC, 0x07, 0xFE,
  0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x20, 0x1E, 0x01, 0xC0,
  0xE0, 0x0F, 0x87, 0x00, 0xFF, 0x78, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xF3,
  0x80, 0x1F, 0x1E, 0x03, 0xF8, 0xF0, 0x0F, 0x87, 0xC0, 0x38, 0x1F, 0x00,
  0x80, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC3, 0xF0, 0xF8,
  0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0,
  0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xFF,
  0xDF, 0xBE, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x3F,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xBE, 0x7F, 0x7E, 0xFE, 0x7C, 0x7C, 0x7C,
  0x30, 0x7C, 0x20, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0x07, 0xF0, 0x0F, 0x00, 0xFC, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0x81, 0xFC, 0x03, 0x00, 0x7E, 0x01, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0xC0, 0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xBE, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0x00, 0x0F, 0xE0,
  0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0x00, 0x3E, 0x3F, 0xC0, 0x3E, 0x7F, 0xF0, 0x3E, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC1, 0xF8, 0x7F, 0x00, 0xF8, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7F,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x7C, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0xF8, 0x1F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x60, 0x00,
  0x00, 0x08, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3C, 0x1F, 0xC4, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x0F, 0xF0, 0x3C, 0x1E, 0x01, 0xFF, 0xE1, 0xE1, 0xF0, 0x3F, 0xFE,
  0x07, 0x8F, 0x03, 0xF1, 0xF0, 0x3C, 0xF8, 0x1E, 0x07, 0x81, 0xE7, 0x81,
  0xE0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x1E, 0x07,
  0x9E, 0x0F, 0x80, 0xF0, 0x3C, 0xF0, 0x78, 0x0F, 0x81, 0xE7, 0x83, 0xC0,
  0x78, 0x0F, 0x78, 0x3E, 0x03, 0xC0, 0x7B, 0xC1, 0xE0, 0x1E, 0x07, 0x9E,
  0x0F, 0x01, 0xF0, 0x3C, 0xF0, 0x78, 0x0F, 0x03, 0xC7, 0x83, 0xC0, 0xF8,
  0x1E, 0x3C, 0x1F, 0x0F, 0xC1, 0xE1, 0xE0, 0xF8, 0xFF, 0x1F, 0x0F, 0x03,
  0xFF, 0x7F, 0xF0, 0x7C, 0x1F, 0xF1, 0xFF, 0x01, 0xE0, 0x3F, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x3F, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x03,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0x00, 0xFE,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x10, 0x07, 0xF8, 0x3E, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xF0,
  0x07, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF8, 0x1F,
  0x00, 0x3F, 0x80, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xF8, 0x0F, 0xF0, 0x01, 0x80, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x7F, 0xF9, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x1F,
  0xFC, 0x7E, 0x00, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0x1F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0x80, 0x3F, 0x01, 0xFF, 0x07, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x1F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xBF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x1F, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x0F, 0x87, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x07, 0xBE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xEF,
  0x00, 0x0F, 0x7C, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x03, 0xCF, 0x00, 0x1E,
  0x7C, 0x07, 0xCF, 0x00, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0x3C, 0xF8, 0x07,
  0xCF, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x78, 0xF8, 0x07, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF1, 0xF8, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x1F, 0x07,
  0x83, 0xC1, 0xF0, 0x1F, 0x07, 0x87, 0xC3, 0xF0, 0x1F, 0x07, 0x87, 0x83,
  0xE0, 0x1F, 0x07, 0x8F, 0x83, 0xE0, 0x1F, 0x07, 0x8F, 0x03, 0xE0, 0x3E,
  0x07, 0x9F, 0x03, 0xE0, 0x3E, 0x07, 0x9E, 0x07, 0xE0, 0x3E, 0x07, 0xFE,
  0x07, 0xC0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0x3C, 0x07, 0xFC, 0x07, 0xC0,
  0x7C, 0x07, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x07, 0xC0, 0x7F, 0x80, 0x03, 0xE0, 0x3F, 0xC0, 0x01, 0xF0, 0x1F,
  0xE0, 0x01, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFC, 0x00, 0x7C, 0x07,
  0xFE, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x1F, 0x01, 0xF7, 0xC0, 0x1F, 0x00,
  0xFB, 0xE0, 0x0F, 0x80, 0x79, 0xF0, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE0,
  0x3E, 0x3E, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F, 0x8F, 0xC0, 0xF8,
  0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x3F,
  0x01, 0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0xF9,
  0xF0, 0x0F, 0x80, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x7C, 0x07, 0xC0, 0x0F,
  0xBE, 0x03, 0xE0, 0x07, 0xDE, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x3F, 0xE0, 0x3E, 0x00,
  0x0F, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x03, 0xF8, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x81, 0xF8,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF0,
  0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0xFE, 0x07, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xE0, 0xF8, 0x0F, 0xC0, 0x0C, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0x00,
  0x07, 0xF0, 0xE0, 0x07, 0xF0, 0x7E, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x0F, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xDE, 0x00,
  0xF8, 0x7C, 0x01, 0xEF, 0x00, 0xFC, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x1F,
  0x00, 0xF3, 0xC0, 0x7E, 0x0F, 0x80, 0xF9, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x3C, 0x0F,
  0x80, 0xF8, 0x1E, 0x1E, 0x0F, 0xC0, 0x7C, 0x1F, 0x0F, 0x07, 0xC0, 0x3E,
  0x0F, 0x07, 0x83, 0xE0, 0x1F, 0x0F, 0x83, 0xC3, 0xE0, 0x0F, 0x87, 0xC1,
  0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x78, 0xF8,
  0x01, 0xF1, 0xE0, 0x3C, 0x7C, 0x00, 0xF9, 0xF0, 0x1E, 0x7C, 0x00, 0x7C,
  0xF0, 0x0F, 0x3E, 0x00, 0x3E, 0xF8, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x03,
  0xDF, 0x00, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF3, 0xE0, 0x01,
  0xF1, 0xE0, 0x01, 0xE1, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF8, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xFC,
  0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x87,
  0xC0, 0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x0F,
  0xF8, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x87,
  0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0,
  0x3F, 0xFE, 0xF8, 0x1F, 0xFE, 0x78, 0x07, 0xFE, 0x3C, 0x01, 0xFE, 0x1E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x40, 0x03, 0xE3, 0xF8, 0x07, 0xCF, 0xFC, 0x07, 0xDF,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0,
  0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7F, 0x87, 0xF0, 0x7B, 0xFF, 0xE0, 0xFB, 0xFF, 0xE0, 0xF1, 0xFF,
  0x80, 0xF0, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x06, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x10, 0x7F, 0x07, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x04, 0x07, 0xC0, 0x07, 0xF1, 0xF8, 0x03, 0xFF, 0x3E, 0x00, 0xFF, 0xF7,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7F, 0x0F, 0xF8, 0x07,
  0xFF, 0xDE, 0x00, 0xFF, 0xF3, 0xC0, 0x0F, 0xFC, 0x78, 0x00, 0xFF, 0x0F,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0x7C, 0x3E, 0x03, 0xE3,
  0xF0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0xFC, 0x07,
  0xE7, 0xC1, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x08, 0x7E, 0x01, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x8F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x7C, 0x01, 0xFF, 0x8F,
  0x00, 0x7F, 0xF9, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F,
  0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xE0, 0x3F,
  0x87, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xE0, 0x07, 0xFE, 0x7C,
  0x00, 0x7F, 0x8F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x40, 0x03, 0xF0, 0x0F, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x40, 0x03, 0xE3, 0xFC,
  0x07, 0xCF, 0xFE, 0x07, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x3F,
  0x07, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE1, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0x7C, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xF9, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x40, 0x01, 0x00, 0x0F, 0x0F, 0xE0, 0x3F, 0x80, 0x7C,
  0xFF, 0xC3, 0xFF, 0x81, 0xF7, 0xFF, 0x9F, 0xFE, 0x07, 0xBF, 0xFE, 0xFF,
  0xFC, 0x1E, 0xE1, 0xFB, 0xC3, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xC3, 0xF8,
  0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x1F,
  0x87, 0xC0, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xE1,
  0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC3,
  0xFC, 0x07, 0xCF, 0xFE, 0x07, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xBC,
  0x3F, 0x0F, 0xF0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7E,
  0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0x0F, 0xE0, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xEE, 0x0F, 0xC0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0,
  0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xEF,
  0xFF, 0x80, 0x7D, 0xFF, 0xF0, 0x0F, 0x9F, 0xF8, 0x01, 0xF1, 0xFE, 0x00,
  0x3E, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x87, 0xC0,
  0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0x03, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x87, 0xC0,
  0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFE, 0xF8, 0x07, 0xFE, 0x7C, 0x01, 0xFE, 0x3E, 0x00,
  0x10, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x7F, 0x07, 0xCF, 0xE0, 0x7D, 0xFE,
  0x07, 0xDF, 0xE0, 0x7B, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x06, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x88, 0x01, 0xF8, 0xE0, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x06, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x3F, 0xC1, 0xF8, 0x3F, 0xE0, 0x7F, 0xFD, 0xE0, 0x3F, 0xFC,
  0xF0, 0x0F, 0xFC, 0x78, 0x03, 0xFC, 0x7C, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xF7, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0x00, 0xFB, 0xE0, 0x1F, 0xC0, 0x3E, 0xF8, 0x0F, 0xF0,
  0x1F, 0x3E, 0x03, 0xFC, 0x07, 0xCF, 0x81, 0xFF, 0x03, 0xF3, 0xE0, 0x7B,
  0xC0, 0xF8, 0xF8, 0x1E, 0xF0, 0x3E, 0x3E, 0x0F, 0x3C, 0x1F, 0x0F, 0x83,
  0xCF, 0x07, 0xC3, 0xE1, 0xF3, 0xC3, 0xE0, 0xF8, 0x78, 0xF0, 0xF8, 0x3E,
  0x3E, 0x3C, 0x7E, 0x0F, 0x8F, 0x0F, 0x1F, 0x03, 0xE3, 0xC3, 0xC7, 0xC0,
  0xF9, 0xE0, 0xF3, 0xE0, 0x3E, 0x78, 0x3C, 0xF8, 0x0F, 0xBE, 0x0F, 0x3C,
  0x01, 0xEF, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0xF7, 0x80, 0x1F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x7E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x04, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x02, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xA0, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 38, 13, 1, -37 },
  { 63, 17, 13, 20, 5, -37 },
  { 91, 29, 37, 30, 1, -37 },
  { 226, 25, 42, 26, 1, -39 },
  { 358, 34, 39, 39, 3, -38 },
  { 524, 29, 39, 31, 1, -38 },
  { 666, 8, 13, 11, 5, -37 },
  { 679, 17, 45, 15, 2, -37 },
  { 775, 17, 45, 15, -4, -37 },
  { 871, 21, 23, 25, 5, -40 },
  { 932, 23, 25, 27, 3, -31 },
  { 1004, 10, 13, 13, -2, -6 },
  { 1021, 13, 4, 16, 1, -16 },
  { 1028, 7, 8, 13, 1, -7 },
  { 1035, 25, 37, 19, -2, -37 },
  { 1151, 23, 39, 26, 2, -38 },
  { 1264, 16, 37, 26, 6, -37 },
  { 1338, 26, 38, 26, -1, -38 },
  { 1462, 25, 39, 26, 0, -38 },
  { 1584, 25, 37, 26, 0, -37 },
  { 1700, 25, 38, 26, 1, -37 },
  { 1819, 24, 39, 26, 2, -38 },
  { 1936, 24, 37, 26, 3, -37 },
  { 2047, 25, 39, 26, 1, -38 },
  { 2169, 24, 39, 26, 1, -38 },
  { 2286, 11, 30, 13, 1, -29 },
  { 2328, 15, 36, 13, -3, -29 },
  { 2396, 23, 25, 27, 3, -31 },
  { 2468, 23, 15, 27, 3, -26 },
  { 2512, 23, 25, 27, 3, -31 },
  { 2584, 19, 39, 20, 3, -38 },
  { 2677, 37, 42, 40, 2, -37 },
  { 2872, 27, 37, 27, -3, -37 },
  { 2997, 27, 37, 28, 1, -37 },
  { 3122, 27, 39, 27, 3, -38 },
  { 3254, 29, 37, 31, 1, -37 },
  { 3389, 25, 37, 24, 1, -37 },
  { 3505, 25, 37, 23, 1, -37 },
  { 3621, 29, 39, 32, 3, -38 },
  { 3763, 32, 37, 32, 1, -37 },
  { 3911, 22, 37, 17, -2, -37 },
  { 4013, 23, 47, 14, -8, -37 },
  { 4149, 31, 37, 27, 1, -37 },
  { 4293, 19, 37, 23, 1, -37 },
  { 4381, 40, 37, 41, 1, -37 },
  { 4566, 33, 37, 34, 1, -37 },
  { 4719, 29, 39, 34, 3, -38 },
  { 4861, 27, 37, 27, 1, -37 },
  { 4986, 29, 47, 34, 3, -38 },
  { 5157, 26, 37, 28, 1, -37 },
  { 5278, 25, 39, 24, 0, -38 },
  { 5400, 24, 37, 24, 4, -37 },
  { 5511, 30, 38, 32, 3, -37 },
  { 5654, 26, 37, 27, 5, -37 },
  { 5775, 41, 37, 41, 5, -37 },
  { 5965, 33, 37, 26, -3, -37 },
  { 6118, 24, 37, 24, 5, -37 },
  { 6229, 28, 37, 24, -1, -37 },
  { 6359, 20, 45, 15, -1, -37 },
  { 6472, 10, 37, 19, 5, -37 },
  { 6519, 20, 45, 15, -4, -37 },
  { 6632, 24, 22, 26, 1, -37 },
  { 6698, 20, 3, 19, -5, 5 },
  { 6706, 8, 8, 15, 8, -40 },
  { 6714, 25, 30, 27, 2, -29 },
  { 6808, 24, 41, 27, 1, -40 },
  { 6931, 20, 30, 22, 2, -29 },
  { 7006, 27, 41, 28, 2, -40 },
  { 7145, 21, 30, 24, 2, -29 },
  { 7224, 28, 52, 16, -6, -40 },
  { 7406, 27, 41, 28, 0, -29 },
  { 7545, 24, 40, 27, 1, -40 },
  { 7665, 13, 39, 13, 1, -39 },
  { 7729, 21, 51, 13, -7, -39 },
  { 7863, 25, 40, 24, 1, -40 },
  { 7988, 13, 40, 13, 1, -40 },
  { 8053, 38, 29, 41, 1, -29 },
  { 8191, 24, 29, 27, 1, -29 },
  { 8278, 23, 29, 27, 2, -29 },
  { 8362, 27, 41, 27, -2, -29 },
  { 8501, 25, 41, 27, 2, -29 },
  { 8630, 20, 29, 19, 1, -29 },
  { 8703, 20, 30, 21, 0, -29 },
  { 8778, 16, 35, 17, 2, -34 },
  { 8848, 25, 29, 27, 2, -28 },
  { 8939, 22, 28, 23, 3, -28 },
  { 9016, 34, 28, 35, 3, -28 },
  { 9135, 27, 28, 23, -2, -28 },
  { 9230, 30, 40, 23, -5, -28 },
  { 9380, 22, 28, 21, -1, -28 },
  { 9457, 20, 45, 18, 1, -37 },
  { 9570, 4, 52, 25, 11, -40 },
  { 9596, 20, 45, 18, -3, -37 },
  { 9709, 23, 7, 27, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC52PT7B_H_
