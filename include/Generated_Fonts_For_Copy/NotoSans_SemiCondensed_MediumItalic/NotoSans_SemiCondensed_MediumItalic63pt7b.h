#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x01, 0xC0, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0x1C, 0x3C, 0x03, 0xF8, 0x70, 0x10, 0x0F, 0xC3, 0xC0, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0xFC, 0x38, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0xC7,
  0x80, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x03, 0xFD, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0xFF, 0x00, 0x00,
  0x71, 0xFC, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x3C,
  0x3F, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x1E, 0x1F,
  0xC1, 0x00, 0x78, 0x7E, 0x0F, 0x01, 0xE3, 0xF8, 0x3F, 0xC7, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x07, 0xC3, 0xF0, 0x00,
  0x7C, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x03, 0xE1, 0xF0, 0x18, 0x1F, 0x01,
  0xF1, 0xF8, 0x7F, 0x8F, 0x81, 0xF0, 0xF8, 0xFF, 0xE7, 0xC0, 0xF8, 0xF8,
  0xFF, 0xFB, 0xE0, 0xF8, 0xFC, 0xFF, 0xFD, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F,
  0x7F, 0xFC, 0x7C, 0x7E, 0x1F, 0xBF, 0xFC, 0x7E, 0x3E, 0x07, 0xCF, 0xFC,
  0x3E, 0x3F, 0x03, 0xE3, 0xFC, 0x3E, 0x1F, 0x01, 0xF0, 0x30, 0x3F, 0x0F,
  0x80, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x7E,
  0x00, 0x1F, 0x83, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x0F,
  0x81, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0x00, 0x7F,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xF0, 0x7F, 0xBF, 0x00, 0x7E, 0x0F, 0xF3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x87, 0xE0, 0x07, 0xF3, 0xF0, 0x7E, 0x00,
  0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xFC, 0x0F,
  0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFD, 0xFE, 0x01,
  0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03, 0x00, 0xF8,
  0x01, 0xF0, 0x3C, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0xF3, 0xC0, 0x0F, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0x01, 0xFF, 0x80, 0x00, 0xFD, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x38, 0x0F, 0xC0, 0x06, 0x01, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xEF, 0xCF, 0xFC, 0xFC, 0x7F, 0x9F, 0xC7,
  0xE1, 0xF8, 0x3C, 0x1F, 0x81, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x38, 0x00,
  0xFE, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0x38, 0x00, 0xFE,
  0x00, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x20, 0x00, 0x0F, 0xF0,
  0x70, 0x00, 0x3F, 0xC0, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x82, 0x00, 0x01,
  0xFE, 0x0C, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x40, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x06,
  0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x7E, 0x7F, 0xFC, 0x03, 0xF7, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFB,
  0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF1, 0xF8,
  0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xE1, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xC0, 0x3F, 0xFC, 0xFC, 0x01,
  0xFF, 0x0F, 0xC0, 0x01, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x0C, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xFF,
  0xF8, 0x1F, 0x0F, 0x80, 0x3F, 0xFF, 0x81, 0xF1, 0xF0, 0x07, 0xFF, 0xF8,
  0x1F, 0x1F, 0x00, 0xFE, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x81, 0xF0, 0x1F,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF3, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x7C, 0x0F,
  0x80, 0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x00,
  0x7C, 0x03, 0xEF, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0x7C,
  0x07, 0xCF, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F, 0x00, 0xF8, 0x07,
  0xCF, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0x8F,
  0x81, 0xF0, 0x3F, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xF8, 0x3F, 0x0F, 0x81,
  0xF8, 0xF7, 0xC7, 0xE0, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0x80, 0xFF,
  0xE3, 0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F,
  0xC0, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0x80, 0x0C, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFE, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xE0,
  0x0F, 0xFC, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC7, 0xF0, 0x01,
  0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xC3, 0xF8,
  0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0x80,
  0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x06, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xE0,
  0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x0F,
  0x80, 0x3E, 0x1F, 0xC0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0xFC, 0x0F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x87, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xC3, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE3, 0xF0, 0x3F, 0x80, 0x3F,
  0x01, 0xF1, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF9, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7C, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x1F, 0x7C, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
  0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x80, 0x0F,
  0xEF, 0xC0, 0x0F, 0xC0, 0x03, 0xF7, 0xE0, 0x07, 0xE0, 0x01, 0xFB, 0xE0,
  0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFC,
  0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x7E, 0x00, 0xFF, 0x80, 0x1C, 0x01,
  0xFC, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x20, 0x00, 0x1F, 0xE0, 0x38,
  0x00, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x7C, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xDF, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE7, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xF1, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x7C,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x1F,
  0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x07,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x81,
  0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0,
  0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x80, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x01, 0xF3, 0xF0,
  0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0xC1, 0xF0, 0x07, 0xFF, 0x87, 0xC0, 0x3F, 0xFF, 0x3F,
  0x01, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xFB, 0xE0, 0x3F, 0xC1, 0xFF, 0x81,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0x81, 0xFE, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0x3F,
  0x00, 0x7F, 0xF8, 0xF8, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x10, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x7E, 0x3F, 0xF8,
  0x01, 0xF9, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x80,
  0xFF, 0xE0, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x00,
  0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFE,
  0x03, 0xF3, 0xFF, 0xF0, 0x0F, 0x87, 0xFF, 0x80, 0x3E, 0x0F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xF0, 0x18, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0x03, 0xFE,
  0x03, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x07, 0xE0, 0x00, 0x7F, 0xC3, 0xF0, 0x00,
  0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x7E, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFB, 0xE0, 0x03, 0xFF,
  0xFB, 0xF0, 0x01, 0xFF, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x0F,
  0xF0, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x0F, 0xF1, 0xFC, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x1F, 0xE0, 0x0F, 0x03, 0xFF, 0xBF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x47, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x1F, 0xFE,
  0x1F, 0x00, 0x3F, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xBF, 0x00, 0xFF, 0xFF,
  0xBE, 0x00, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xE0, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xDF,
  0xC0, 0x07, 0xFF, 0x9F, 0x80, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x20, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x80, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0x00,
  0x07, 0xE1, 0xFF, 0x00, 0x3F, 0x1F, 0xFC, 0x01, 0xFB, 0xFF, 0xF0, 0x1F,
  0xBF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xF0, 0x3F, 0xE0,
  0x1F, 0x81, 0xFE, 0x00, 0xFC, 0x1F, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x87, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xEF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x07, 0xC1, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7C, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xDF, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0x7C,
  0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x83,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x83, 0xFE, 0x00, 0x7C, 0x3F, 0xF8, 0x03, 0xE7, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFF, 0x81, 0xFB, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F,
  0x07, 0xFC, 0x01, 0xF8, 0x3F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0x07, 0xFC, 0x00, 0x0F, 0x87, 0xFF, 0x00, 0x07, 0xC7, 0xFF,
  0xC0, 0x07, 0xE7, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xF8, 0x01, 0xFF, 0xC1,
  0xFC, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0x80,
  0x0F, 0xC7, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0x00, 0x03, 0xF0, 0x1C, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xC1, 0xF0, 0x07, 0xFF, 0x87, 0xC0, 0x3F,
  0xFF, 0x3F, 0x01, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xFB, 0xE0, 0x3F, 0xC1,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0x01,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xC0, 0x3F,
  0xFF, 0x3F, 0x00, 0x7F, 0xF9, 0xF8, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x30,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0,
  0x7F, 0x01, 0xF1, 0xFF, 0x01, 0xF3, 0xFF, 0x03, 0xF3, 0xFE, 0x03, 0xF7,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xC0, 0x38, 0x1F, 0xC0, 0x04, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x3F, 0x87, 0x80,
  0x3F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFF, 0x07, 0xE0,
  0x07, 0xF8, 0x3F, 0x00, 0x7F, 0xC1, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xCF, 0x80,
  0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xFC, 0x03, 0xF9, 0xF8, 0x07,
  0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xDF, 0x01, 0xFC, 0x7E, 0x03, 0xEF, 0x80,
  0xFC, 0x3F, 0x03, 0xF7, 0xC0, 0x7E, 0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF9, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x03, 0xF0, 0x7C,
  0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x3E, 0x1F, 0xC0, 0xFC, 0x3E, 0x1F, 0x0F,
  0xC0, 0x7E, 0x3F, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x07, 0xC7, 0xE0, 0x1F,
  0x8F, 0x83, 0xE3, 0xF0, 0x0F, 0xCF, 0x81, 0xF3, 0xF0, 0x07, 0xE7, 0xC0,
  0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0x3E, 0xFC,
  0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x0F, 0xBE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x08, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x11, 0xFF, 0x80, 0x01, 0x3F,
  0xFF, 0x00, 0x37, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 46, 16, 1, -45 },
  { 99, 20, 16, 25, 6, -45 },
  { 139, 36, 45, 36, 1, -45 },
  { 342, 30, 52, 31, 1, -48 },
  { 537, 41, 47, 47, 4, -46 },
  { 778, 36, 47, 38, 1, -46 },
  { 990, 9, 16, 14, 7, -45 },
  { 1008, 21, 55, 18, 2, -45 },
  { 1153, 21, 55, 18, -5, -45 },
  { 1298, 26, 27, 31, 6, -48 },
  { 1386, 27, 30, 33, 4, -37 },
  { 1488, 13, 15, 16, -3, -7 },
  { 1513, 16, 6, 19, 1, -20 },
  { 1525, 8, 9, 16, 1, -8 },
  { 1534, 31, 45, 23, -3, -45 },
  { 1709, 29, 47, 31, 2, -46 },
  { 1880, 20, 45, 31, 7, -45 },
  { 1993, 32, 46, 31, -1, -46 },
  { 2177, 31, 47, 31, 0, -46 },
  { 2360, 31, 45, 31, 0, -45 },
  { 2535, 30, 46, 31, 1, -45 },
  { 2708, 29, 47, 31, 3, -46 },
  { 2879, 30, 45, 31, 3, -45 },
  { 3048, 30, 47, 31, 1, -46 },
  { 3225, 28, 47, 31, 2, -46 },
  { 3390, 13, 36, 16, 1, -35 },
  { 3449, 17, 43, 16, -3, -35 },
  { 3541, 28, 31, 33, 3, -38 },
  { 3650, 27, 18, 33, 4, -31 },
  { 3711, 27, 31, 33, 4, -38 },
  { 3816, 24, 47, 25, 3, -46 },
  { 3957, 44, 51, 48, 3, -45 },
  { 4238, 33, 45, 33, -4, -45 },
  { 4424, 33, 45, 34, 1, -45 },
  { 4610, 32, 47, 33, 4, -46 },
  { 4798, 35, 45, 38, 1, -45 },
  { 4995, 31, 45, 30, 1, -45 },
  { 5170, 31, 45, 28, 1, -45 },
  { 5345, 35, 47, 39, 4, -46 },
  { 5551, 39, 45, 39, 1, -45 },
  { 5771, 26, 45, 20, -2, -45 },
  { 5918, 28, 57, 17, -10, -45 },
  { 6118, 37, 45, 33, 1, -45 },
  { 6327, 23, 45, 28, 1, -45 },
  { 6457, 49, 45, 49, 1, -45 },
  { 6733, 41, 45, 41, 1, -45 },
  { 6964, 35, 47, 41, 4, -46 },
  { 7170, 32, 45, 33, 1, -45 },
  { 7350, 35, 57, 41, 4, -46 },
  { 7600, 32, 45, 33, 1, -45 },
  { 7780, 31, 47, 29, 0, -46 },
  { 7963, 29, 45, 29, 5, -45 },
  { 8127, 36, 46, 38, 4, -45 },
  { 8334, 32, 45, 32, 6, -45 },
  { 8514, 49, 45, 50, 6, -45 },
  { 8790, 39, 45, 31, -3, -45 },
  { 9010, 29, 45, 30, 6, -45 },
  { 9174, 35, 45, 29, -2, -45 },
  { 9371, 24, 55, 19, -1, -45 },
  { 9536, 12, 45, 23, 7, -45 },
  { 9604, 24, 55, 19, -4, -45 },
  { 9769, 30, 27, 32, 1, -45 },
  { 9871, 24, 4, 23, -6, 6 },
  { 9883, 11, 10, 18, 9, -48 },
  { 9897, 30, 36, 33, 2, -35 },
  { 10032, 30, 49, 33, 1, -48 },
  { 10216, 25, 36, 26, 2, -35 },
  { 10329, 33, 49, 33, 2, -48 },
  { 10532, 26, 36, 30, 2, -35 },
  { 10649, 33, 63, 19, -7, -48 },
  { 10909, 32, 50, 33, 0, -35 },
  { 11109, 29, 48, 33, 1, -48 },
  { 11283, 16, 47, 15, 1, -47 },
  { 11377, 25, 62, 16, -8, -47 },
  { 11571, 31, 48, 29, 1, -48 },
  { 11757, 16, 48, 15, 1, -48 },
  { 11853, 46, 35, 50, 1, -35 },
  { 12055, 29, 35, 33, 1, -35 },
  { 12182, 28, 36, 32, 2, -35 },
  { 12308, 33, 50, 33, -2, -35 },
  { 12515, 30, 50, 33, 2, -35 },
  { 12703, 24, 35, 23, 1, -35 },
  { 12808, 25, 36, 25, 0, -35 },
  { 12921, 19, 43, 20, 3, -42 },
  { 13024, 29, 35, 33, 3, -34 },
  { 13151, 28, 34, 27, 3, -34 },
  { 13270, 41, 34, 43, 4, -34 },
  { 13445, 33, 34, 28, -3, -34 },
  { 13586, 36, 49, 28, -5, -34 },
  { 13807, 28, 34, 25, -2, -34 },
  { 13926, 24, 55, 22, 1, -45 },
  { 14091, 5, 63, 30, 13, -48 },
  { 14131, 24, 55, 22, -3, -45 },
  { 14296, 28, 9, 33, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC63PT7B_H_
