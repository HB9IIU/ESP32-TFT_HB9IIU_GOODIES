#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x87, 0xC1, 0xC0, 0x79, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0x98, 0xE6, 0x3B,
  0x8C, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x18, 0x70, 0x06, 0x18, 0x03, 0x86,
  0x00, 0xE3, 0x80, 0x30, 0xC0, 0xFF, 0xFF, 0x3F, 0xFF, 0x81, 0x86, 0x00,
  0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x18, 0x60, 0x06, 0x18, 0x03, 0x8E, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC3, 0xD9, 0x87, 0x30, 0x1C, 0x40, 0x39, 0x80, 0x7B, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xBC, 0x02,
  0x38, 0x0C, 0x72, 0x19, 0xC7, 0x37, 0x8F, 0xFE, 0x1F, 0xF8, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0F, 0x00, 0xE0, 0xFC, 0x06, 0x0E,
  0x60, 0x70, 0xE3, 0x87, 0x07, 0x1C, 0x30, 0x30, 0xC3, 0x83, 0x86, 0x38,
  0x1C, 0x31, 0x80, 0xE3, 0x9C, 0x07, 0x1D, 0xCF, 0x39, 0xCC, 0xFD, 0xCE,
  0xEE, 0xF7, 0xEE, 0x63, 0xBE, 0x67, 0x1C, 0x07, 0x38, 0xE0, 0x71, 0x87,
  0x03, 0x1C, 0x30, 0x38, 0xE1, 0x83, 0x87, 0x1C, 0x18, 0x38, 0xC1, 0xC1,
  0xCE, 0x1C, 0x07, 0xE1, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x7B, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0x3F, 0xC3,
  0x9E, 0x70, 0xEF, 0x1E, 0x73, 0x83, 0xDC, 0xE0, 0x7E, 0x38, 0x1F, 0x8E,
  0x03, 0xC3, 0x81, 0xF0, 0xFB, 0xFE, 0x1F, 0xF3, 0x83, 0xF8, 0xF0, 0x7B,
  0xDC, 0xE7, 0x31, 0x9C, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x10, 0xE0, 0xC6,
  0x0F, 0xB0, 0x3F, 0xFC, 0x3F, 0xE1, 0xE1, 0x1F, 0x81, 0xCC, 0x1E, 0x70,
  0x63, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x3C, 0xF3, 0x9E, 0x71, 0xCE,
  0x30, 0xFF, 0xFE, 0xFE, 0x73, 0xFE, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x70,
  0xE1, 0xE1, 0xC7, 0x83, 0xCE, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xE0, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1C, 0xE0,
  0x79, 0xC0, 0xE3, 0xC1, 0xC3, 0x87, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0xF8, 0xFE, 0x7B, 0xBD, 0xC6, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xE1, 0xE0, 0x20, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFE, 0x04, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x80, 0x78, 0xFB,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0x9C, 0x03, 0x9C, 0x07,
  0x3C, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x78, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC4, 0x07, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x40, 0x77, 0xE1, 0xDF, 0xE3, 0xE3, 0xC7, 0x83, 0x8E,
  0x07, 0x9C, 0x0F, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0x71, 0xC1, 0xE3, 0x83,
  0x87, 0xFF, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3E, 0xF0, 0xF0, 0xF1, 0xC0,
  0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1E, 0x3C, 0x1F, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xFF, 0x0F, 0x0E, 0x1C, 0x1E, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x80, 0xE7, 0x83, 0xCF, 0x9F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xDE,
  0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x83, 0xCE, 0x1F, 0x3F, 0xFC, 0x7E, 0xE0,
  0xE3, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0xEF, 0xC3,
  0xFE, 0x0F, 0xE0, 0x00, 0x04, 0x1C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0xF0, 0xE0, 0x01, 0x01, 0xC1, 0xE0,
  0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0x8F, 0xFD, 0xFF, 0x90,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xC3, 0xE0,
  0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0x87, 0x03, 0x83, 0x9C,
  0x1F, 0xC7, 0x38, 0xF3, 0x8E, 0x61, 0xC7, 0x1D, 0xC7, 0x0C, 0x3B, 0x0C,
  0x18, 0x76, 0x38, 0x70, 0xDC, 0x70, 0xE1, 0xB8, 0xC1, 0x87, 0x71, 0x87,
  0x0C, 0xE3, 0x8E, 0x39, 0xC7, 0xFF, 0xE3, 0x87, 0xCF, 0x83, 0x02, 0x04,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x0F, 0xCF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x1E, 0x07, 0x0E, 0x03, 0xCF, 0x01, 0xE7, 0x00,
  0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0E, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0E, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x0E, 0x1C, 0x3E, 0x3F, 0xF8, 0x3F, 0xF0, 0x38, 0xFC, 0x38, 0x1C, 0x38,
  0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x3C, 0xF0, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xE0, 0x41, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0xC1, 0xC1, 0xE0, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x3C,
  0xE0, 0x1C, 0xF0, 0x1E, 0x70, 0x0F, 0x38, 0x0F, 0x1C, 0x0F, 0x1E, 0x1F,
  0x8F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x21,
  0xFF, 0x83, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x06, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC1, 0xFC, 0xE0, 0x7F, 0x38, 0x1F, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0,
  0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xE0, 0x70, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x07, 0x87, 0x00,
  0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70, 0x0E,
  0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x78, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0xF8, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x7F, 0xC3, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x0F, 0xF0, 0x3F,
  0x80, 0xFC, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C,
  0x0E, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0x73, 0xC0, 0x1C, 0xE0, 0x07,
  0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0x8E,
  0x01, 0xE3, 0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x07, 0x07, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x0E, 0x0E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x0D, 0x80, 0x7F, 0x1D, 0x80, 0x7E, 0x1D, 0xC0, 0xEE,
  0x1D, 0xC0, 0xEE, 0x1D, 0xC1, 0xDE, 0x1D, 0xC1, 0xDC, 0x39, 0xC3, 0x9C,
  0x39, 0xC3, 0x9C, 0x39, 0xC7, 0x1C, 0x39, 0xC7, 0x3C, 0x39, 0xCE, 0x38,
  0x71, 0xCE, 0x38, 0x70, 0xDC, 0x38, 0x70, 0xDC, 0x38, 0x70, 0xF8, 0x78,
  0xF0, 0xF8, 0x70, 0xE0, 0xF0, 0x70, 0xE0, 0xF0, 0x70, 0xE0, 0xE0, 0xF0,
  0x0F, 0x00, 0x70, 0xF8, 0x07, 0x0F, 0x80, 0x70, 0xF8, 0x0F, 0x0F, 0x80,
  0xE1, 0xDC, 0x0E, 0x1D, 0xC0, 0xE1, 0xDC, 0x0E, 0x1C, 0xE1, 0xC1, 0xCE,
  0x1C, 0x38, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x73, 0xC3, 0x87, 0x38, 0x78,
  0x73, 0x87, 0x03, 0xB8, 0x70, 0x3B, 0x87, 0x03, 0xB8, 0x70, 0x3F, 0x0F,
  0x01, 0xF0, 0xE0, 0x1F, 0x0E, 0x01, 0xF0, 0xE0, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xF3,
  0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x0F,
  0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E,
  0x39, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x1E, 0x1E, 0x03, 0x8F,
  0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1E,
  0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1E, 0x0E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C,
  0x3C, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x78, 0xF0, 0x38, 0xE0, 0x38, 0xE0,
  0x3C, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x06, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x80, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x70,
  0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x07,
  0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x3C, 0x03, 0x8F,
  0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0xC1,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78,
  0xF0, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x73, 0xC0,
  0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x1E, 0x03,
  0xF8, 0x0F, 0x01, 0xDC, 0x07, 0x81, 0xEE, 0x07, 0xC0, 0xE7, 0x03, 0x60,
  0x73, 0x83, 0xB0, 0x71, 0xC1, 0xD8, 0x38, 0xE1, 0xCC, 0x3C, 0x70, 0xE6,
  0x1C, 0x38, 0x63, 0x1E, 0x1C, 0x71, 0x8E, 0x0E, 0x38, 0xC7, 0x07, 0x38,
  0x67, 0x03, 0x9C, 0x33, 0x81, 0xDC, 0x1B, 0xC0, 0xEE, 0x0D, 0xC0, 0x76,
  0x06, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xEF, 0x00,
  0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x1C,
  0x00, 0xF1, 0xC0, 0x1E, 0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x0E, 0x07, 0x80,
  0xE0, 0xF0, 0x0F, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0xE3, 0x83, 0xC7,
  0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x3B, 0xC0, 0x77, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xE0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x80, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFE, 0x0F, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xCC, 0x03, 0x1C, 0x0E, 0x38, 0x18, 0x30, 0x70, 0x70,
  0xC0, 0xE3, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xE7,
  0x1C, 0xE3, 0x8C, 0x01, 0x00, 0x0F, 0xCC, 0x3F, 0xB8, 0xF1, 0xF3, 0xC1,
  0xE7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x7B, 0xC0, 0xE7,
  0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3E, 0x3D, 0xF8, 0x7F, 0x70, 0x7C,
  0xE0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x10, 0x0E, 0xFC, 0x0F, 0xFE, 0x0F, 0x9E, 0x1F, 0x0F, 0x1E,
  0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x7E, 0xF8, 0x7F, 0xF0, 0xE7,
  0xE0, 0x00, 0x80, 0x3F, 0xC3, 0xFC, 0x3C, 0x23, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0xB8, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x04, 0x38, 0x0F, 0xDC,
  0x0F, 0xEE, 0x0F, 0x1F, 0x0F, 0x07, 0x87, 0x03, 0x87, 0x81, 0xC3, 0x80,
  0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x1C, 0x38, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x03, 0xDF, 0x81, 0xFD, 0xC0, 0x7C, 0xE0, 0x00, 0xC0,
  0x3F, 0x83, 0xFE, 0x3C, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x1E, 0x7F,
  0xF7, 0xFE, 0x3E, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x1C,
  0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x20, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x03, 0xF3, 0x07, 0xFF, 0x0F, 0x1F, 0x1E, 0x0F, 0x1C, 0x0E,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x3D, 0xF8, 0x3F, 0xB8, 0x1F, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0xC1, 0xE0, 0xFF, 0xE0,
  0xFF, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x84, 0x07, 0x7E, 0x0F, 0xFE, 0x1F, 0x3C, 0x7C,
  0x38, 0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x0F, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x78,
  0x1C, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x7E, 0x03, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x0F,
  0x0E, 0x1E, 0x0E, 0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0,
  0x3B, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0x70, 0xF0, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x78, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x00,
  0x10, 0x08, 0x0E, 0xFC, 0x7E, 0x0F, 0xFE, 0xFF, 0x0D, 0x9F, 0xCF, 0x1F,
  0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x1C, 0x0E, 0x0F, 0x1C, 0x0E, 0x0F, 0x3C,
  0x1E, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x1E, 0x38,
  0x3C, 0x1C, 0x78, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x70,
  0x38, 0x3C, 0xF0, 0x78, 0x38, 0x00, 0x18, 0x1D, 0xF8, 0x3F, 0xF8, 0xEC,
  0xF1, 0xF0, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x3C, 0x0E, 0x78, 0x3C,
  0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70,
  0x39, 0xE0, 0x70, 0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0x9F, 0x3C, 0x1C,
  0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3B, 0xC1, 0xE7, 0x0F, 0x1F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x00,
  0x08, 0x03, 0xBF, 0x01, 0xFF, 0xC0, 0xD9, 0xE0, 0xF8, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x81,
  0xE1, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x7E, 0xF8, 0x3B, 0xF8, 0x1D,
  0xF8, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xCC, 0x3F,
  0xF8, 0xF1, 0xF3, 0xC1, 0xE7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCE, 0x07, 0x9E, 0x0F, 0x3C, 0x3E, 0x3D,
  0xF8, 0x7F, 0x70, 0x7C, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x10, 0x77, 0xC3,
  0xFC, 0x1B, 0xE1, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x01, 0x00, 0x7F, 0xC7, 0xFC, 0x78, 0x63, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF2, 0x07, 0x9C, 0xF8, 0xFF, 0xC7, 0xF8, 0x00, 0x06, 0x03, 0x80, 0xE0,
  0x70, 0x7F, 0xDF, 0xF9, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0xA1, 0xF8, 0x7E, 0x00, 0x1C,
  0x0E, 0x38, 0x1C, 0xF0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x3C, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E,
  0x1E, 0x3E, 0xFC, 0x3F, 0xB8, 0x3E, 0x70, 0xE0, 0x3F, 0x81, 0xEE, 0x07,
  0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x9E,
  0x06, 0x70, 0x19, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xB8, 0x7C, 0x1D, 0xC3, 0xE1, 0xCE,
  0x1B, 0x0E, 0x71, 0xD8, 0xF3, 0x8C, 0xC7, 0x1C, 0xE6, 0x38, 0xE7, 0x33,
  0x87, 0x71, 0x9C, 0x3B, 0x8D, 0xC1, 0xD8, 0x6E, 0x0F, 0xC3, 0x60, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x1E, 0x0F,
  0x0E, 0x0E, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0,
  0x3C, 0x70, 0x38, 0x70, 0x70, 0x78, 0xF0, 0x38, 0x07, 0x01, 0xE0, 0xE0,
  0x78, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x0E, 0x1E, 0x01, 0xC3,
  0x80, 0x18, 0xF0, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0xFF, 0xE0, 0x00, 0x38, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x17, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x1E, 0x01,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x7E, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x00, 0x10, 0x07, 0xF8, 0x1F, 0xFF, 0xF1,
  0xFF, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 10, 8, 12, 3, -23 },
  { 37, 18, 23, 18, 1, -23 },
  { 89, 15, 26, 16, 1, -24 },
  { 138, 21, 23, 24, 2, -23 },
  { 199, 18, 23, 19, 1, -23 },
  { 251, 5, 8, 7, 3, -23 },
  { 256, 11, 28, 9, 1, -23 },
  { 295, 10, 28, 9, -2, -23 },
  { 330, 13, 13, 16, 3, -24 },
  { 352, 14, 15, 17, 2, -19 },
  { 379, 6, 8, 8, -1, -4 },
  { 385, 8, 3, 10, 1, -10 },
  { 388, 5, 4, 8, 0, -4 },
  { 391, 16, 23, 12, -2, -23 },
  { 437, 15, 23, 16, 1, -23 },
  { 481, 10, 23, 16, 4, -23 },
  { 510, 17, 23, 16, -1, -23 },
  { 559, 16, 23, 16, 0, -23 },
  { 605, 16, 23, 16, 0, -23 },
  { 651, 15, 23, 16, 1, -23 },
  { 695, 15, 23, 16, 1, -23 },
  { 739, 15, 23, 16, 2, -23 },
  { 783, 15, 23, 16, 1, -23 },
  { 827, 14, 23, 16, 1, -23 },
  { 868, 7, 18, 8, 0, -18 },
  { 884, 9, 22, 8, -2, -18 },
  { 909, 14, 15, 17, 2, -19 },
  { 936, 14, 9, 17, 2, -16 },
  { 952, 14, 15, 17, 2, -19 },
  { 979, 11, 23, 12, 2, -23 },
  { 1011, 23, 26, 24, 1, -23 },
  { 1086, 17, 23, 17, -2, -23 },
  { 1135, 16, 23, 17, 1, -23 },
  { 1181, 17, 23, 17, 2, -23 },
  { 1230, 17, 23, 19, 1, -23 },
  { 1279, 15, 23, 15, 1, -23 },
  { 1323, 15, 23, 14, 1, -23 },
  { 1367, 18, 23, 20, 2, -23 },
  { 1419, 19, 23, 20, 1, -23 },
  { 1474, 13, 23, 10, -1, -23 },
  { 1512, 14, 29, 8, -5, -23 },
  { 1563, 18, 23, 17, 1, -23 },
  { 1615, 11, 23, 14, 1, -23 },
  { 1647, 24, 23, 25, 1, -23 },
  { 1716, 20, 23, 21, 1, -23 },
  { 1774, 18, 23, 21, 2, -23 },
  { 1826, 16, 23, 17, 1, -23 },
  { 1872, 18, 28, 21, 2, -23 },
  { 1935, 16, 23, 17, 1, -23 },
  { 1981, 16, 23, 15, 0, -23 },
  { 2027, 14, 23, 15, 3, -23 },
  { 2068, 18, 23, 19, 2, -23 },
  { 2120, 16, 23, 16, 3, -23 },
  { 2166, 25, 23, 25, 3, -23 },
  { 2238, 20, 23, 16, -2, -23 },
  { 2296, 15, 23, 15, 3, -23 },
  { 2340, 18, 23, 15, -1, -23 },
  { 2392, 13, 28, 9, -1, -23 },
  { 2438, 7, 23, 12, 3, -23 },
  { 2459, 12, 28, 9, -2, -23 },
  { 2501, 15, 14, 16, 1, -23 },
  { 2528, 12, 2, 12, -3, 3 },
  { 2531, 5, 6, 9, 5, -25 },
  { 2535, 15, 18, 17, 1, -18 },
  { 2569, 16, 24, 17, 0, -24 },
  { 2617, 13, 18, 13, 1, -18 },
  { 2647, 17, 24, 17, 1, -24 },
  { 2698, 13, 18, 15, 1, -18 },
  { 2728, 17, 32, 10, -4, -24 },
  { 2796, 16, 26, 17, 0, -18 },
  { 2848, 15, 24, 17, 0, -24 },
  { 2893, 9, 24, 8, 0, -24 },
  { 2920, 13, 32, 8, -4, -24 },
  { 2972, 16, 24, 15, 0, -24 },
  { 3020, 9, 24, 8, 0, -24 },
  { 3047, 24, 18, 25, 0, -18 },
  { 3101, 15, 18, 17, 0, -18 },
  { 3135, 14, 18, 16, 1, -18 },
  { 3167, 17, 26, 17, -1, -18 },
  { 3223, 15, 26, 17, 1, -18 },
  { 3272, 13, 18, 12, 0, -18 },
  { 3302, 13, 18, 13, 0, -18 },
  { 3332, 10, 21, 10, 1, -21 },
  { 3359, 15, 17, 17, 1, -17 },
  { 3391, 14, 17, 14, 2, -17 },
  { 3421, 21, 17, 22, 2, -17 },
  { 3466, 16, 17, 14, -1, -17 },
  { 3500, 19, 25, 14, -3, -17 },
  { 3560, 14, 17, 13, -1, -17 },
  { 3590, 13, 28, 11, 0, -23 },
  { 3636, 2, 32, 15, 7, -24 },
  { 3644, 13, 28, 11, -2, -23 },
  { 3690, 14, 5, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC32PT7B_H_
