#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x70, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xE7, 0x0E, 0x07, 0xC7, 0x04,
  0x07, 0x87, 0x00, 0x0F, 0x87, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x8E, 0x00,
  0x0F, 0xCE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x38, 0xF8,
  0x00, 0x30, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x70, 0xF8, 0x80, 0x71, 0xF0,
  0xF0, 0x73, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x02, 0x01, 0xFE, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xC0,
  0x0F, 0x01, 0xF1, 0xE0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0xF0, 0x78,
  0x07, 0x80, 0x78, 0x3C, 0x07, 0x80, 0x7C, 0x1E, 0x07, 0xC0, 0x3C, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC3, 0xE0, 0x07, 0x81,
  0xE1, 0xE0, 0x07, 0xC1, 0xE1, 0xE0, 0x03, 0xC0, 0xF1, 0xF0, 0x01, 0xE0,
  0x78, 0xF1, 0xFC, 0xF0, 0x78, 0xF1, 0xFF, 0x78, 0x3C, 0xF9, 0xFF, 0xDE,
  0x3C, 0x79, 0xFB, 0xEF, 0xFE, 0x78, 0xF0, 0xF7, 0xFE, 0x7C, 0xF8, 0x79,
  0xFE, 0x3C, 0x78, 0x3C, 0x3C, 0x3C, 0x7C, 0x1E, 0x00, 0x3E, 0x3C, 0x0F,
  0x00, 0x1E, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x1F, 0x0F, 0x81,
  0xE0, 0x0F, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0x3E,
  0x3E, 0x03, 0xC0, 0x0F, 0x3E, 0x03, 0xC0, 0x07, 0xFE, 0x01, 0xE0, 0x03,
  0xFF, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0xFD,
  0xF0, 0x1F, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x3F, 0x0F, 0x8F, 0xC0, 0xF8,
  0x7C, 0x7C, 0x07, 0xE7, 0xC7, 0xE0, 0x1F, 0x7E, 0x3E, 0x00, 0xFF, 0xE1,
  0xF0, 0x03, 0xFE, 0x0F, 0x80, 0x1F, 0xF0, 0x7C, 0x00, 0x7F, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE7, 0xE0, 0x7F, 0xFE, 0x3F, 0x00, 0xFF, 0xC0, 0xFC,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x30, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0xCF, 0x00, 0xFF, 0xF0, 0x3B, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x8F, 0x83, 0xFC, 0x00,
  0x3E, 0xF0, 0x03, 0xE7, 0x80, 0x3F, 0x1E, 0x03, 0xF0, 0xF0, 0x0F, 0x07,
  0xC0, 0x30, 0x1E, 0x00, 0x80, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x19, 0xFF, 0xFF, 0xFF, 0xFF, 0x8C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x01, 0xF0,
  0x3E, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC, 0xFF,
  0x7C, 0x7C, 0x7C, 0x78, 0xFC, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3C, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0x01, 0xF8, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x10, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE1, 0x80,
  0x07, 0xE0, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xBC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xC7, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x04,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x80,
  0x07, 0xE0, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x7F, 0xE0, 0x3E, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xC3, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xF1, 0xFC, 0x01,
  0xFB, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xE7, 0xE0, 0x1F, 0xC3, 0xF0, 0x3F, 0x01, 0xF8, 0x3E,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFC,
  0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xFC,
  0x7E, 0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF, 0x80,
  0xFF, 0x1F, 0x00, 0x70, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xC0, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x02, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC6, 0x03, 0xF1, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0xF0, 0x0F, 0xFE,
  0x0F, 0x1F, 0x01, 0xFF, 0xE0, 0xF1, 0xE0, 0x7F, 0xFE, 0x0F, 0x3E, 0x07,
  0xC3, 0xE0, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0xC0, 0xF7,
  0x81, 0xE0, 0x3C, 0x0F, 0x78, 0x3C, 0x07, 0xC0, 0xF7, 0x83, 0xC0, 0x78,
  0x1E, 0x78, 0x7C, 0x07, 0x81, 0xEF, 0x07, 0x80, 0x78, 0x1E, 0xF0, 0x78,
  0x0F, 0x01, 0xEF, 0x07, 0x80, 0xF0, 0x3C, 0xF0, 0x78, 0x1F, 0x03, 0xCF,
  0x07, 0x81, 0xF0, 0x78, 0xF0, 0x78, 0x3F, 0x07, 0x8F, 0x07, 0xC7, 0x71,
  0xF0, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0x03, 0xFE, 0x7F, 0xC0, 0x78, 0x1F,
  0xC3, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xE0,
  0x3F, 0x80, 0x08, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x40,
  0x3F, 0xC0, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0,
  0x3F, 0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC3,
  0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1E, 0x03, 0xF8, 0x00,
  0x20, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0xFC, 0xFC, 0x01, 0xFF, 0xCF, 0xC0, 0x1F, 0xFC, 0xFC, 0x03,
  0xFF, 0xCF, 0x80, 0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x07, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7F, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x7C,
  0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x3E, 0xF8, 0x07, 0xCF,
  0x00, 0x3E, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x7C,
  0xF8, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x00, 0xF1, 0xF0, 0x0F,
  0x8F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x03,
  0xE3, 0xF0, 0x0F, 0x0F, 0x83, 0xC3, 0xE0, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0x1F, 0x0F, 0x87, 0x83, 0xE0, 0x1F, 0x0F, 0x8F, 0x83, 0xE0, 0x1F, 0x0F,
  0x8F, 0x07, 0xC0, 0x1E, 0x07, 0x9F, 0x07, 0xC0, 0x3E, 0x07, 0x9E, 0x07,
  0xC0, 0x3E, 0x07, 0xBE, 0x07, 0xC0, 0x3E, 0x07, 0xBC, 0x07, 0xC0, 0x3E,
  0x07, 0xFC, 0x0F, 0x80, 0x3C, 0x07, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0x80,
  0x7F, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x03, 0xE0, 0x1F, 0xE0, 0x01, 0xF0,
  0x0F, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x7C,
  0x03, 0xFF, 0x00, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x00, 0xF3, 0xE0, 0x0F,
  0x80, 0xF9, 0xF0, 0x0F, 0x80, 0x7C, 0x78, 0x07, 0xC0, 0x3E, 0x3E, 0x03,
  0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x0F, 0x83, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x3E, 0x01, 0xF0, 0x3C,
  0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x00, 0xF9, 0xF0, 0x1F, 0x00,
  0x7C, 0xF0, 0x0F, 0x80, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0xFC, 0x03, 0xE0,
  0x07, 0xFE, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xF0, 0x3F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x0F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xC0, 0x70, 0x0F, 0xC0, 0x08, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0x80, 0x0F, 0xE0, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1E,
  0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xFC, 0x00,
  0xF8, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0xF8,
  0x07, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0xF8, 0x0F, 0xBC,
  0x03, 0xE0, 0xF8, 0x0F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0xF8, 0x3E,
  0x3E, 0x1F, 0x80, 0xF8, 0x3C, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x3E, 0x1F,
  0x00, 0xF8, 0x78, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x3E, 0x3E, 0x00, 0xF8,
  0xF0, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x3E,
  0x7C, 0x00, 0xF9, 0xE0, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x00,
  0xFB, 0xC0, 0x3E, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x1E, 0x07,
  0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFB,
  0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0x78, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x0F, 0x03,
  0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x0F, 0xF3, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFD, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F,
  0xF3, 0xE0, 0x1F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xF8, 0x07,
  0xCF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F,
  0x03, 0xF0, 0x7F, 0x87, 0xF0, 0xFF, 0xFF, 0xE0, 0xFB, 0xFF, 0xC0, 0xF1,
  0xFF, 0x80, 0xF0, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xF9, 0xE0, 0xFC, 0x02, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0x07, 0xE0, 0x70, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xF1, 0xF0, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0xF7, 0xC0,
  0x7F, 0x9F, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xF0,
  0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0xFE, 0xF0, 0x07, 0xFF,
  0xBE, 0x00, 0x7F, 0xE7, 0xC0, 0x07, 0xF8, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E,
  0x1F, 0x87, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01,
  0x0F, 0xC0, 0x30, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC4, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x23, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xF8, 0xF0, 0x0F, 0xFE, 0x7C, 0x07, 0xFF, 0xDF, 0x03,
  0xFC, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xBE, 0x00, 0xFF,
  0xCF, 0x80, 0x1F, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x08, 0x00, 0xFC, 0x03, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xFC, 0x07,
  0xCF, 0xFE, 0x07, 0xDF, 0xFE, 0x07, 0xFE, 0xFE, 0x07, 0xF8, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x08,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x10, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F,
  0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01,
  0xF1, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7D, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xF7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x3F, 0xC1, 0xFF, 0x01, 0xE7, 0xFF, 0x1F, 0xFC, 0x0F, 0x7F, 0xF9, 0xFF,
  0xF0, 0x7B, 0xCF, 0xFF, 0x3F, 0x83, 0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0x80,
  0xFE, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x03, 0xC3, 0xF0, 0x07, 0xC7, 0xFC, 0x07, 0xDF,
  0xFE, 0x07, 0x9F, 0xFE, 0x07, 0xBE, 0xFE, 0x0F, 0xF8, 0x3F, 0x0F, 0xF0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x1F, 0xE0, 0x03, 0xC7, 0xFE, 0x00, 0x79, 0xFF, 0xE0, 0x0F,
  0x79, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0x7F, 0xFC, 0x03, 0xEF, 0xFF,
  0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0x8F, 0xF0, 0x01, 0xF0, 0x20, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0x8F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF,
  0x0F, 0xF3, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x00, 0x7E,
  0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC7, 0xC0,
  0x02, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0xF8, 0xFC, 0x1F, 0x7F, 0x83, 0xCF, 0xF0, 0x7B, 0xFC,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xE0, 0xF8, 0x06, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x80, 0x1F, 0x8E, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC1, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0,
  0x1F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF,
  0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x81, 0xE0, 0x3E, 0x07, 0x81, 0xF0,
  0x1E, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xF0,
  0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xEF, 0x80, 0x7F, 0x01, 0xF3, 0xE0, 0x3F,
  0xC0, 0x7C, 0xF8, 0x0F, 0xF0, 0x3F, 0x3E, 0x07, 0xBC, 0x0F, 0x8F, 0x81,
  0xEF, 0x03, 0xE3, 0xE0, 0xFB, 0xC1, 0xF0, 0xF8, 0x3C, 0xF0, 0x7C, 0x3E,
  0x0F, 0x3C, 0x3E, 0x0F, 0x87, 0x8F, 0x0F, 0x83, 0xE1, 0xE3, 0xC7, 0xC0,
  0xF8, 0xF8, 0xF1, 0xF0, 0x3E, 0x3C, 0x3C, 0x7C, 0x0F, 0x9F, 0x0F, 0x3E,
  0x03, 0xE7, 0x83, 0xCF, 0x80, 0xF9, 0xE0, 0xF7, 0xC0, 0x3E, 0xF0, 0x3D,
  0xF0, 0x0F, 0xBC, 0x0F, 0x78, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x07,
  0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x21, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x04, 0x00, 0x04, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x20, 0x00, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 16, 13, 20, 5, -36 },
  { 88, 29, 36, 29, 1, -36 },
  { 219, 24, 42, 25, 1, -39 },
  { 345, 33, 38, 38, 3, -37 },
  { 502, 29, 38, 31, 1, -37 },
  { 640, 8, 13, 11, 5, -36 },
  { 653, 16, 45, 15, 2, -37 },
  { 743, 17, 45, 15, -4, -37 },
  { 839, 21, 22, 25, 5, -39 },
  { 897, 22, 24, 27, 3, -30 },
  { 963, 10, 13, 13, -2, -6 },
  { 980, 13, 5, 15, 1, -16 },
  { 989, 6, 8, 13, 1, -7 },
  { 995, 25, 37, 19, -2, -37 },
  { 1111, 23, 38, 25, 2, -37 },
  { 1221, 16, 36, 25, 6, -36 },
  { 1293, 26, 37, 25, -1, -37 },
  { 1414, 25, 38, 25, 0, -37 },
  { 1533, 25, 37, 25, 0, -37 },
  { 1649, 24, 37, 25, 1, -36 },
  { 1760, 24, 38, 25, 2, -37 },
  { 1874, 24, 36, 25, 3, -36 },
  { 1982, 24, 38, 25, 1, -37 },
  { 2096, 23, 38, 25, 1, -37 },
  { 2206, 11, 29, 13, 1, -28 },
  { 2246, 15, 35, 13, -3, -28 },
  { 2312, 22, 25, 27, 3, -31 },
  { 2381, 22, 14, 27, 3, -25 },
  { 2420, 22, 25, 27, 3, -31 },
  { 2489, 18, 38, 20, 3, -37 },
  { 2575, 36, 41, 39, 2, -37 },
  { 2760, 27, 36, 27, -3, -36 },
  { 2882, 27, 36, 28, 1, -36 },
  { 3004, 26, 38, 27, 3, -37 },
  { 3128, 28, 36, 31, 1, -36 },
  { 3254, 25, 36, 24, 1, -36 },
  { 3367, 25, 36, 23, 1, -36 },
  { 3480, 28, 38, 31, 3, -37 },
  { 3613, 31, 36, 31, 1, -36 },
  { 3753, 21, 36, 16, -2, -36 },
  { 3848, 22, 46, 13, -8, -36 },
  { 3975, 30, 36, 27, 1, -36 },
  { 4110, 18, 36, 22, 1, -36 },
  { 4191, 40, 36, 40, 1, -36 },
  { 4371, 33, 36, 33, 1, -36 },
  { 4520, 29, 38, 33, 3, -37 },
  { 4658, 26, 36, 27, 1, -36 },
  { 4775, 29, 46, 33, 3, -37 },
  { 4942, 26, 36, 27, 1, -36 },
  { 5059, 25, 38, 24, 0, -37 },
  { 5178, 23, 36, 23, 4, -36 },
  { 5282, 29, 37, 31, 3, -36 },
  { 5417, 26, 36, 26, 5, -36 },
  { 5534, 40, 36, 41, 5, -36 },
  { 5714, 32, 36, 25, -3, -36 },
  { 5858, 24, 36, 24, 5, -36 },
  { 5966, 27, 36, 24, -1, -36 },
  { 6088, 20, 45, 15, -1, -37 },
  { 6201, 10, 37, 19, 5, -37 },
  { 6248, 20, 45, 15, -4, -37 },
  { 6361, 24, 23, 26, 1, -37 },
  { 6430, 20, 4, 19, -5, 4 },
  { 6440, 9, 8, 14, 7, -39 },
  { 6449, 24, 29, 27, 2, -28 },
  { 6536, 24, 40, 27, 1, -39 },
  { 6656, 20, 29, 21, 2, -28 },
  { 6729, 27, 40, 27, 2, -39 },
  { 6864, 21, 29, 24, 2, -28 },
  { 6941, 27, 51, 15, -6, -39 },
  { 7114, 26, 40, 27, 0, -28 },
  { 7244, 24, 39, 27, 1, -39 },
  { 7361, 13, 38, 13, 1, -38 },
  { 7423, 20, 50, 13, -6, -38 },
  { 7548, 25, 39, 24, 1, -39 },
  { 7670, 13, 39, 13, 1, -39 },
  { 7734, 37, 28, 40, 1, -28 },
  { 7864, 24, 28, 27, 1, -28 },
  { 7948, 22, 28, 26, 2, -28 },
  { 8025, 27, 40, 27, -2, -28 },
  { 8160, 24, 40, 27, 2, -28 },
  { 8280, 19, 28, 19, 1, -28 },
  { 8347, 20, 29, 21, 0, -28 },
  { 8420, 16, 35, 16, 2, -34 },
  { 8490, 24, 28, 27, 2, -27 },
  { 8574, 22, 27, 22, 3, -27 },
  { 8649, 34, 27, 35, 3, -27 },
  { 8764, 27, 27, 23, -2, -27 },
  { 8856, 29, 39, 22, -4, -27 },
  { 8998, 22, 27, 20, -1, -27 },
  { 9073, 20, 44, 18, 1, -36 },
  { 9183, 4, 51, 25, 11, -39 },
  { 9209, 19, 44, 18, -2, -36 },
  { 9314, 22, 8, 27, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC51PT7B_H_
