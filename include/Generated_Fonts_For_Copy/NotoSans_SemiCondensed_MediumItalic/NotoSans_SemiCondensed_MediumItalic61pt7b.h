#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC61PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F, 0x87, 0xE7, 0xF0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1,
  0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0x3C, 0x78, 0x07, 0xF1, 0xC0, 0xC0, 0x3F, 0x0E, 0x00, 0x01, 0xF0, 0x70,
  0x00, 0x1F, 0x87, 0x80, 0x00, 0xFC, 0x3C, 0x00, 0x07, 0xE1, 0xC0, 0x00,
  0x3F, 0x8E, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF3, 0xF8, 0x00, 0x07, 0x8F, 0xC0, 0x00,
  0x38, 0x7E, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0xF0,
  0xFC, 0x00, 0x07, 0x87, 0xE1, 0x00, 0x38, 0x7F, 0x0E, 0x01, 0xC7, 0xF0,
  0x7E, 0x1E, 0x7F, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xFE,
  0x00, 0x0F, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0x7C,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0xFC,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0x3E, 0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x3F, 0xE7, 0xC0, 0xF8, 0xF8,
  0xFF, 0xEF, 0x83, 0xE3, 0xE3, 0xFF, 0xDF, 0x0F, 0xC7, 0xCF, 0xFF, 0xFF,
  0x3F, 0x1F, 0x1F, 0x0F, 0xBF, 0xFC, 0x7C, 0x7C, 0x1F, 0x7F, 0xF8, 0xF8,
  0xF8, 0x3E, 0x7F, 0xC3, 0xE3, 0xE0, 0x7C, 0x7F, 0x0F, 0x87, 0xC0, 0xF8,
  0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x01, 0xF1, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x07, 0xFF,
  0x80, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x0F, 0xF7,
  0xF0, 0x0F, 0xC7, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x81, 0xF8, 0xFE,
  0x07, 0xF0, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x3F, 0x9F, 0x87,
  0xE0, 0x07, 0xEF, 0xE3, 0xF8, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF,
  0xFC, 0x7F, 0x00, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8,
  0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x7C, 0x00, 0xF0, 0x3E, 0x00,
  0x7E, 0x1E, 0x00, 0x7F, 0xCF, 0x00, 0x3F, 0xFF, 0x80, 0xEF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0x03, 0xFF, 0x00, 0x03, 0xF7, 0x80, 0x03, 0xF3, 0xE0, 0x03, 0xF8,
  0xF0, 0x03, 0xF8, 0x7C, 0x03, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x80, 0x1C,
  0x07, 0xC0, 0x04, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x30, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFB, 0xF3, 0xFC, 0x7E, 0x3F,
  0x0F, 0xC3, 0xC3, 0xF0, 0x60, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0x1C, 0x00,
  0xFE, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0x80, 0x3F, 0x80,
  0x18, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x83, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0E, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x07, 0xF0, 0x60, 0x00, 0x7F,
  0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x06,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x03, 0xC0, 0x03, 0xF1, 0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x07, 0xE7, 0xFF,
  0xE0, 0x7E, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xF0, 0x7F, 0xC0, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8,
  0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xF1, 0xF8, 0x03, 0xFE, 0x3F, 0x80, 0xFF, 0x87, 0xF8, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFB, 0xF0, 0x0F, 0xFE, 0x7E,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x20, 0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xF0, 0x7F, 0x83, 0x80, 0x3F, 0x04, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x3F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0xFE, 0x07, 0xC1, 0xF0,
  0x0F, 0xFF, 0xE0, 0xF8, 0x7C, 0x03, 0xFF, 0xFC, 0x0F, 0x0F, 0x80, 0xFE,
  0x1F, 0x01, 0xE3, 0xE0, 0x3F, 0x03, 0xE0, 0x3C, 0x7C, 0x0F, 0xC0, 0x7C,
  0x07, 0x9F, 0x01, 0xF0, 0x0F, 0x80, 0xF3, 0xE0, 0x7C, 0x03, 0xE0, 0x3E,
  0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x0F, 0x80, 0xFB, 0xE0,
  0x7C, 0x01, 0xE0, 0x1F, 0x7C, 0x0F, 0x80, 0x7C, 0x03, 0xCF, 0x83, 0xE0,
  0x0F, 0x80, 0xF9, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x3C, 0x0F, 0x80, 0x7C,
  0x03, 0xC7, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0xF0, 0x3E, 0x03, 0xF0, 0x1F,
  0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0xC1, 0xF8, 0x78,
  0x1F, 0x87, 0xF8, 0x7E, 0x0F, 0x01, 0xFF, 0xEF, 0xFF, 0x81, 0xF0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0x81,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F,
  0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0xFE, 0x00,
  0xFF, 0x80, 0x0C, 0x01, 0xFF, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x08, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x1F, 0xC0, 0x0F, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x3F,
  0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0x80, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0x80, 0x01, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x1F, 0xBE, 0x00, 0x0F, 0xDF,
  0x80, 0x3E, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C,
  0x01, 0xF9, 0xF0, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x3E, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xF8, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0x83, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x3E, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFB, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xF7, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x07,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xEF, 0x80, 0x07, 0xE0, 0x0F, 0xDF, 0x80,
  0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x3F, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xF8,
  0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC0,
  0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x0F, 0xDF, 0x80, 0x3E, 0x00, 0x1F, 0xBE,
  0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xF0,
  0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0x7E,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xC0, 0x1F, 0xE0, 0x07,
  0x00, 0x7F, 0x00, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x80, 0x00, 0x7F, 0x01, 0x80, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF3, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xE3, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xC3, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0x83, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0x3E, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x03, 0xE3, 0xF8, 0x00, 0xFC,
  0x7E, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0xFC, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xE0, 0x00, 0xFD,
  0xF8, 0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0, 0x03, 0xEF, 0xC0, 0x00, 0xFD,
  0xF0, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE,
  0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0,
  0x00, 0x1F, 0xE0, 0xF8, 0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xFE, 0x7E, 0x03,
  0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xDF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0x80,
  0x7F, 0xC0, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x9F,
  0x00, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0x87, 0xC0, 0x0F, 0xF8, 0x7C, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x07, 0xE7, 0xFF, 0x00, 0x7E,
  0x7F, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC1,
  0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x83, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0x7F, 0xFF, 0x81, 0xF9, 0xFF, 0xF8, 0x0F, 0x87, 0xFF, 0x00, 0x7C,
  0x1F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC,
  0x06, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x10, 0x7F, 0x80, 0x60, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0xF1,
  0xF8, 0x00, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xFD,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xBE,
  0x00, 0x3F, 0xFF, 0x3E, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x1F, 0xFC, 0x3E,
  0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE7,
  0xF8, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0,
  0x0F, 0xF3, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x0F, 0xF0, 0x07,
  0x03, 0xFF, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x3E, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0xF9, 0xF8,
  0x03, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xF7, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xE7, 0xE0,
  0x03, 0xFF, 0x8F, 0xC0, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x40, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x80,
  0x01, 0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0x01, 0xF9, 0xFF, 0xC0, 0x3F,
  0x3F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x07,
  0xF0, 0x3F, 0xE0, 0x3F, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0x8F, 0xFE, 0x07, 0xFF,
  0x00, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xCF, 0xFF, 0xE0,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x83, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F,
  0x83, 0xFC, 0x00, 0xFC, 0x7F, 0xF8, 0x07, 0xE7, 0xFF, 0xC0, 0x3E, 0x7F,
  0xFF, 0x01, 0xF7, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xC0, 0xFF, 0xC0, 0x7E,
  0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFD, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x3E,
  0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7C, 0xFF, 0xFC, 0x00, 0x7D,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0x80, 0x1F, 0x8F,
  0xFE, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xF8, 0x03, 0xFF,
  0x87, 0xC0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xDF,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F,
  0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0x00, 0xFF, 0xF9, 0xF8, 0x03, 0xFF,
  0x8F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x0C, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0xFE, 0x03, 0xE3, 0xFC, 0x0F, 0xCF, 0xF8, 0x1F, 0x3F, 0xF0,
  0x3E, 0xFF, 0xC0, 0x7D, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xE0, 0x0C, 0x0F, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xF0, 0xE0, 0x0F, 0xF0, 0xFF,
  0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x03, 0xFE,
  0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0x7C, 0x0F, 0xFF, 0xE7, 0xC0, 0x7F,
  0xFC, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xF0, 0xF8, 0x00, 0x30, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0xFC,
  0x07, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xFE,
  0x03, 0xF0, 0xFC, 0x0F, 0xBE, 0x03, 0xF0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0,
  0xFC, 0x1F, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x3E, 0x07, 0xE0, 0xFC, 0x3F,
  0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x3E, 0x1F,
  0x80, 0xFC, 0x7C, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x3E, 0x3F, 0x00, 0xFC,
  0xF8, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x3E,
  0x7E, 0x00, 0xFD, 0xF0, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x3E, 0xFC, 0x00,
  0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x00, 0xFB, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x23, 0xFF, 0x00, 0x05, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF6, 0x00, 0x1F, 0xFC,
  0x80, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 45, 16, 1, -44 },
  { 91, 19, 16, 24, 6, -44 },
  { 129, 35, 44, 35, 1, -44 },
  { 322, 29, 50, 30, 1, -46 },
  { 504, 39, 45, 46, 4, -44 },
  { 724, 34, 45, 37, 1, -44 },
  { 916, 9, 16, 13, 6, -44 },
  { 934, 20, 54, 18, 2, -44 },
  { 1069, 21, 54, 18, -5, -44 },
  { 1211, 25, 27, 30, 6, -47 },
  { 1296, 27, 29, 32, 3, -36 },
  { 1394, 13, 15, 15, -3, -7 },
  { 1419, 16, 5, 18, 1, -19 },
  { 1429, 8, 9, 15, 1, -8 },
  { 1438, 30, 44, 22, -3, -44 },
  { 1603, 28, 45, 30, 2, -44 },
  { 1761, 19, 44, 30, 7, -44 },
  { 1866, 31, 44, 30, -1, -44 },
  { 2037, 30, 45, 30, 0, -44 },
  { 2206, 30, 44, 30, 0, -44 },
  { 2371, 29, 45, 30, 1, -44 },
  { 2535, 28, 45, 30, 3, -44 },
  { 2693, 29, 44, 30, 3, -44 },
  { 2853, 29, 45, 30, 1, -44 },
  { 3017, 27, 45, 30, 2, -44 },
  { 3169, 13, 34, 15, 1, -33 },
  { 3225, 17, 41, 15, -3, -33 },
  { 3313, 27, 30, 32, 3, -37 },
  { 3415, 26, 17, 32, 4, -30 },
  { 3471, 27, 30, 32, 3, -37 },
  { 3573, 23, 45, 24, 3, -44 },
  { 3703, 43, 49, 46, 2, -44 },
  { 3967, 32, 44, 32, -4, -44 },
  { 4143, 32, 44, 33, 1, -44 },
  { 4319, 32, 45, 32, 3, -44 },
  { 4499, 34, 44, 37, 1, -44 },
  { 4686, 30, 44, 29, 1, -44 },
  { 4851, 30, 44, 27, 1, -44 },
  { 5016, 35, 45, 38, 3, -44 },
  { 5213, 37, 44, 38, 1, -44 },
  { 5417, 25, 44, 19, -2, -44 },
  { 5555, 26, 56, 16, -9, -44 },
  { 5737, 36, 44, 32, 1, -44 },
  { 5935, 22, 44, 27, 1, -44 },
  { 6056, 47, 44, 48, 1, -44 },
  { 6315, 39, 44, 40, 1, -44 },
  { 6530, 35, 45, 39, 3, -44 },
  { 6727, 31, 44, 32, 1, -44 },
  { 6898, 35, 54, 39, 3, -44 },
  { 7135, 31, 44, 32, 1, -44 },
  { 7306, 30, 45, 28, 0, -44 },
  { 7475, 28, 44, 28, 5, -44 },
  { 7629, 34, 45, 37, 4, -44 },
  { 7821, 32, 44, 31, 5, -44 },
  { 7997, 48, 44, 48, 6, -44 },
  { 8261, 38, 44, 30, -3, -44 },
  { 8470, 29, 44, 29, 5, -44 },
  { 8630, 34, 44, 28, -2, -44 },
  { 8817, 24, 54, 18, -1, -44 },
  { 8979, 12, 44, 22, 6, -44 },
  { 9045, 23, 54, 18, -4, -44 },
  { 9201, 29, 27, 31, 1, -44 },
  { 9299, 24, 4, 22, -6, 5 },
  { 9311, 10, 10, 17, 9, -47 },
  { 9324, 29, 34, 32, 2, -33 },
  { 9448, 29, 47, 32, 1, -46 },
  { 9619, 24, 34, 25, 2, -33 },
  { 9721, 32, 47, 32, 2, -46 },
  { 9909, 25, 34, 29, 2, -33 },
  { 10016, 33, 62, 18, -7, -47 },
  { 10272, 31, 48, 32, 0, -33 },
  { 10458, 28, 46, 32, 1, -46 },
  { 10619, 15, 45, 15, 1, -45 },
  { 10704, 24, 60, 15, -8, -45 },
  { 10884, 30, 46, 28, 1, -46 },
  { 11057, 16, 46, 15, 1, -46 },
  { 11149, 45, 33, 48, 1, -33 },
  { 11335, 29, 34, 32, 1, -34 },
  { 11459, 27, 34, 31, 2, -33 },
  { 11574, 32, 48, 32, -2, -33 },
  { 11766, 29, 48, 32, 2, -33 },
  { 11940, 23, 33, 22, 1, -33 },
  { 12035, 24, 34, 25, 0, -33 },
  { 12137, 18, 41, 19, 3, -40 },
  { 12230, 28, 34, 32, 3, -33 },
  { 12349, 27, 33, 26, 3, -33 },
  { 12461, 40, 33, 41, 4, -33 },
  { 12626, 33, 33, 27, -3, -33 },
  { 12763, 35, 48, 27, -5, -33 },
  { 12973, 26, 33, 24, -1, -33 },
  { 13081, 24, 54, 21, 1, -44 },
  { 13243, 5, 60, 30, 13, -46 },
  { 13281, 23, 54, 21, -3, -44 },
  { 13437, 27, 9, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC61PT7B_H_
