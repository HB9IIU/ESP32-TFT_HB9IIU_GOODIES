#ifndef _NOTOSANS_SEMICONDENSED_MEDIUMITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x01, 0x00, 0x7C, 0x7B, 0xC7,
  0xDE, 0x3E, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7,
  0x0F, 0x38, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x01,
  0xE0, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0,
  0x3C, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFB,
  0x8C, 0x0F, 0x1C, 0x20, 0x78, 0xC0, 0x03, 0xC6, 0x00, 0x1E, 0x30, 0x00,
  0xF3, 0x80, 0x07, 0xDC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x06, 0x7C, 0x00,
  0x73, 0xE0, 0x03, 0x8F, 0x00, 0x18, 0x78, 0x00, 0xC7, 0xC4, 0x06, 0x3C,
  0x38, 0x73, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x1F, 0xF0,
  0x07, 0x83, 0xEF, 0x80, 0x70, 0x3C, 0x78, 0x0F, 0x07, 0x87, 0x81, 0xE0,
  0x78, 0x78, 0x1C, 0x07, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x78, 0x0F, 0x07,
  0x87, 0x00, 0xF0, 0x70, 0xF0, 0x0F, 0x07, 0x1E, 0x00, 0xE0, 0xF1, 0xC0,
  0x0E, 0x0F, 0x3C, 0x7C, 0xE1, 0xE7, 0x9F, 0xEF, 0x1E, 0x73, 0xFF, 0xF3,
  0xCF, 0x3C, 0xF7, 0xF9, 0xE7, 0x87, 0x7F, 0x1C, 0x70, 0x71, 0xE3, 0xCF,
  0x07, 0x00, 0x78, 0xF0, 0x70, 0x07, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0xF0,
  0x1E, 0x1E, 0x0F, 0x01, 0xC1, 0xE0, 0xE0, 0x3C, 0x1E, 0x0E, 0x07, 0x81,
  0xE1, 0xE0, 0x70, 0x1E, 0x1C, 0x0F, 0x01, 0xE3, 0xC1, 0xE0, 0x0F, 0xF8,
  0x1C, 0x00, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x8F, 0xFE, 0x07, 0x8F, 0xCF, 0x07, 0xC7, 0xC7, 0xC3, 0xC7, 0xC1, 0xF3,
  0xE7, 0xC0, 0xF9, 0xE3, 0xE0, 0x3F, 0xF1, 0xE0, 0x1F, 0xF0, 0xF0, 0x07,
  0xF0, 0x78, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xFE, 0x0F, 0xE7,
  0xFF, 0x03, 0xFF, 0xF7, 0xC0, 0xFF, 0xF1, 0xF0, 0x3F, 0xE0, 0xFC, 0x7D,
  0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x40, 0xF0, 0x1C, 0x3C, 0x07, 0xCE, 0x03, 0xFF,
  0x81, 0x7F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0x70,
  0x07, 0xDE, 0x03, 0xE7, 0x81, 0xF0, 0xF0, 0x1C, 0x3C, 0x02, 0x0F, 0x80,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x37, 0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x1F,
  0x07, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0,
  0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x03,
  0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF8,
  0xFF, 0xCF, 0xEF, 0x1E, 0x3C, 0x31, 0xF0, 0x87, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xF0, 0xFC,
  0x07, 0x01, 0xF0, 0x08, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3C, 0x1F, 0x80, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF1, 0x80, 0x1F, 0x8F, 0x8F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00,
  0x3C, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF1, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x20, 0x07,
  0xE1, 0xF1, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x7C, 0x07, 0xDF, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF,
  0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x7E, 0x7E,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x7C, 0x1E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0,
  0x7C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7,
  0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x7F, 0x1F, 0x1F,
  0xE1, 0xFF, 0xDE, 0x0F, 0xFD, 0xE0, 0x7F, 0x3E, 0x00, 0x83, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0xF3, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xE0, 0x20, 0x00, 0x00, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xC1, 0xF0, 0x80,
  0x78, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x03,
  0xF0, 0x38, 0x78, 0x1F, 0xF8, 0x79, 0xE0, 0x7F, 0xF0, 0xF3, 0x81, 0xE1,
  0xE1, 0xEF, 0x07, 0x83, 0x83, 0xDE, 0x1E, 0x07, 0x07, 0xB8, 0x38, 0x1E,
  0x0E, 0x70, 0xF0, 0x3C, 0x1D, 0xE1, 0xE0, 0x70, 0x3B, 0xC3, 0x80, 0xE0,
  0xF7, 0x07, 0x03, 0xC1, 0xEE, 0x1E, 0x07, 0x83, 0x9C, 0x3C, 0x1E, 0x0F,
  0x38, 0x78, 0x3C, 0x1C, 0x70, 0x70, 0xFC, 0x78, 0xE0, 0xFF, 0xBF, 0xE1,
  0xE1, 0xFE, 0x7F, 0x83, 0xC1, 0xF8, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x04, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0,
  0x3E, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1E, 0x1F, 0xE0, 0x3C, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0x1F, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xE0, 0x1F, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC1,
  0xC0, 0x7E, 0x00, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x04, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F,
  0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F,
  0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3C, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xF0,
  0x7C, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xC0, 0xF0, 0x1F, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F,
  0xFC, 0x7C, 0x07, 0xFE, 0x3C, 0x03, 0xFF, 0x1E, 0x01, 0xFF, 0x9F, 0x00,
  0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x1F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xE0,
  0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0x7C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x23, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x87, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3D, 0xE0, 0x7B, 0x80, 0x0F, 0xF8, 0x1E, 0xE0,
  0x07, 0xBC, 0x07, 0xB8, 0x01, 0xEF, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0xF3,
  0xC0, 0x3D, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0xF3, 0xE0, 0x78, 0xF0, 0x78, 0xF8,
  0x1E, 0x3C, 0x1E, 0x3C, 0x07, 0x8F, 0x0F, 0x0F, 0x01, 0xE3, 0xC3, 0xC3,
  0xC0, 0xF8, 0x71, 0xE1, 0xF0, 0x3C, 0x1C, 0x78, 0x7C, 0x0F, 0x07, 0x3C,
  0x1E, 0x03, 0xC1, 0xEF, 0x07, 0x80, 0xF0, 0x7F, 0x81, 0xE0, 0x7C, 0x1F,
  0xE0, 0xF8, 0x1E, 0x07, 0xF0, 0x3E, 0x07, 0x81, 0xFC, 0x0F, 0x01, 0xE0,
  0x7E, 0x03, 0xC0, 0x78, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F,
  0x01, 0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03,
  0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x80,
  0x1E, 0x07, 0xFC, 0x03, 0xE0, 0x7B, 0xC0, 0x3E, 0x07, 0xBC, 0x03, 0xC0,
  0x7B, 0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x7C, 0x0F, 0x1E,
  0x07, 0x80, 0xF1, 0xF0, 0x78, 0x1F, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0x8F, 0x81, 0xE0, 0x78, 0xF0, 0x1E, 0x07, 0x8F, 0x03, 0xE0,
  0x78, 0xF0, 0x3C, 0x07, 0xCF, 0x03, 0xC0, 0x3D, 0xF0, 0x3C, 0x03, 0xDE,
  0x03, 0xC0, 0x3F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0x80, 0x1F, 0xE0, 0x78,
  0x01, 0xFE, 0x07, 0x80, 0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0xC0, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xC0, 0xFC, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xE1,
  0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0x87, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF1, 0xFE,
  0x03, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x07,
  0x80, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x00,
  0xF8, 0x3C, 0x07, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1F,
  0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xF0, 0xF0, 0x1F, 0x00, 0x40, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x08, 0x00, 0xF8, 0x38, 0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xE0, 0x78,
  0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3C,
  0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01,
  0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00,
  0xFB, 0xE0, 0x0F, 0xC0, 0x1E, 0x7C, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0x7F,
  0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x1E, 0x3E, 0x03, 0xFC, 0x07, 0xC7, 0xC0,
  0x7F, 0x80, 0xF0, 0xF8, 0x1E, 0xF0, 0x3E, 0x1F, 0x03, 0xDE, 0x07, 0x83,
  0xE0, 0x73, 0xC0, 0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x83, 0xCF, 0x07,
  0x81, 0xF0, 0xF1, 0xE1, 0xF0, 0x1E, 0x1E, 0x3C, 0x3C, 0x03, 0xC7, 0x87,
  0x8F, 0x80, 0x78, 0xF0, 0xF1, 0xE0, 0x0F, 0x1E, 0x1E, 0x3C, 0x01, 0xE7,
  0x83, 0xCF, 0x80, 0x3C, 0xF0, 0x79, 0xE0, 0x07, 0xBC, 0x0F, 0x7C, 0x00,
  0xF7, 0x81, 0xEF, 0x00, 0x1F, 0xE0, 0x3D, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x77, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x1E, 0x00,
  0xF8, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x07,
  0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF0,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xEE, 0x00,
  0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x38,
  0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x01, 0xC3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xC0, 0xF8, 0x7C, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x01, 0xF8,
  0x78, 0x1F, 0xE3, 0x81, 0xFF, 0xBC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7F, 0x1F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x03, 0xE3, 0xC0,
  0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x07, 0xE1,
  0xF0, 0x7F, 0x0F, 0xCF, 0xF0, 0x3F, 0xF7, 0x81, 0xFF, 0x3C, 0x07, 0xF1,
  0xE0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x7C, 0x03, 0xEF, 0xF8, 0x1E, 0xFF, 0xC0, 0xF7, 0xFF, 0x07,
  0xF0, 0xF8, 0x3F, 0x03, 0xC3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0,
  0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x7F, 0x8F, 0xC3, 0xDF, 0xFC, 0x1E, 0xFF,
  0xC0, 0xE1, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF8, 0x11, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0x07, 0xE7,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xF1, 0xF0,
  0x0F, 0xF3, 0xC0, 0x3F, 0xF7, 0x80, 0xFF, 0xFF, 0x03, 0xF0, 0xFE, 0x0F,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0,
  0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x01,
  0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x7E,
  0x07, 0x80, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x9F, 0xE0, 0x1F, 0xFB, 0xC0,
  0x3F, 0xE7, 0x80, 0x3F, 0x8F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0x3E, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7D, 0xF0, 0x1E,
  0x78, 0x0F, 0x9E, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x08, 0x7C, 0x1C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7C, 0x20, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x8F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x1E, 0x01, 0xFE, 0x38, 0x07, 0xFE, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F,
  0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78,
  0x0F, 0xC0, 0xF0, 0x1F, 0x81, 0xF0, 0x7F, 0x03, 0xF3, 0xFC, 0x03, 0xFF,
  0x78, 0x07, 0xFC, 0xF0, 0x07, 0xF3, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x10, 0x03, 0xE0,
  0x3C, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0xFC, 0x0F, 0xBF, 0xE0, 0xF7, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFE, 0x1F, 0x0F, 0xC0, 0xF1, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x03,
  0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x7C, 0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x0F, 0x80, 0x00, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x02, 0x3E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0,
  0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE3, 0xE0, 0x1E, 0x3E, 0x00,
  0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFD, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE1, 0xE0, 0x1E,
  0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0xF8, 0x0F, 0x3F, 0xC3, 0xFE,
  0x0F, 0x7F, 0xE7, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F,
  0x0F, 0xC1, 0xFC, 0x1F, 0x1F, 0x81, 0xF8, 0x1F, 0x1F, 0x01, 0xF0, 0x1F,
  0x1F, 0x01, 0xF0, 0x1F, 0x1E, 0x01, 0xE0, 0x1E, 0x3E, 0x01, 0xE0, 0x1E,
  0x3E, 0x03, 0xE0, 0x1E, 0x3C, 0x03, 0xE0, 0x3E, 0x3C, 0x03, 0xC0, 0x3C,
  0x3C, 0x03, 0xC0, 0x3C, 0x7C, 0x03, 0xC0, 0x3C, 0x7C, 0x07, 0xC0, 0x7C,
  0x78, 0x07, 0xC0, 0x7C, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x78,
  0xF8, 0x07, 0x80, 0x78, 0xF8, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x00, 0xF8,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x0F, 0xC0, 0xF3, 0xFE, 0x0F, 0x7F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xE1, 0xF1, 0xFC, 0x0F, 0x1F, 0x80, 0xF1, 0xF0, 0x0F,
  0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x01,
  0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0,
  0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF0,
  0x0F, 0x8F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x0F, 0x87, 0xE7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xE1, 0xF0, 0x01, 0xE7, 0xFC, 0x01, 0xEF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFC, 0x3E, 0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80,
  0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0xE3, 0xF0, 0x1E, 0xFF, 0xE0, 0x1E, 0x7F, 0xC0, 0x1E, 0x3F,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x78, 0x1F, 0xE3,
  0x81, 0xFF, 0xBC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7F, 0x1F, 0x81, 0xF0, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF1,
  0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x87, 0x80, 0xFC, 0x3C, 0x07, 0xE1, 0xF0, 0x7E, 0x0F,
  0xCF, 0xF0, 0x3F, 0xF7, 0x81, 0xFF, 0x3C, 0x07, 0xF3, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x07, 0x0F, 0x87, 0x9F, 0x83, 0xDF, 0xC1, 0xEF, 0xE0,
  0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFB, 0xE1, 0xF0, 0x10, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x90, 0x07,
  0xCF, 0x0F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0xC4, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0xF1,
  0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E,
  0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x01, 0xF8, 0xF0, 0x1F, 0x8F, 0x83, 0xF0, 0xFC,
  0xFF, 0x0F, 0xFE, 0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0xF0, 0xF8, 0x01, 0xFF,
  0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E,
  0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C,
  0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x01, 0xEF, 0x80, 0x3D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0xF8,
  0x07, 0xBC, 0x07, 0xC0, 0x7D, 0xE0, 0x7E, 0x03, 0xCF, 0x03, 0xF8, 0x3E,
  0x78, 0x3F, 0xC1, 0xE3, 0xC1, 0xDE, 0x0F, 0x1E, 0x1E, 0xF0, 0xF8, 0xF0,
  0xF7, 0x87, 0x87, 0x87, 0x3C, 0x7C, 0x3C, 0x79, 0xE3, 0xC1, 0xE3, 0x8F,
  0x1E, 0x0F, 0x3C, 0x79, 0xE0, 0x79, 0xE3, 0xCF, 0x03, 0xDE, 0x1E, 0xF0,
  0x1E, 0xF0, 0xF7, 0x80, 0xF7, 0x07, 0xBC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x1F, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E,
  0x00, 0x3E, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF8,
  0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x07,
  0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x01,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x02, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x06, 0x00, 0x13,
  0xFC, 0x01, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFC,
  0x80, 0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 32, 11, 1, -31 },
  { 45, 13, 11, 17, 5, -31 },
  { 63, 25, 31, 25, 1, -31 },
  { 160, 21, 36, 22, 1, -33 },
  { 255, 28, 32, 33, 3, -32 },
  { 367, 25, 32, 26, 1, -32 },
  { 467, 6, 11, 10, 5, -31 },
  { 476, 15, 39, 13, 1, -32 },
  { 550, 14, 39, 13, -3, -32 },
  { 619, 18, 19, 21, 4, -34 },
  { 662, 20, 21, 23, 2, -26 },
  { 715, 9, 11, 11, -2, -5 },
  { 728, 11, 4, 13, 1, -14 },
  { 734, 5, 7, 11, 1, -6 },
  { 739, 22, 32, 16, -2, -32 },
  { 827, 19, 32, 22, 2, -32 },
  { 903, 14, 31, 22, 5, -31 },
  { 958, 22, 32, 22, -1, -32 },
  { 1046, 21, 32, 22, 0, -32 },
  { 1130, 21, 32, 22, 0, -32 },
  { 1214, 21, 31, 22, 1, -31 },
  { 1296, 20, 32, 22, 2, -32 },
  { 1376, 21, 31, 22, 2, -31 },
  { 1458, 21, 32, 22, 1, -32 },
  { 1542, 20, 32, 22, 1, -32 },
  { 1622, 10, 25, 11, 0, -24 },
  { 1654, 12, 30, 11, -2, -24 },
  { 1699, 20, 21, 23, 2, -26 },
  { 1752, 19, 13, 23, 3, -22 },
  { 1783, 20, 21, 23, 2, -26 },
  { 1836, 17, 33, 17, 2, -32 },
  { 1907, 31, 36, 33, 2, -32 },
  { 2047, 24, 31, 23, -3, -31 },
  { 2140, 23, 31, 24, 1, -31 },
  { 2230, 23, 32, 23, 2, -32 },
  { 2322, 24, 31, 26, 1, -31 },
  { 2415, 21, 31, 21, 1, -31 },
  { 2497, 21, 31, 19, 1, -31 },
  { 2579, 25, 32, 27, 2, -32 },
  { 2679, 27, 31, 27, 1, -31 },
  { 2784, 18, 31, 14, -1, -31 },
  { 2854, 19, 40, 12, -7, -31 },
  { 2949, 26, 31, 23, 1, -31 },
  { 3050, 16, 31, 19, 1, -31 },
  { 3112, 34, 31, 34, 1, -31 },
  { 3244, 28, 31, 29, 1, -31 },
  { 3353, 25, 32, 28, 2, -32 },
  { 3453, 22, 31, 23, 1, -31 },
  { 3539, 25, 39, 28, 2, -32 },
  { 3661, 22, 31, 23, 1, -31 },
  { 3747, 22, 32, 21, 0, -32 },
  { 3835, 20, 31, 20, 4, -31 },
  { 3913, 25, 31, 27, 3, -31 },
  { 4010, 22, 31, 22, 4, -31 },
  { 4096, 35, 31, 35, 4, -31 },
  { 4232, 27, 31, 22, -2, -31 },
  { 4337, 21, 31, 21, 4, -31 },
  { 4419, 24, 31, 21, -1, -31 },
  { 4512, 17, 39, 13, -1, -32 },
  { 4595, 8, 32, 16, 5, -32 },
  { 4627, 17, 39, 13, -3, -32 },
  { 4710, 20, 20, 22, 1, -32 },
  { 4760, 17, 3, 16, -4, 4 },
  { 4767, 8, 7, 12, 6, -34 },
  { 4774, 21, 24, 23, 2, -24 },
  { 4837, 21, 33, 23, 1, -33 },
  { 4924, 17, 24, 18, 2, -24 },
  { 4975, 23, 33, 23, 2, -33 },
  { 5070, 18, 24, 21, 2, -24 },
  { 5124, 23, 45, 13, -5, -34 },
  { 5254, 23, 35, 23, 0, -24 },
  { 5355, 20, 33, 23, 1, -33 },
  { 5438, 11, 33, 11, 1, -33 },
  { 5484, 18, 44, 11, -6, -33 },
  { 5583, 21, 33, 21, 1, -33 },
  { 5670, 11, 33, 11, 1, -33 },
  { 5716, 32, 24, 35, 1, -24 },
  { 5812, 20, 24, 23, 1, -24 },
  { 5872, 19, 24, 23, 2, -24 },
  { 5929, 24, 34, 23, -2, -24 },
  { 6031, 21, 35, 23, 2, -24 },
  { 6123, 17, 24, 16, 1, -24 },
  { 6174, 17, 24, 18, 0, -24 },
  { 6225, 13, 29, 14, 2, -29 },
  { 6273, 20, 24, 23, 2, -24 },
  { 6333, 19, 24, 19, 2, -24 },
  { 6390, 29, 24, 30, 3, -24 },
  { 6477, 23, 24, 20, -2, -24 },
  { 6546, 25, 35, 19, -4, -24 },
  { 6656, 19, 24, 17, -1, -24 },
  { 6713, 17, 38, 15, 1, -31 },
  { 6794, 4, 43, 21, 9, -33 },
  { 6816, 17, 38, 15, -2, -31 },
  { 6897, 20, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_MediumItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUMITALIC44PT7B_H_
