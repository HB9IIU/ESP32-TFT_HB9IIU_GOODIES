#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x0C, 0x60,
  0x31, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x40, 0x63, 0x01, 0x8C, 0x06, 0x30,
  0x10, 0x80, 0x42, 0x03, 0x18, 0x0C, 0x60, 0x21, 0x00, 0x84, 0x02, 0x10,
  0x18, 0xC0, 0x63, 0x01, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1C, 0x30, 0x78, 0x03, 0x81, 0x80, 0x40, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0x40, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x38, 0x00, 0x00,
  0x08, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x01, 0xC0, 0x40, 0x08, 0x1C, 0x03, 0xC0, 0xC3, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x60, 0x0F, 0x78, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x02, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0x0C, 0x01, 0x80, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xC0,
  0x01, 0x80, 0x06, 0x0C, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0xFE, 0x60, 0x03,
  0x06, 0x1C, 0x3B, 0x00, 0x18, 0x61, 0xC0, 0x78, 0x01, 0x83, 0x0C, 0x03,
  0xC0, 0x0C, 0x30, 0xC0, 0x1E, 0x00, 0xC3, 0x06, 0x00, 0x78, 0x0C, 0x18,
  0x60, 0x02, 0xC0, 0xC1, 0x83, 0x00, 0x13, 0xFC, 0x18, 0x30, 0x00, 0x8F,
  0xC0, 0xC1, 0x80, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x00, 0xC0, 0xC0,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x06,
  0x01, 0x00, 0x06, 0x00, 0x30, 0x18, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x03, 0x00,
  0x00, 0xE1, 0xC0, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x30, 0xE0, 0x0C, 0x00,
  0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x0C, 0x60, 0x00, 0x60,
  0x04, 0x70, 0x00, 0x18, 0x06, 0x30, 0x00, 0x0C, 0x06, 0x10, 0x00, 0x03,
  0x03, 0x18, 0x00, 0x01, 0x83, 0x0C, 0x00, 0x00, 0x61, 0x86, 0x00, 0x00,
  0x31, 0x83, 0x00, 0x00, 0x0D, 0x81, 0x80, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xF0, 0x18, 0x00,
  0x00, 0xCC, 0x06, 0x00, 0x01, 0xC6, 0x03, 0x80, 0x01, 0xC1, 0x80, 0xE0,
  0x03, 0x80, 0xC0, 0x3C, 0x07, 0x80, 0x30, 0x0F, 0xFF, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82,
  0x18, 0x61, 0x04, 0x10, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x0C,
  0x00, 0x38, 0x08, 0x00, 0x0E, 0x08, 0x00, 0x03, 0x08, 0x00, 0x01, 0xC8,
  0x0F, 0x00, 0x73, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x68, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0x84, 0x00, 0x03, 0x04, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x02,
  0x00, 0x38, 0x03, 0x00, 0x30, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x02, 0x03, 0x01,
  0x01, 0x80, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00,
  0xF0, 0x07, 0x60, 0x1C, 0xC0, 0x61, 0x03, 0x86, 0x0E, 0x0C, 0x70, 0x19,
  0xC0, 0x31, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF7, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x10, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x33, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x01, 0x83, 0xFF,
  0x80, 0x08, 0x78, 0x0E, 0x00, 0xC7, 0x00, 0x18, 0x06, 0x60, 0x00, 0x60,
  0x36, 0x00, 0x01, 0x81, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x03, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x1E, 0x06, 0x00, 0x01, 0xA0, 0x30, 0x00, 0x19, 0x00, 0xC0, 0x01,
  0x98, 0x03, 0x00, 0x38, 0xC0, 0x0F, 0xBF, 0x04, 0x00, 0x3F, 0xE0, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x03,
  0xC0, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0x7E, 0x07, 0x00, 0x38, 0x10, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0x78,
  0x03, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x31, 0x80, 0x07, 0x00, 0x30, 0x03,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x33, 0x00, 0x30, 0x00, 0x60, 0x03, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x36, 0x00, 0x60, 0x00, 0x40, 0x03, 0x60, 0x06, 0x00,
  0x0C, 0x00, 0x66, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x60, 0x0C, 0x00, 0x0C,
  0x00, 0x64, 0x00, 0xC0, 0x00, 0x80, 0x06, 0xC0, 0x08, 0x00, 0x18, 0x00,
  0xCC, 0x01, 0x80, 0x01, 0x80, 0x0C, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xCC,
  0x01, 0x80, 0x03, 0x00, 0x18, 0xC0, 0x18, 0x00, 0x30, 0x01, 0x8C, 0x01,
  0x80, 0x07, 0x00, 0x30, 0xC0, 0x18, 0x00, 0xD0, 0x03, 0x0C, 0x01, 0x80,
  0x0D, 0x00, 0x60, 0xC0, 0x0C, 0x01, 0x90, 0x0C, 0x0C, 0x00, 0xC0, 0x31,
  0x81, 0x80, 0xC0, 0x07, 0x0E, 0x1C, 0x70, 0x0C, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x60, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x08, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x02, 0x38, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x01, 0xE0, 0x03, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x06, 0x00,
  0x3F, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x03, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x60, 0x00, 0x0F,
  0xFF, 0x86, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x03, 0xE4, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x20, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x03, 0x1E, 0x00, 0x00, 0x00, 0x23, 0x30, 0x00, 0x00, 0x06, 0x63,
  0x00, 0x00, 0x00, 0x6C, 0x18, 0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x44, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0xC4, 0x00, 0x00, 0x01, 0x88, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x98,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x86, 0x00, 0x00, 0x06, 0x18, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x01, 0x82, 0x00, 0x00, 0x18, 0x30,
  0x01, 0x02, 0x00, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x00, 0x30, 0x20,
  0x03, 0x03, 0x00, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x06, 0x01, 0x00, 0x01, 0x80, 0x40, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0,
  0x06, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x04, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04, 0x00, 0x80,
  0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x80, 0x02, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x43, 0x00, 0x06, 0x00, 0x30, 0x00, 0x43, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x66, 0x00, 0x06, 0x00, 0x60, 0x00, 0x66, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x6C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x02, 0xC0, 0x00, 0x00, 0xC0, 0x0D, 0x80, 0x00, 0x01, 0x80,
  0x1B, 0x00, 0x00, 0x02, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x00, 0x66, 0x00,
  0x00, 0x18, 0x00, 0x8C, 0x00, 0x00, 0x30, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0x06, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x00, 0x10,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x04, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x06, 0x00, 0x04,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x01, 0x80, 0x30, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x08, 0x00, 0xC0, 0x00, 0x18,
  0x30, 0x01, 0x80, 0x00, 0x30, 0x60, 0x02, 0x00, 0x00, 0x30, 0xC0, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x18, 0x00, 0x00, 0x42, 0x00, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x60, 0x00, 0x01, 0x98, 0x00, 0x80, 0x00, 0x01, 0x30, 0x03,
  0x00, 0x00, 0x03, 0x60, 0x06, 0x00, 0x00, 0x06, 0x80, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xC0,
  0x0F, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xC0, 0x0F, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x80,
  0x0C, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x02, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x40, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x06, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x0C, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x40, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x20,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x41, 0x80, 0x00, 0x61, 0x80, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x43, 0x00, 0x00, 0x63, 0x00, 0x00, 0x42, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x62, 0x00, 0x00, 0x46, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x40, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x08, 0x02, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x38, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0x81, 0x83, 0x03,
  0x02, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0x81, 0x00, 0x3C, 0x1C, 0x30, 0x07, 0x00, 0x63, 0x00, 0xC0, 0x03, 0x30,
  0x18, 0x00, 0x32, 0x03, 0x00, 0x01, 0x60, 0x60, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x40, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x06, 0xC0, 0x60, 0x00,
  0xCC, 0x07, 0x00, 0x18, 0x80, 0x38, 0x03, 0x08, 0x01, 0xC0, 0xE1, 0x80,
  0x0F, 0xF8, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x03,
  0x0F, 0x0F, 0x00, 0x08, 0x70, 0x06, 0x00, 0x63, 0x00, 0x0C, 0x01, 0x98,
  0x00, 0x30, 0x06, 0xC0, 0x00, 0x60, 0x16, 0x00, 0x01, 0x80, 0x58, 0x00,
  0x02, 0x03, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x0E, 0x02,
  0xC0, 0x00, 0x30, 0x19, 0x00, 0x01, 0x80, 0x66, 0x00, 0x0C, 0x01, 0x8C,
  0x00, 0xE0, 0x04, 0x1C, 0x0F, 0x00, 0x10, 0x3F, 0xF0, 0x00, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x0F,
  0x01, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x0F, 0xF8, 0x18, 0x00, 0x3C, 0x1E, 0x18, 0x00, 0x70, 0x07, 0x18,
  0x00, 0xC0, 0x03, 0x90, 0x01, 0x80, 0x01, 0xB0, 0x03, 0x00, 0x00, 0xB0,
  0x06, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x36, 0x00,
  0x60, 0x00, 0x66, 0x00, 0x60, 0x00, 0xE4, 0x00, 0x70, 0x01, 0xC4, 0x00,
  0x38, 0x03, 0x8C, 0x00, 0x1C, 0x0E, 0x0C, 0x00, 0x0F, 0xFC, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00,
  0x03, 0x07, 0x00, 0x01, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x1C, 0x20, 0x00, 0x78, 0x60, 0x01, 0xE0, 0x60, 0x1F, 0x80, 0x7F, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x20, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x04, 0x00, 0x3C, 0x1E, 0x18, 0x00,
  0xE0, 0x0E, 0x30, 0x03, 0x00, 0x0C, 0x40, 0x0C, 0x00, 0x0C, 0x80, 0x30,
  0x00, 0x0B, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x06, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x03, 0x60, 0x0C,
  0x00, 0x0E, 0xC0, 0x18, 0x00, 0x39, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x38,
  0x03, 0x8C, 0x00, 0x38, 0x1C, 0x18, 0x00, 0x3F, 0xF0, 0x30, 0x00, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x81, 0xFF, 0x00, 0x30,
  0xF0, 0x70, 0x04, 0x30, 0x03, 0x01, 0x8C, 0x00, 0x30, 0x33, 0x00, 0x06,
  0x06, 0xC0, 0x00, 0xC0, 0xB0, 0x00, 0x08, 0x1C, 0x00, 0x01, 0x07, 0x80,
  0x00, 0x20, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x00, 0x00, 0x10, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x47, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x0C, 0x00, 0x0E, 0x00, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x01, 0x80,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x04, 0x3C, 0x00, 0x00, 0xC6, 0xC0, 0x00, 0x0C,
  0xC6, 0x00, 0x00, 0xD8, 0x60, 0x00, 0x0B, 0x02, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x03, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x08, 0x78, 0x78, 0x0E, 0x0F, 0x00, 0x23, 0x80, 0x60,
  0xE0, 0x0C, 0x01, 0x98, 0x00, 0xC7, 0x00, 0x18, 0x06, 0xC0, 0x03, 0x18,
  0x00, 0x60, 0x1A, 0x00, 0x04, 0xC0, 0x00, 0x80, 0x58, 0x00, 0x1E, 0x00,
  0x02, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x20, 0x38, 0x00, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x0C, 0x0F, 0xF8, 0x00, 0x83, 0xC3, 0xC0, 0x08,
  0x60, 0x06, 0x01, 0x9C, 0x00, 0x30, 0x19, 0x80, 0x03, 0x01, 0xB0, 0x00,
  0x30, 0x16, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x10, 0x3C, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x02, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x18, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x0F, 0xF8, 0x00, 0x04, 0x1E, 0x1E, 0x00, 0x02, 0x1C, 0x01, 0x80,
  0x03, 0x18, 0x00, 0x60, 0x01, 0x98, 0x00, 0x30, 0x00, 0xD8, 0x00, 0x0C,
  0x00, 0x5C, 0x00, 0x06, 0x00, 0x2C, 0x00, 0x01, 0x00, 0x3C, 0x00, 0x00,
  0xC0, 0x1E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x0B, 0x00, 0x00, 0xC0, 0x0C, 0x80, 0x00, 0xC0, 0x06,
  0x60, 0x00, 0xC0, 0x03, 0x18, 0x01, 0xC0, 0x01, 0x87, 0x03, 0xC0, 0x00,
  0x81, 0xFF, 0x80, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xC0, 0x0F, 0x07, 0x86, 0x00, 0xE0, 0x0E,
  0x30, 0x1C, 0x00, 0x31, 0x00, 0xC0, 0x00, 0xC8, 0x0C, 0x00, 0x02, 0xC0,
  0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0xD8, 0x0C, 0x00, 0x0E, 0xC0, 0x60, 0x00, 0xE4, 0x03, 0x80, 0x0E,
  0x20, 0x0E, 0x00, 0xE3, 0x00, 0x38, 0x1C, 0x18, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC1, 0xFE, 0x01, 0x07, 0x84, 0x02, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0x36, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0xF8, 0x1F, 0x01, 0xC0, 0x03, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00,
  0xC0, 0xC0, 0x01, 0xC0, 0xF8, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x40, 0x7F, 0x80, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x08, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x10, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x3C, 0x0C, 0x00, 0x02, 0xC0, 0xC0, 0x00, 0x68, 0x0C, 0x00, 0x0C,
  0x80, 0x60, 0x01, 0x98, 0x06, 0x00, 0x71, 0x80, 0x38, 0x1E, 0x18, 0x01,
  0xFF, 0x81, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x40, 0x00,
  0x60, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x20, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x31, 0x80, 0x00, 0x13, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x16, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x2C, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x00, 0x14,
  0x00, 0x04, 0xC0, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0xCC,
  0x00, 0x19, 0x00, 0x06, 0x30, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x03, 0x10,
  0x00, 0xC3, 0x00, 0x0C, 0x40, 0x03, 0x0C, 0x00, 0x61, 0x00, 0x08, 0x30,
  0x01, 0x84, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x30, 0x60,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x04, 0x06, 0x01, 0x80,
  0xC0, 0x10, 0x18, 0x06, 0x02, 0x00, 0x40, 0x40, 0x18, 0x18, 0x01, 0x03,
  0x00, 0x60, 0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x10, 0x60, 0x02, 0x0C,
  0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20,
  0x00, 0x8C, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x47, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x83, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x70,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0E, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 49, 14, 2, -49 },
  { 81, 14, 18, 20, 7, -49 },
  { 113, 34, 49, 36, 2, -49 },
  { 322, 29, 56, 32, 2, -52 },
  { 525, 37, 50, 46, 5, -49 },
  { 757, 33, 50, 37, 2, -49 },
  { 964, 6, 18, 11, 7, -49 },
  { 978, 19, 59, 16, 2, -48 },
  { 1119, 18, 59, 16, -4, -48 },
  { 1252, 24, 24, 31, 8, -51 },
  { 1324, 28, 32, 34, 4, -40 },
  { 1436, 9, 16, 12, -3, -7 },
  { 1454, 16, 1, 20, 2, -19 },
  { 1456, 3, 4, 13, 2, -4 },
  { 1458, 29, 48, 20, -3, -48 },
  { 1632, 28, 50, 32, 3, -49 },
  { 1807, 15, 49, 32, 10, -49 },
  { 1899, 30, 49, 32, 0, -49 },
  { 2083, 31, 50, 32, 0, -49 },
  { 2277, 31, 49, 32, 0, -49 },
  { 2467, 31, 50, 32, 1, -49 },
  { 2661, 29, 50, 32, 3, -49 },
  { 2843, 28, 49, 32, 6, -49 },
  { 3015, 30, 50, 32, 2, -49 },
  { 3203, 29, 50, 32, 2, -49 },
  { 3385, 11, 36, 13, 1, -36 },
  { 3435, 15, 45, 13, -3, -36 },
  { 3520, 28, 29, 34, 4, -39 },
  { 3622, 28, 16, 34, 4, -32 },
  { 3678, 28, 29, 34, 4, -39 },
  { 3780, 21, 49, 23, 4, -49 },
  { 3909, 44, 54, 49, 3, -48 },
  { 4206, 32, 49, 32, -4, -49 },
  { 4402, 32, 49, 35, 2, -49 },
  { 4598, 33, 50, 34, 5, -49 },
  { 4805, 35, 49, 39, 2, -49 },
  { 5020, 32, 49, 31, 2, -49 },
  { 5216, 32, 49, 29, 2, -49 },
  { 5412, 36, 50, 41, 4, -49 },
  { 5637, 38, 49, 40, 2, -49 },
  { 5870, 21, 49, 16, -1, -49 },
  { 5999, 25, 61, 14, -11, -49 },
  { 6190, 36, 49, 32, 2, -49 },
  { 6411, 21, 49, 29, 2, -49 },
  { 6540, 48, 49, 49, 2, -49 },
  { 6834, 39, 49, 41, 2, -49 },
  { 7073, 36, 50, 42, 4, -49 },
  { 7298, 31, 49, 33, 2, -49 },
  { 7488, 36, 61, 42, 4, -49 },
  { 7763, 31, 49, 33, 2, -49 },
  { 7953, 31, 50, 30, 0, -49 },
  { 8147, 28, 49, 28, 6, -49 },
  { 8319, 36, 50, 40, 5, -49 },
  { 8544, 30, 49, 32, 7, -49 },
  { 8728, 48, 49, 50, 7, -49 },
  { 9022, 38, 49, 29, -4, -49 },
  { 9255, 28, 49, 28, 6, -49 },
  { 9427, 35, 49, 31, -1, -49 },
  { 9642, 25, 60, 20, -1, -49 },
  { 9830, 10, 49, 21, 7, -49 },
  { 9892, 25, 60, 20, -5, -49 },
  { 10080, 28, 28, 33, 3, -49 },
  { 10178, 23, 2, 23, -6, 7 },
  { 10184, 7, 11, 15, 10, -52 },
  { 10194, 28, 38, 33, 3, -37 },
  { 10327, 30, 53, 34, 1, -52 },
  { 10526, 24, 38, 26, 3, -37 },
  { 10640, 32, 53, 34, 3, -52 },
  { 10852, 24, 38, 29, 3, -37 },
  { 10966, 34, 68, 16, -9, -52 },
  { 11255, 31, 53, 34, 1, -37 },
  { 11461, 27, 52, 33, 2, -52 },
  { 11637, 13, 49, 13, 1, -49 },
  { 11717, 23, 65, 13, -9, -49 },
  { 11904, 28, 52, 26, 1, -52 },
  { 12086, 13, 52, 13, 1, -52 },
  { 12171, 46, 37, 50, 1, -37 },
  { 12384, 28, 37, 33, 1, -37 },
  { 12514, 27, 38, 33, 3, -37 },
  { 12643, 33, 53, 34, -2, -37 },
  { 12862, 29, 53, 34, 3, -37 },
  { 13055, 23, 36, 22, 1, -36 },
  { 13159, 24, 38, 25, 0, -37 },
  { 13273, 16, 46, 18, 3, -45 },
  { 13365, 28, 37, 33, 3, -36 },
  { 13495, 24, 36, 24, 4, -36 },
  { 13603, 38, 36, 40, 4, -36 },
  { 13774, 31, 36, 27, -3, -36 },
  { 13914, 36, 53, 25, -8, -36 },
  { 14153, 26, 36, 24, -1, -36 },
  { 14270, 24, 60, 22, 2, -49 },
  { 14450, 2, 68, 32, 16, -52 },
  { 14467, 24, 59, 22, -4, -48 },
  { 14644, 28, 6, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC68PT7B_H_
