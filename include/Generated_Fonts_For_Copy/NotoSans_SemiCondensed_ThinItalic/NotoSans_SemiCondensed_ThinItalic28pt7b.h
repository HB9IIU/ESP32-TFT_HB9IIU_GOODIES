#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x00, 0x00,
  0x21, 0x00, 0x45, 0x14, 0x92, 0x8A, 0x29, 0x00, 0x01, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x20, 0x10, 0x87, 0xFF, 0xC2, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x20, 0x10, 0x83, 0xFF, 0xC2, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x20, 0x10, 0x80, 0x00, 0x80, 0x08, 0x07, 0xE0,
  0x91, 0x11, 0x02, 0x10, 0x22, 0x02, 0x20, 0x12, 0x01, 0xA0, 0x04, 0x00,
  0x30, 0x04, 0x80, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x88, 0x89, 0x07,
  0xE0, 0x08, 0x01, 0x00, 0x10, 0x00, 0x1E, 0x06, 0x44, 0x09, 0x08, 0x22,
  0x10, 0x84, 0x21, 0x10, 0x44, 0x20, 0x88, 0x41, 0x20, 0x84, 0x9F, 0x09,
  0x46, 0x24, 0x8B, 0x92, 0x10, 0x24, 0x20, 0x88, 0x42, 0x20, 0x84, 0x41,
  0x10, 0x82, 0x41, 0x08, 0x82, 0x12, 0x03, 0xC0, 0x03, 0xC0, 0x21, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x21, 0x01, 0x10, 0x07, 0x00, 0x60,
  0x04, 0x80, 0x44, 0x14, 0x10, 0xC0, 0x4A, 0x02, 0x50, 0x0C, 0x80, 0x44,
  0x03, 0x20, 0x68, 0xFC, 0x20, 0x55, 0xA8, 0x03, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02, 0x01, 0x0C, 0x40, 0x90,
  0x1F, 0xC3, 0x01, 0x40, 0x88, 0x42, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x24, 0xA5, 0x20, 0xFC, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0x84, 0x08, 0x41, 0x03, 0xE0, 0x04, 0x72, 0x72, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x07, 0xE0,
  0x40, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x40, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60, 0x78, 0x00,
  0x30, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x20, 0x20, 0xFE, 0x00, 0x00, 0x18, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x09,
  0x00, 0x88, 0x08, 0x80, 0x84, 0x04, 0x20, 0x41, 0x04, 0x10, 0x40, 0x82,
  0x04, 0x20, 0x23, 0xFF, 0xE0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x1F, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x20, 0x20, 0xFE, 0x00, 0x01, 0xF0,
  0x60, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x4F, 0x85,
  0x04, 0x60, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x44,
  0x08, 0x40, 0x83, 0xF0, 0x7F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xC0,
  0x82, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x20, 0x84, 0x09, 0x80,
  0x60, 0x19, 0x02, 0x08, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x04, 0x40, 0x83, 0xF0, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x20, 0x61, 0xFA, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x13, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x10, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x00, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x40, 0x00, 0x00, 0x00, 0x80, 0x80,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x12, 0x0F, 0xC4, 0x84, 0x11, 0x42, 0x08, 0x50, 0x82, 0x14, 0x40,
  0x86, 0x10, 0x41, 0x84, 0x10, 0x61, 0x04, 0x28, 0x43, 0x0A, 0x11, 0x44,
  0x83, 0x8E, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x09,
  0x00, 0x48, 0x04, 0x40, 0x22, 0x02, 0x08, 0x10, 0x41, 0x02, 0x0F, 0xF0,
  0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x03, 0x80,
  0x10, 0x0F, 0xE0, 0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x24, 0x02, 0x20, 0x61, 0xFC, 0x08, 0x18, 0x40, 0x44, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x40, 0x24, 0x02, 0x20, 0x21, 0xFE, 0x00, 0x03, 0xF8,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x20, 0x40, 0x80,
  0x84, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40,
  0x22, 0x01, 0x08, 0x18, 0x3F, 0x80, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xF0, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x03, 0xFC, 0x08, 0x04, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xE4, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x10, 0x80, 0x20, 0x80, 0x40,
  0xFF, 0x00, 0x08, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x3F, 0xFC, 0x20, 0x04,
  0x20, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x10, 0x0F, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x40, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x00, 0x08, 0x04,
  0x20, 0x21, 0x01, 0x04, 0x08, 0x10, 0x40, 0x42, 0x01, 0x10, 0x08, 0x80,
  0x24, 0x00, 0xB0, 0x03, 0x20, 0x08, 0x80, 0x41, 0x01, 0x04, 0x04, 0x10,
  0x10, 0x20, 0x40, 0x82, 0x01, 0x08, 0x04, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x1F, 0xF0, 0x08, 0x00, 0x21, 0x00,
  0x0C, 0x50, 0x01, 0x8A, 0x00, 0x51, 0x40, 0x0A, 0x28, 0x02, 0x85, 0x00,
  0x51, 0x20, 0x12, 0x24, 0x04, 0x44, 0x40, 0x90, 0x88, 0x22, 0x11, 0x04,
  0x44, 0x21, 0x08, 0x84, 0x21, 0x10, 0x88, 0x42, 0x11, 0x08, 0x41, 0x41,
  0x10, 0x30, 0x22, 0x06, 0x04, 0x40, 0x81, 0x00, 0x08, 0x01, 0x08, 0x01,
  0x14, 0x02, 0x14, 0x02, 0x14, 0x02, 0x12, 0x02, 0x12, 0x04, 0x22, 0x04,
  0x21, 0x04, 0x21, 0x04, 0x20, 0x84, 0x20, 0x88, 0x40, 0x88, 0x40, 0x48,
  0x40, 0x48, 0x40, 0x48, 0x40, 0x30, 0x80, 0x30, 0x80, 0x30, 0x80, 0x10,
  0x07, 0xF0, 0x20, 0x21, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00,
  0x50, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x84, 0x04, 0x0F, 0xE0, 0x0F,
  0xC0, 0x41, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24, 0x02,
  0x20, 0x11, 0x01, 0x08, 0x70, 0x7C, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x20, 0x21,
  0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04,
  0x80, 0x11, 0x00, 0x84, 0x04, 0x0F, 0xE0, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x0F, 0xC0, 0x41, 0x82, 0x04, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x44, 0x02, 0x20, 0x21, 0x03, 0x0F, 0xE0, 0x42, 0x04,
  0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x84, 0x02, 0x20, 0x11, 0x00,
  0x80, 0x07, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x21, 0xFE, 0x00, 0xFF, 0xE0,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x00, 0x10, 0x02, 0x20, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x81,
  0x03, 0x01, 0xF8, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x44, 0x04,
  0x80, 0x48, 0x05, 0x00, 0x50, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x40,
  0x18, 0x04, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12,
  0x08, 0x81, 0x20, 0x88, 0x22, 0x08, 0x82, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x22, 0x08, 0x82, 0x20, 0x88, 0x24, 0x09, 0x02, 0x40, 0x90, 0x28, 0x09,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x03, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00,
  0x04, 0x01, 0x02, 0x02, 0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x10,
  0x01, 0x20, 0x01, 0x20, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x20, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x10, 0xC0, 0x10, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x10, 0x82,
  0x10, 0x82, 0x20, 0x44, 0x05, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x03, 0xE0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22,
  0x21, 0x11, 0x07, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x43, 0xF0, 0x01, 0x00, 0x28, 0x02,
  0x80, 0x48, 0x08, 0x40, 0x84, 0x10, 0x41, 0x02, 0x20, 0x24, 0x02, 0xC0,
  0x10, 0xFF, 0x80, 0x89, 0x10, 0x07, 0x91, 0x85, 0x10, 0x22, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x81,
  0x84, 0x28, 0x3C, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x13, 0xC2, 0xC2, 0x30, 0x23, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x04, 0xC0, 0x8C, 0x08, 0xBF, 0x00,
  0x07, 0xC6, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x79, 0x06, 0x14, 0x10, 0x30, 0x80,
  0xC4, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80,
  0x42, 0x03, 0x08, 0x14, 0x10, 0xD0, 0x3C, 0x80, 0x07, 0x82, 0x11, 0x04,
  0x81, 0x40, 0x50, 0x24, 0x31, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x03, 0xF0, 0x00, 0x3C, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x3F, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x38, 0x00, 0x03, 0xC8, 0x61, 0x42, 0x06, 0x20, 0x32, 0x01,
  0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0xC4,
  0x0A, 0x10, 0xD0, 0x79, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x0C, 0x30, 0x1E, 0x00, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x05, 0xF1, 0x41, 0x30, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x90,
  0x12, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x48, 0x08, 0x18, 0x80, 0x00,
  0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x0C, 0x00, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x09, 0x02, 0x20, 0x84, 0x20, 0x88, 0x22,
  0x04, 0x80, 0xB0, 0x19, 0x02, 0x20, 0x82, 0x10, 0x42, 0x08, 0x40, 0x88,
  0x10, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x08, 0x00, 0x17, 0x87, 0x8A, 0x12, 0x13, 0x05, 0x04, 0x80, 0x81,
  0x20, 0x20, 0x48, 0x10, 0x14, 0x04, 0x05, 0x01, 0x01, 0x40, 0x40, 0x90,
  0x20, 0x28, 0x08, 0x0A, 0x02, 0x02, 0x80, 0x81, 0x20, 0x20, 0x48, 0x10,
  0x10, 0x17, 0xC5, 0x04, 0xC0, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x02,
  0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x20, 0x07, 0x81,
  0x08, 0x40, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x40, 0x28, 0x08, 0x83, 0x0F, 0x80, 0x04, 0xF0, 0x2C, 0x20, 0xC0,
  0x83, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40,
  0x21, 0x00, 0x8C, 0x04, 0x30, 0x20, 0xC0, 0x82, 0xFC, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0x91, 0x85, 0x10,
  0x32, 0x03, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0x48, 0x0C, 0x81, 0x44, 0x14, 0x3E, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x17, 0x94, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x0F, 0xC4,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x4F, 0xE0, 0x10, 0x20, 0x43, 0xF2, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0xE0, 0x20, 0x12, 0x01,
  0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x81, 0x88, 0x28, 0x7C, 0x80, 0x80, 0x60, 0x14, 0x09,
  0x02, 0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x04, 0x81, 0x20, 0x30,
  0x08, 0x02, 0x00, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x14, 0x28, 0x28, 0x50,
  0x90, 0xA1, 0x22, 0x42, 0x44, 0x88, 0x91, 0x11, 0x21, 0x42, 0x82, 0x85,
  0x06, 0x0C, 0x0C, 0x18, 0x10, 0x20, 0x20, 0x00, 0x10, 0x18, 0x40, 0x82,
  0x08, 0x10, 0x80, 0x48, 0x02, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x48,
  0x04, 0x40, 0x21, 0x02, 0x08, 0x20, 0x42, 0x01, 0x00, 0x04, 0x02, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10,
  0x04, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE0,
  0x01, 0xC0, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x00, 0xC0, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x83, 0xC0, 0x78, 0x30, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 6, 7, 8, 3, -20 },
  { 20, 14, 20, 15, 1, -20 },
  { 55, 12, 23, 13, 1, -21 },
  { 90, 15, 20, 19, 2, -20 },
  { 128, 13, 20, 15, 1, -20 },
  { 161, 2, 7, 5, 3, -20 },
  { 163, 8, 24, 7, 1, -20 },
  { 187, 8, 24, 7, -2, -20 },
  { 211, 10, 10, 13, 3, -21 },
  { 224, 11, 13, 14, 2, -16 },
  { 242, 3, 7, 5, -1, -3 },
  { 245, 6, 1, 8, 1, -8 },
  { 246, 1, 2, 5, 1, -2 },
  { 247, 12, 20, 8, -1, -20 },
  { 277, 12, 20, 13, 1, -20 },
  { 307, 6, 20, 13, 4, -20 },
  { 322, 13, 20, 13, 0, -20 },
  { 355, 13, 20, 13, 0, -20 },
  { 388, 13, 20, 13, 0, -20 },
  { 421, 13, 20, 13, 0, -20 },
  { 454, 12, 20, 13, 1, -20 },
  { 484, 12, 20, 13, 2, -20 },
  { 514, 12, 20, 13, 1, -20 },
  { 544, 12, 20, 13, 1, -20 },
  { 574, 4, 15, 5, 1, -15 },
  { 582, 6, 19, 5, -1, -15 },
  { 597, 11, 12, 14, 2, -16 },
  { 614, 11, 6, 14, 2, -13 },
  { 623, 11, 12, 14, 2, -16 },
  { 640, 8, 20, 10, 2, -20 },
  { 660, 18, 23, 20, 1, -20 },
  { 712, 13, 20, 13, -2, -20 },
  { 745, 13, 20, 14, 1, -20 },
  { 778, 13, 20, 14, 2, -20 },
  { 811, 14, 20, 16, 1, -20 },
  { 846, 13, 20, 13, 1, -20 },
  { 879, 13, 20, 12, 1, -20 },
  { 912, 15, 20, 17, 2, -20 },
  { 950, 16, 20, 17, 1, -20 },
  { 990, 8, 20, 7, 0, -20 },
  { 1010, 10, 25, 6, -4, -20 },
  { 1042, 14, 20, 13, 1, -20 },
  { 1077, 9, 20, 12, 1, -20 },
  { 1100, 19, 20, 20, 1, -20 },
  { 1148, 16, 20, 17, 1, -20 },
  { 1188, 14, 20, 17, 2, -20 },
  { 1223, 13, 20, 14, 1, -20 },
  { 1256, 14, 25, 17, 2, -20 },
  { 1300, 13, 20, 14, 1, -20 },
  { 1333, 13, 20, 12, 0, -20 },
  { 1366, 11, 20, 12, 3, -20 },
  { 1394, 15, 20, 17, 2, -20 },
  { 1432, 12, 20, 13, 3, -20 },
  { 1462, 20, 20, 21, 3, -20 },
  { 1512, 16, 20, 12, -2, -20 },
  { 1552, 11, 20, 12, 3, -20 },
  { 1580, 15, 20, 13, -1, -20 },
  { 1618, 10, 24, 8, 0, -20 },
  { 1648, 4, 20, 9, 3, -20 },
  { 1658, 10, 24, 8, -2, -20 },
  { 1688, 12, 11, 14, 1, -20 },
  { 1705, 9, 1, 9, -2, 3 },
  { 1707, 3, 4, 6, 4, -21 },
  { 1709, 12, 15, 14, 1, -15 },
  { 1732, 12, 21, 14, 1, -21 },
  { 1764, 10, 15, 11, 1, -15 },
  { 1783, 14, 21, 14, 1, -21 },
  { 1820, 10, 15, 12, 1, -15 },
  { 1839, 14, 28, 7, -4, -21 },
  { 1888, 13, 22, 14, 0, -15 },
  { 1924, 11, 21, 14, 1, -21 },
  { 1953, 5, 20, 5, 1, -20 },
  { 1966, 10, 27, 5, -4, -20 },
  { 2000, 11, 21, 11, 1, -21 },
  { 2029, 5, 21, 5, 1, -21 },
  { 2043, 18, 15, 21, 1, -15 },
  { 2077, 11, 15, 13, 1, -15 },
  { 2098, 11, 15, 14, 1, -15 },
  { 2119, 14, 21, 14, -1, -15 },
  { 2156, 12, 22, 14, 1, -15 },
  { 2189, 9, 15, 9, 1, -15 },
  { 2206, 10, 15, 10, 0, -15 },
  { 2225, 7, 18, 7, 1, -18 },
  { 2241, 12, 15, 14, 1, -15 },
  { 2264, 10, 15, 10, 1, -15 },
  { 2283, 15, 15, 16, 2, -15 },
  { 2312, 13, 15, 11, -1, -15 },
  { 2337, 15, 22, 10, -3, -15 },
  { 2379, 11, 15, 10, -1, -15 },
  { 2400, 10, 24, 9, 1, -20 },
  { 2430, 1, 28, 13, 6, -21 },
  { 2434, 10, 24, 9, -2, -20 },
  { 2464, 11, 2, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC28PT7B_H_
