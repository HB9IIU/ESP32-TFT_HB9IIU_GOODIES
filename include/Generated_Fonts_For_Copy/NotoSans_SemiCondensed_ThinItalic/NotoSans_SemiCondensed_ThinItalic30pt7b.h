#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x65, 0x14, 0x51, 0x4A, 0x28, 0x80, 0x01, 0x0C, 0x02,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x0F, 0xFF, 0x82, 0x10,
  0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x01, 0x04, 0x1F, 0xFF, 0x04,
  0x20, 0x08, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0F, 0xF0, 0x88, 0x08, 0x80, 0x44,
  0x04, 0x20, 0x21, 0x00, 0x88, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x40,
  0x09, 0x00, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x8C, 0x98, 0x0F,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x01, 0x09, 0x01, 0x08, 0x40,
  0x88, 0x20, 0x84, 0x10, 0x82, 0x08, 0x42, 0x04, 0x41, 0x02, 0x40, 0x82,
  0x20, 0x41, 0x27, 0xA0, 0xA4, 0x50, 0x92, 0x14, 0x92, 0x09, 0x89, 0x04,
  0x09, 0x02, 0x08, 0x82, 0x04, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x42, 0x04, 0x22, 0x01, 0xE0, 0x01, 0xC0, 0x08, 0x80, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x02, 0x08, 0x04, 0xC0, 0x14, 0x00, 0x60,
  0x02, 0x80, 0x31, 0x05, 0x04, 0x14, 0x08, 0x60, 0x22, 0x80, 0x4A, 0x00,
  0xC8, 0x02, 0x20, 0x14, 0xC0, 0x91, 0xFC, 0x20, 0x69, 0x25, 0x20, 0x03,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x80, 0x04, 0x01, 0x00, 0x42, 0x10, 0x64, 0x07, 0xF0, 0x80,
  0xD0, 0x44, 0x20, 0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x32, 0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x31, 0x82, 0x04, 0x10, 0x11, 0x00, 0x88,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x81, 0x04,
  0x10, 0x1F, 0x00, 0x06, 0x34, 0x96, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x00, 0x01, 0xE0,
  0x30, 0x82, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xF0, 0x01, 0xE0,
  0x18, 0x60, 0x80, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x7C, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x80, 0x41, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x50, 0x04, 0x80, 0x44, 0x02,
  0x40, 0x22, 0x02, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11,
  0x00, 0x90, 0x08, 0x7F, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x1F, 0x80, 0x41, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x20, 0x30,
  0x7F, 0x00, 0x00, 0xF0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x05, 0xF8, 0xA0, 0x4C, 0x04, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x07, 0xE0, 0xFF,
  0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x21, 0x82, 0x02,
  0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02, 0x08, 0x20, 0x26, 0x00,
  0xC0, 0x1A, 0x03, 0x0C, 0x20, 0x22, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x84, 0x0C, 0x1F, 0x80, 0x03, 0xC0, 0x21, 0x02, 0x04,
  0x20, 0x22, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x88,
  0x04, 0x40, 0x61, 0x0D, 0x07, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x7E, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x88, 0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x00, 0x1E, 0x30, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x03, 0x02, 0x01, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0xFF,
  0x00, 0x10, 0x0C, 0x06, 0x00, 0x40, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00,
  0x01, 0x20, 0x7E, 0x12, 0x08, 0x21, 0x41, 0x04, 0x14, 0x20, 0x41, 0x42,
  0x04, 0x14, 0x20, 0x82, 0x84, 0x08, 0x28, 0x40, 0x82, 0x84, 0x18, 0x48,
  0x41, 0x84, 0x82, 0x29, 0x88, 0x1C, 0x60, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x3E, 0x00, 0x00, 0x10,
  0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x08, 0x80, 0x42,
  0x01, 0x08, 0x08, 0x20, 0x20, 0x81, 0x01, 0x07, 0xFC, 0x20, 0x10, 0x80,
  0x44, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0xC0, 0x04, 0x0F,
  0xF8, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x02, 0x10, 0x10, 0xFF, 0x82, 0x06, 0x08, 0x04, 0x20, 0x11, 0x00, 0x24,
  0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x48, 0x02, 0x20, 0x30, 0xFF, 0x00,
  0x00, 0xF8, 0x06, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x10,
  0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x22, 0x01, 0x84, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xFC,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xFF, 0x82, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x03, 0xFE, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x00, 0xF0, 0x03, 0x07, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x7C,
  0x80, 0x84, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x40, 0x08, 0x40, 0x08, 0x20, 0x10, 0x1F, 0xE0, 0x08, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x41, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x1F, 0xFF, 0x08, 0x00, 0x84, 0x00, 0x82, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x80, 0x0F, 0x82, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x0F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x1F, 0x00, 0x08, 0x03, 0x08, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x16, 0x00, 0x2E,
  0x00, 0x2A, 0x00, 0x31, 0x00, 0x21, 0x00, 0x41, 0x00, 0x40, 0x80, 0x40,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x20, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x0F, 0xF8, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0x43, 0x00, 0x0C, 0x18, 0x00, 0xA1, 0x40, 0x05,
  0x09, 0x00, 0x48, 0x48, 0x02, 0x82, 0x40, 0x24, 0x12, 0x01, 0x21, 0x10,
  0x11, 0x08, 0x81, 0x08, 0x44, 0x08, 0x82, 0x20, 0x84, 0x20, 0x84, 0x21,
  0x04, 0x41, 0x08, 0x22, 0x08, 0x41, 0x20, 0x82, 0x09, 0x04, 0x20, 0x50,
  0x21, 0x03, 0x01, 0x08, 0x08, 0x10, 0x00, 0x0C, 0x00, 0x86, 0x00, 0x43,
  0x00, 0x41, 0x40, 0x21, 0x20, 0x10, 0x90, 0x08, 0x44, 0x04, 0x22, 0x04,
  0x11, 0x02, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x04, 0x42, 0x02,
  0x21, 0x01, 0x10, 0x80, 0x48, 0x40, 0x28, 0x20, 0x14, 0x20, 0x06, 0x10,
  0x03, 0x08, 0x01, 0x80, 0x01, 0xF0, 0x06, 0x08, 0x08, 0x04, 0x10, 0x02,
  0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xC0,
  0x0F, 0xF0, 0x20, 0x20, 0x80, 0x82, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x84, 0x02, 0x10, 0x08, 0x80, 0x42, 0x06, 0x0F, 0xE0, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x01, 0xF0, 0x06, 0x08, 0x08, 0x04, 0x10, 0x02, 0x10, 0x02, 0x20,
  0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1D, 0xC0, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x0F, 0xF0, 0x20, 0x20, 0x80,
  0x82, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x80,
  0xC2, 0x0C, 0x0F, 0xC0, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x41, 0x01, 0x08, 0x04, 0x20, 0x08, 0x80, 0x20, 0x01, 0xF0, 0x18, 0x30,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x80, 0xC3, 0xFC, 0x00, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x00, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x40, 0x40, 0x3F,
  0x80, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01,
  0x10, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x22, 0x01,
  0x10, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x05, 0x00, 0xC0, 0x28, 0x09,
  0x02, 0x40, 0x48, 0x12, 0x04, 0x41, 0x10, 0x22, 0x08, 0x82, 0x10, 0x84,
  0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x22, 0x08, 0x41, 0x10, 0x24, 0x09,
  0x01, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x03, 0x00, 0xA0, 0x18,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x00, 0x02, 0x01, 0x81, 0x01,
  0x00, 0x80, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x40, 0x01,
  0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x24, 0x00,
  0x11, 0x00, 0x10, 0x80, 0x10, 0x40, 0x10, 0x20, 0x08, 0x08, 0x08, 0x04,
  0x08, 0x02, 0x0C, 0x00, 0x80, 0x80, 0x18, 0x02, 0x80, 0x44, 0x04, 0x40,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x24, 0x02, 0x40, 0x28, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x00, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0x00, 0x88, 0x84, 0x44, 0x44, 0x42,
  0x22, 0x22, 0x21, 0x11, 0x11, 0x10, 0x07, 0xE0, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x1F, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x50, 0x04,
  0x80, 0x44, 0x02, 0x10, 0x20, 0x81, 0x04, 0x10, 0x11, 0x00, 0x88, 0x04,
  0x80, 0x18, 0x00, 0x80, 0xFF, 0xC0, 0x84, 0x42, 0x10, 0x07, 0xC8, 0x41,
  0x44, 0x0C, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x20, 0x61, 0x05, 0x07, 0xC8, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x7C,
  0x14, 0x11, 0x40, 0x8C, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x48,
  0x02, 0x40, 0x12, 0x00, 0x90, 0x09, 0x80, 0x4C, 0x04, 0x50, 0x42, 0x7C,
  0x00, 0x07, 0xE1, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0xF8, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x03, 0xE4, 0x08, 0x28, 0x20, 0x30, 0x80, 0x41, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84, 0x03,
  0x04, 0x0C, 0x08, 0x28, 0x0F, 0x90, 0x00, 0x07, 0xC1, 0x04, 0x40, 0x90,
  0x12, 0x02, 0x80, 0x90, 0x22, 0xF8, 0x60, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x18, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE4, 0x10, 0x50, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x80,
  0x22, 0x00, 0x88, 0x02, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x40,
  0x30, 0x81, 0x82, 0x0A, 0x07, 0xC8, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x82, 0x06, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x3E, 0x14, 0x12, 0x81, 0x30, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x40, 0x08, 0x40, 0x00, 0x00, 0x42, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x00, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x03, 0x10, 0x42, 0x04,
  0x20, 0x82, 0x10, 0x22, 0x02, 0x40, 0x4C, 0x05, 0x40, 0x64, 0x04, 0x20,
  0x82, 0x08, 0x10, 0x81, 0x08, 0x10, 0x80, 0x80, 0x08, 0x42, 0x11, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x00, 0x13,
  0xC3, 0xC1, 0xC2, 0x42, 0x28, 0x28, 0x13, 0x03, 0x01, 0x20, 0x20, 0x12,
  0x02, 0x02, 0x20, 0x20, 0x24, 0x02, 0x02, 0x40, 0x40, 0x24, 0x04, 0x04,
  0x40, 0x40, 0x44, 0x04, 0x04, 0x80, 0x40, 0x48, 0x08, 0x04, 0x80, 0x80,
  0x88, 0x08, 0x08, 0x13, 0xE1, 0x41, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x24, 0x04,
  0x40, 0x83, 0xF0, 0x04, 0xF8, 0x0A, 0x08, 0x28, 0x10, 0x60, 0x10, 0xC0,
  0x21, 0x00, 0x42, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10,
  0x80, 0x43, 0x00, 0x86, 0x02, 0x0A, 0x08, 0x13, 0xE0, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xC8, 0x41, 0x44, 0x06, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x06, 0x20, 0x61, 0x05, 0x07,
  0xC8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x13, 0xC5, 0x02, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0xE2, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x20, 0x47, 0xF0, 0x08, 0x20, 0x40, 0x87, 0xE4,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x03,
  0x80, 0x10, 0x09, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00,
  0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x61,
  0x05, 0x0F, 0xC8, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x22,
  0x10, 0x84, 0x22, 0x04, 0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x00, 0x80,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84,
  0x84, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0x90, 0xA0,
  0xA0, 0xC0, 0xA0, 0xC0, 0x40, 0x80, 0x40, 0x08, 0x08, 0x40, 0x82, 0x04,
  0x08, 0x40, 0x44, 0x02, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x28, 0x02,
  0x40, 0x21, 0x01, 0x08, 0x10, 0x41, 0x01, 0x10, 0x08, 0x04, 0x03, 0x04,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x02,
  0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x03, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xF8, 0x01, 0xC0, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x0E, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x18, 0x00, 0x78, 0x18, 0x61, 0x01,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 21, 6, 1, -21 },
  { 15, 6, 7, 9, 3, -21 },
  { 21, 15, 21, 16, 1, -21 },
  { 61, 13, 25, 14, 1, -23 },
  { 102, 17, 22, 20, 2, -22 },
  { 149, 14, 22, 17, 1, -22 },
  { 188, 3, 7, 5, 3, -21 },
  { 191, 8, 26, 7, 1, -21 },
  { 217, 8, 26, 7, -2, -21 },
  { 243, 10, 11, 14, 4, -23 },
  { 257, 12, 13, 15, 2, -17 },
  { 277, 4, 7, 5, -1, -3 },
  { 281, 7, 1, 9, 1, -9 },
  { 282, 1, 2, 6, 1, -2 },
  { 283, 12, 21, 9, -1, -21 },
  { 315, 13, 22, 14, 1, -22 },
  { 351, 7, 21, 14, 4, -21 },
  { 370, 13, 22, 14, 0, -22 },
  { 406, 14, 22, 14, 0, -22 },
  { 445, 13, 22, 14, 0, -22 },
  { 481, 14, 21, 14, 0, -21 },
  { 518, 12, 22, 14, 2, -22 },
  { 551, 12, 21, 14, 3, -21 },
  { 583, 13, 22, 14, 1, -22 },
  { 619, 13, 22, 14, 1, -22 },
  { 655, 4, 16, 6, 1, -16 },
  { 663, 6, 20, 6, -1, -16 },
  { 678, 12, 13, 15, 2, -17 },
  { 698, 12, 7, 15, 2, -14 },
  { 709, 12, 13, 15, 2, -17 },
  { 729, 9, 22, 10, 2, -22 },
  { 754, 20, 24, 21, 1, -21 },
  { 814, 14, 21, 14, -2, -21 },
  { 851, 14, 21, 15, 1, -21 },
  { 888, 15, 22, 15, 2, -22 },
  { 930, 15, 21, 17, 1, -21 },
  { 970, 14, 21, 14, 1, -21 },
  { 1007, 14, 21, 13, 1, -21 },
  { 1044, 16, 22, 18, 2, -22 },
  { 1088, 17, 21, 18, 1, -21 },
  { 1133, 9, 21, 7, 0, -21 },
  { 1157, 11, 26, 6, -5, -21 },
  { 1193, 16, 21, 14, 1, -21 },
  { 1235, 9, 21, 13, 1, -21 },
  { 1259, 21, 21, 22, 1, -21 },
  { 1315, 17, 21, 18, 1, -21 },
  { 1360, 16, 22, 18, 2, -22 },
  { 1404, 14, 21, 14, 1, -21 },
  { 1441, 16, 27, 18, 2, -22 },
  { 1495, 14, 21, 15, 1, -21 },
  { 1532, 14, 22, 13, 0, -22 },
  { 1571, 12, 21, 12, 3, -21 },
  { 1603, 16, 21, 18, 2, -21 },
  { 1645, 13, 21, 14, 3, -21 },
  { 1680, 21, 21, 22, 3, -21 },
  { 1736, 17, 21, 13, -2, -21 },
  { 1781, 12, 21, 12, 3, -21 },
  { 1813, 16, 21, 14, -1, -21 },
  { 1855, 11, 26, 9, 0, -21 },
  { 1891, 4, 21, 9, 3, -21 },
  { 1902, 11, 26, 9, -2, -21 },
  { 1938, 13, 13, 15, 1, -22 },
  { 1960, 10, 1, 10, -2, 3 },
  { 1962, 4, 5, 7, 4, -23 },
  { 1965, 13, 16, 15, 1, -16 },
  { 1991, 13, 23, 15, 1, -23 },
  { 2029, 11, 16, 12, 1, -16 },
  { 2051, 15, 23, 15, 1, -23 },
  { 2095, 11, 16, 13, 1, -16 },
  { 2117, 15, 30, 7, -4, -23 },
  { 2174, 14, 23, 15, 0, -16 },
  { 2215, 12, 23, 14, 1, -23 },
  { 2250, 5, 22, 6, 1, -22 },
  { 2264, 10, 29, 6, -4, -22 },
  { 2301, 12, 23, 12, 1, -23 },
  { 2336, 5, 23, 6, 1, -23 },
  { 2351, 20, 16, 22, 1, -16 },
  { 2391, 12, 16, 14, 1, -16 },
  { 2415, 12, 16, 15, 1, -16 },
  { 2439, 15, 23, 15, -1, -16 },
  { 2483, 13, 23, 15, 1, -16 },
  { 2521, 10, 16, 10, 1, -16 },
  { 2541, 11, 16, 11, 0, -16 },
  { 2563, 7, 20, 8, 1, -20 },
  { 2581, 13, 16, 14, 1, -16 },
  { 2607, 10, 16, 11, 2, -16 },
  { 2627, 16, 16, 17, 2, -16 },
  { 2659, 13, 16, 12, -1, -16 },
  { 2685, 16, 23, 11, -3, -16 },
  { 2731, 12, 16, 11, -1, -16 },
  { 2755, 10, 26, 10, 1, -21 },
  { 2788, 1, 30, 14, 7, -23 },
  { 2792, 11, 26, 10, -2, -21 },
  { 2828, 12, 3, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC30PT7B_H_
