#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0x21, 0x61, 0x41, 0x41,
  0x42, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x00, 0x10, 0x10, 0x00, 0x40,
  0xC0, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x81, 0x00,
  0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x02, 0x02, 0x01, 0xFF,
  0xFF, 0xC0, 0x20, 0x20, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x10, 0x10,
  0x00, 0x40, 0xC0, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x10, 0x10, 0x00, 0xC0, 0xC0, 0x02, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x60, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00,
  0x10, 0x10, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x03, 0x11, 0xC0,
  0x82, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x00, 0x82, 0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x19, 0x00, 0x01,
  0xA0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x26, 0x00, 0x04, 0x60, 0x01,
  0x84, 0x00, 0x20, 0xC0, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x60, 0x04,
  0x08, 0x00, 0x83, 0x00, 0x10, 0xC1, 0xC2, 0x70, 0x0F, 0xF0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x06, 0x0C, 0x40, 0x04, 0x18, 0x20, 0x08, 0x10, 0x20, 0x18, 0x20,
  0x20, 0x10, 0x20, 0x20, 0x20, 0x40, 0x20, 0x60, 0x40, 0x20, 0x40, 0x40,
  0x20, 0x80, 0x40, 0x21, 0x80, 0xC0, 0x41, 0x00, 0x80, 0x42, 0x00, 0x80,
  0x46, 0x18, 0x80, 0xC4, 0x66, 0x80, 0x88, 0xC2, 0x81, 0x99, 0x81, 0xC1,
  0x11, 0x01, 0x42, 0x23, 0x01, 0x3C, 0x22, 0x01, 0x00, 0x42, 0x01, 0x00,
  0xC6, 0x03, 0x00, 0x84, 0x02, 0x01, 0x04, 0x02, 0x03, 0x04, 0x02, 0x02,
  0x04, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x04, 0x04, 0x08, 0x04, 0x0C, 0x10,
  0x04, 0x08, 0x30, 0x06, 0x10, 0x60, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0x0C, 0x00, 0x20, 0x20, 0x03, 0x01, 0x80, 0x10, 0x0C,
  0x00, 0x80, 0x60, 0x0C, 0x02, 0x00, 0x60, 0x10, 0x03, 0x01, 0x80, 0x08,
  0x08, 0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x09, 0x80, 0x00, 0x58, 0x00,
  0x03, 0x00, 0x00, 0x6C, 0x00, 0x06, 0x20, 0x00, 0x41, 0x80, 0x44, 0x04,
  0x02, 0x40, 0x10, 0x26, 0x00, 0x81, 0x20, 0x02, 0x13, 0x00, 0x11, 0x90,
  0x00, 0x48, 0x80, 0x03, 0x84, 0x00, 0x0C, 0x20, 0x00, 0xE1, 0x80, 0x0D,
  0x04, 0x00, 0xCC, 0x10, 0x18, 0x20, 0x7F, 0x80, 0x80, 0x2D, 0x24, 0xA4,
  0x92, 0x00, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x0C, 0x08, 0x0C, 0x10, 0x06, 0x40, 0x03, 0x8F, 0x01,
  0xE0, 0x06, 0x00, 0x12, 0x00, 0xC4, 0x03, 0x04, 0x0C, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x0C,
  0x20, 0x86, 0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0xFF, 0xC0, 0x7C, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x60, 0xC0, 0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0x82, 0x00, 0x30, 0x80,
  0x04, 0x40, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x03,
  0x60, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xB0,
  0x00, 0x6C, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x0C, 0x00, 0x81, 0x00, 0x60,
  0x60, 0x30, 0x0C, 0x18, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x60, 0x68, 0x32,
  0x31, 0x98, 0x4C, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x00, 0x3F,
  0x00, 0x38, 0x10, 0x0C, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x1C, 0x0C, 0x07, 0x00, 0x60, 0x20, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x0C, 0x01, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x02, 0x80, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x0C, 0x80, 0x01, 0x10, 0x00,
  0x42, 0x00, 0x10, 0xC0, 0x06, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40, 0x08,
  0x08, 0x02, 0x02, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x04, 0x01, 0x01, 0x00,
  0x60, 0x60, 0x08, 0x18, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x3F, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xF0, 0x02, 0x03, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x81, 0x00, 0x60, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x1F, 0x00, 0x4E, 0x38, 0x13, 0x01, 0x82, 0x80, 0x10,
  0x60, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x11,
  0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0xC1,
  0x00, 0x10, 0x20, 0x06, 0x06, 0x01, 0x80, 0x60, 0x60, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x30, 0x0C,
  0x01, 0x01, 0x00, 0x30, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20,
  0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03, 0x01, 0x00, 0xC0, 0x10,
  0x30, 0x03, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0x18, 0x01, 0x80,
  0x80, 0xC0, 0x08, 0x10, 0x01, 0x84, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x20, 0x01,
  0x06, 0x00, 0x40, 0x60, 0x30, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x30,
  0x20, 0x0C, 0x02, 0x03, 0x00, 0x60, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00,
  0x10, 0xC0, 0x03, 0x10, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x30, 0x80, 0x0A, 0x08, 0x02,
  0x81, 0x81, 0x90, 0x0F, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x04, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x43, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0,
  0x60, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x21, 0x00, 0x3E, 0x03, 0x10, 0x0C, 0x18, 0x12, 0x01, 0x81, 0x01, 0x20,
  0x30, 0x10, 0x16, 0x06, 0x01, 0x01, 0x40, 0x40, 0x20, 0x34, 0x0C, 0x02,
  0x02, 0x40, 0x80, 0x20, 0x2C, 0x08, 0x06, 0x02, 0x81, 0x80, 0x40, 0x68,
  0x10, 0x04, 0x04, 0x81, 0x00, 0xC0, 0x48, 0x10, 0x0C, 0x0C, 0x81, 0x01,
  0x40, 0x88, 0x18, 0x14, 0x10, 0x80, 0x86, 0x42, 0x08, 0x07, 0xC3, 0xC0,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x80, 0x40, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0xFF, 0xC0, 0x20, 0x06, 0x04, 0x00,
  0x20, 0xC0, 0x02, 0x08, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00,
  0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80,
  0x00, 0x30, 0x01, 0xFF, 0x00, 0x08, 0x1E, 0x00, 0xC0, 0x0C, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0, 0x03, 0x04,
  0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04,
  0x04, 0x00, 0xC0, 0x3F, 0xF8, 0x01, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x80,
  0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x20,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18, 0x00,
  0x20, 0x80, 0x02, 0x04, 0x00, 0x60, 0x20, 0x0E, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0x80, 0xC0, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x02, 0x0F, 0x80, 0x0C, 0x01, 0x80, 0x10, 0x00, 0x80, 0x20, 0x00,
  0x80, 0x40, 0x01, 0x00, 0x80, 0x01, 0x03, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x30, 0x80, 0x00, 0x41,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01, 0x86, 0x00,
  0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x01,
  0x81, 0x00, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00, 0xE0, 0x08, 0x0F, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x3C, 0x06, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x0F, 0xF1, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00,
  0x10, 0x80, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x01, 0x01, 0x00, 0x02,
  0x03, 0x00, 0x04, 0x03, 0x80, 0x30, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x20, 0x20,
  0x00, 0x10, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x04,
  0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80,
  0x80, 0x00, 0x40, 0x40, 0x00, 0x20, 0x3F, 0xFF, 0xF0, 0x10, 0x00, 0x10,
  0x18, 0x00, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x02, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00,
  0x20, 0x20, 0x00, 0x20, 0x10, 0x00, 0x10, 0x18, 0x00, 0x08, 0x08, 0x00,
  0x04, 0x04, 0x00, 0x06, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x00, 0x01,
  0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x01, 0x00, 0x06, 0x02, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x10, 0x01, 0x80, 0x20, 0x06, 0x00, 0x40, 0x18, 0x00,
  0x80, 0x60, 0x03, 0x01, 0x80, 0x04, 0x06, 0x00, 0x08, 0x18, 0x00, 0x10,
  0x60, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x01, 0x18, 0x00, 0x02, 0x50,
  0x00, 0x05, 0x20, 0x00, 0x1C, 0x20, 0x00, 0x30, 0x40, 0x00, 0x40, 0xC0,
  0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x01, 0x00, 0x08, 0x02, 0x00,
  0x10, 0x06, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x08, 0x02,
  0x00, 0x10, 0x04, 0x00, 0x30, 0x08, 0x00, 0x20, 0x30, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC0, 0xA0, 0x00, 0x07, 0x02, 0x80,
  0x00, 0x28, 0x0A, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x04, 0x81, 0xA0, 0x00,
  0x32, 0x04, 0x40, 0x00, 0x98, 0x11, 0x00, 0x06, 0x40, 0x44, 0x00, 0x11,
  0x01, 0x10, 0x00, 0xC4, 0x08, 0x40, 0x02, 0x10, 0x21, 0x00, 0x10, 0xC0,
  0x84, 0x00, 0x42, 0x02, 0x18, 0x02, 0x08, 0x18, 0x20, 0x18, 0x20, 0x40,
  0x80, 0x41, 0x81, 0x02, 0x03, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x01, 0x02, 0x02, 0x08, 0x0C, 0x08, 0x0C, 0x20,
  0x20, 0x20, 0x11, 0x00, 0x80, 0x80, 0x4C, 0x02, 0x04, 0x01, 0x20, 0x08,
  0x10, 0x05, 0x80, 0x60, 0x40, 0x14, 0x01, 0x01, 0x00, 0x70, 0x04, 0x0C,
  0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x80, 0xE0,
  0x00, 0x40, 0x50, 0x00, 0x20, 0x28, 0x00, 0x10, 0x12, 0x00, 0x18, 0x09,
  0x00, 0x08, 0x0C, 0x80, 0x04, 0x04, 0x20, 0x02, 0x02, 0x10, 0x01, 0x01,
  0x08, 0x01, 0x80, 0x82, 0x00, 0x80, 0x81, 0x00, 0x40, 0x40, 0x80, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08, 0x08, 0x02, 0x04,
  0x04, 0x01, 0x02, 0x02, 0x00, 0x83, 0x01, 0x00, 0x21, 0x01, 0x80, 0x10,
  0x80, 0x80, 0x08, 0x40, 0x40, 0x02, 0x20, 0x20, 0x01, 0x30, 0x10, 0x00,
  0xD0, 0x10, 0x00, 0x28, 0x08, 0x00, 0x14, 0x04, 0x00, 0x0E, 0x02, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80, 0x10,
  0x03, 0x01, 0x80, 0x06, 0x04, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00,
  0x44, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x50,
  0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x06,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03,
  0x00, 0x60, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x10, 0x78,
  0x03, 0x00, 0x40, 0x20, 0x02, 0x02, 0x00, 0x30, 0x20, 0x01, 0x02, 0x00,
  0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x30, 0x40,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x18,
  0x0E, 0x01, 0xFF, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80, 0x10, 0x03, 0x01, 0x80, 0x06,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0x44, 0x00, 0x01, 0x30,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x38, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFC,
  0x00, 0x10, 0x78, 0x03, 0x00, 0x40, 0x20, 0x02, 0x02, 0x00, 0x30, 0x20,
  0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x04, 0x08, 0x01, 0x80,
  0x80, 0x30, 0x1F, 0xFC, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x00, 0x80,
  0x10, 0x08, 0x03, 0x00, 0x80, 0x20, 0x0C, 0x02, 0x00, 0x40, 0x20, 0x04,
  0x02, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00,
  0x30, 0xC0, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x07, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x0C, 0x01, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x02, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00,
  0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x30, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00,
  0x04, 0x02, 0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x60, 0x00, 0x64,
  0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40, 0x02, 0x08,
  0x00, 0xC1, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x10,
  0x04, 0x02, 0x01, 0x80, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x10,
  0x60, 0x02, 0x08, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x22,
  0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x28,
  0x00, 0x60, 0x00, 0xA0, 0x01, 0x80, 0x04, 0x80, 0x0F, 0x00, 0x12, 0x00,
  0x2C, 0x00, 0xC8, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x11,
  0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x01, 0x82, 0x03, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30,
  0x20, 0x60, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10,
  0x04, 0x60, 0x08, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x98, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x20, 0x18, 0x00, 0x20, 0x30, 0x00, 0x20,
  0x20, 0x00, 0x30, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x34, 0x00, 0x00, 0x26, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x82, 0x00, 0x01, 0x01, 0x00, 0x02, 0x01,
  0x00, 0x06, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x08, 0x00, 0x80, 0x10, 0x00,
  0x80, 0x30, 0x00, 0xC0, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x80, 0x00,
  0xE0, 0x00, 0x2C, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x01, 0x04,
  0x00, 0xC0, 0x80, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x02, 0x00, 0xC1,
  0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0A, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x80,
  0xFF, 0x00, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x80, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x21, 0x00,
  0x10, 0x40, 0x0C, 0x10, 0x02, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x20, 0x20,
  0x04, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00,
  0xA0, 0x00, 0x10, 0xFF, 0xFC, 0xC2, 0x18, 0x41, 0x08, 0x20, 0x01, 0xF8,
  0x40, 0xC1, 0x10, 0x40, 0x28, 0x20, 0x0A, 0x10, 0x01, 0x8C, 0x00, 0x62,
  0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x32, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80, 0x04,
  0x20, 0x03, 0x08, 0x01, 0xC3, 0x00, 0x50, 0x40, 0x28, 0x18, 0x32, 0x03,
  0xF8, 0x80, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x43, 0xE0, 0x33, 0x06, 0x09, 0x80, 0x82, 0x80, 0x10, 0xE0, 0x04,
  0x30, 0x01, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00,
  0x26, 0x00, 0x11, 0x80, 0x04, 0x60, 0x02, 0x18, 0x01, 0x8D, 0x00, 0xC2,
  0x60, 0x60, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x06, 0x04, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x02, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0xF8, 0x40, 0x30, 0x64, 0x04, 0x02, 0x40, 0x80, 0x14,
  0x10, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x18, 0x40, 0x01,
  0x84, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00,
  0x30, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x80,
  0x0C, 0x0C, 0x01, 0x40, 0x40, 0x24, 0x06, 0x0C, 0x40, 0x3F, 0x84, 0x00,
  0x00, 0xF8, 0x06, 0x08, 0x18, 0x08, 0x40, 0x11, 0x80, 0x22, 0x00, 0x48,
  0x00, 0x90, 0x03, 0x40, 0x0C, 0x80, 0x31, 0x03, 0x87, 0xF8, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x02, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x06, 0x10, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x07, 0xFC, 0x00, 0x22, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x10, 0x0C, 0x19,
  0x01, 0x00, 0x90, 0x20, 0x05, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00,
  0x61, 0x80, 0x06, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20,
  0x01, 0x82, 0x00, 0x38, 0x20, 0x07, 0x03, 0x00, 0x50, 0x10, 0x09, 0x01,
  0x83, 0x10, 0x0F, 0xE3, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x0C, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x43, 0xE0, 0x13, 0x06, 0x09, 0x00, 0x82,
  0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x00, 0x03, 0x03, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x21, 0x80, 0x20, 0x80,
  0x20, 0x40, 0x20, 0x20, 0x20, 0x10, 0x20, 0x18, 0x20, 0x08, 0x20, 0x04,
  0x20, 0x02, 0x20, 0x01, 0x30, 0x01, 0x24, 0x00, 0xA2, 0x00, 0x71, 0x80,
  0x30, 0x40, 0x10, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00,
  0x83, 0x00, 0x41, 0x00, 0x30, 0x80, 0x08, 0x00, 0x01, 0x01, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0x80, 0x04, 0x7C, 0x07, 0xC0, 0x8C, 0x31, 0x82,
  0x09, 0x01, 0x30, 0x10, 0xA0, 0x16, 0x01, 0x0C, 0x01, 0x40, 0x10, 0xC0,
  0x18, 0x01, 0x18, 0x01, 0x80, 0x11, 0x80, 0x10, 0x01, 0x10, 0x01, 0x00,
  0x11, 0x00, 0x10, 0x01, 0x10, 0x03, 0x00, 0x23, 0x00, 0x20, 0x02, 0x20,
  0x02, 0x00, 0x22, 0x00, 0x20, 0x02, 0x20, 0x02, 0x00, 0x62, 0x00, 0x60,
  0x04, 0x40, 0x04, 0x00, 0x44, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00, 0x44,
  0x00, 0x40, 0x0C, 0xC0, 0x08, 0x00, 0x88, 0x00, 0x80, 0x08, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x3E, 0x02, 0x30, 0x60, 0x90, 0x08, 0x28, 0x02, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x18, 0xC0, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0xC0,
  0x06, 0x20, 0x01, 0x08, 0x00, 0x40, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x00,
  0xC1, 0x00, 0x21, 0x00, 0x19, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x08, 0x01,
  0x84, 0x01, 0x81, 0x01, 0x80, 0x7F, 0x00, 0x01, 0x0F, 0x80, 0x23, 0x06,
  0x02, 0x60, 0x20, 0x2C, 0x01, 0x03, 0x80, 0x10, 0x30, 0x01, 0x07, 0x00,
  0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18,
  0x00, 0x61, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x34, 0x03, 0x02,
  0x60, 0x60, 0x23, 0xF8, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x40, 0xC1, 0x90, 0x40,
  0x24, 0x20, 0x05, 0x10, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x19, 0x80, 0x06,
  0x40, 0x01, 0x90, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20,
  0x00, 0xC8, 0x00, 0x22, 0x00, 0x18, 0x80, 0x06, 0x20, 0x03, 0x88, 0x00,
  0xC3, 0x00, 0x50, 0x40, 0x24, 0x18, 0x11, 0x03, 0xF8, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x04, 0x3C, 0x23,
  0x00, 0x90, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x0C, 0x0C, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x18, 0x0C, 0x1F, 0xF0, 0x00, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x1F, 0xF9, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xF0, 0x18, 0x00, 0xC4,
  0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x62, 0x00, 0x10, 0x80, 0x0C, 0x20,
  0x03, 0x08, 0x01, 0x42, 0x00, 0x60, 0x80, 0x28, 0x10, 0x32, 0x03, 0xF8,
  0x80, 0x80, 0x03, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x60, 0x40, 0x40, 0x40,
  0xC0, 0x20, 0x80, 0x21, 0x80, 0x21, 0x00, 0x23, 0x00, 0x22, 0x00, 0x26,
  0x00, 0x24, 0x00, 0x28, 0x00, 0x28, 0x00, 0x30, 0x00, 0x10, 0x00, 0xC0,
  0x08, 0x01, 0x40, 0x08, 0x01, 0x40, 0x18, 0x03, 0x40, 0x18, 0x02, 0x40,
  0x28, 0x02, 0x40, 0x28, 0x04, 0x40, 0x48, 0x04, 0x40, 0x48, 0x08, 0x40,
  0x84, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0x42,
  0x04, 0x20, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x4C,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x58, 0x05, 0x00, 0x50, 0x05, 0x00, 0x70,
  0x05, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x02, 0x00, 0x30, 0x20,
  0x06, 0x03, 0x00, 0x40, 0x10, 0x08, 0x01, 0x01, 0x00, 0x08, 0x30, 0x00,
  0x82, 0x00, 0x08, 0x40, 0x00, 0x48, 0x00, 0x05, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x09, 0x00, 0x01, 0x10, 0x00, 0x31, 0x80,
  0x06, 0x08, 0x00, 0x40, 0x80, 0x08, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x04,
  0x02, 0x00, 0x20, 0xC0, 0x02, 0x00, 0x00, 0x80, 0x02, 0x01, 0x00, 0x08,
  0x02, 0x00, 0x10, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x01,
  0x03, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x20, 0x00, 0x10,
  0xC0, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x48, 0x00, 0x00, 0xB0,
  0x00, 0x01, 0x40, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x82, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x78, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x78,
  0x00, 0xE0, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0xE0, 0xC0, 0x60, 0x1D, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 8, 11, 13, 5, -31 },
  { 43, 22, 31, 22, 1, -31 },
  { 129, 19, 36, 20, 1, -33 },
  { 215, 24, 32, 29, 3, -31 },
  { 311, 21, 31, 24, 1, -31 },
  { 393, 3, 11, 7, 5, -31 },
  { 398, 12, 38, 10, 1, -31 },
  { 455, 12, 38, 10, -3, -31 },
  { 512, 15, 16, 19, 5, -33 },
  { 542, 18, 20, 22, 2, -25 },
  { 587, 6, 11, 7, -2, -5 },
  { 596, 10, 1, 13, 1, -12 },
  { 598, 2, 3, 8, 1, -3 },
  { 599, 18, 31, 13, -2, -31 },
  { 669, 18, 31, 20, 2, -31 },
  { 739, 10, 31, 20, 6, -31 },
  { 778, 19, 31, 20, 0, -31 },
  { 852, 20, 31, 20, 0, -31 },
  { 930, 19, 31, 20, 0, -31 },
  { 1004, 19, 31, 20, 1, -31 },
  { 1078, 19, 31, 20, 2, -31 },
  { 1152, 17, 31, 20, 4, -31 },
  { 1218, 19, 31, 20, 1, -31 },
  { 1292, 19, 31, 20, 1, -31 },
  { 1366, 6, 23, 8, 1, -23 },
  { 1384, 9, 29, 8, -2, -23 },
  { 1417, 17, 19, 22, 3, -25 },
  { 1458, 18, 10, 22, 2, -20 },
  { 1481, 17, 19, 22, 3, -25 },
  { 1522, 14, 31, 15, 2, -31 },
  { 1577, 28, 35, 31, 2, -31 },
  { 1700, 20, 31, 20, -2, -31 },
  { 1778, 21, 31, 22, 1, -31 },
  { 1860, 21, 31, 22, 3, -31 },
  { 1942, 23, 31, 25, 1, -31 },
  { 2032, 20, 31, 20, 1, -31 },
  { 2110, 20, 31, 18, 1, -31 },
  { 2188, 23, 31, 26, 3, -31 },
  { 2278, 25, 31, 26, 1, -31 },
  { 2375, 13, 31, 10, -1, -31 },
  { 2426, 16, 38, 9, -7, -31 },
  { 2502, 23, 31, 20, 1, -31 },
  { 2592, 14, 31, 18, 1, -31 },
  { 2647, 30, 31, 31, 1, -31 },
  { 2764, 25, 31, 26, 1, -31 },
  { 2861, 22, 31, 26, 3, -31 },
  { 2947, 20, 31, 21, 1, -31 },
  { 3025, 22, 38, 26, 3, -31 },
  { 3130, 20, 31, 21, 1, -31 },
  { 3208, 20, 31, 19, 0, -31 },
  { 3286, 18, 31, 18, 4, -31 },
  { 3356, 23, 31, 26, 3, -31 },
  { 3446, 19, 31, 20, 4, -31 },
  { 3520, 30, 31, 32, 5, -31 },
  { 3637, 24, 31, 18, -3, -31 },
  { 3730, 18, 31, 18, 4, -31 },
  { 3800, 22, 31, 19, -1, -31 },
  { 3886, 16, 38, 13, -1, -31 },
  { 3962, 7, 31, 13, 4, -31 },
  { 3990, 16, 38, 13, -3, -31 },
  { 4066, 18, 18, 21, 2, -31 },
  { 4107, 14, 1, 14, -3, 4 },
  { 4109, 5, 7, 9, 6, -33 },
  { 4114, 18, 23, 21, 2, -23 },
  { 4166, 18, 33, 21, 1, -33 },
  { 4241, 15, 23, 17, 2, -23 },
  { 4285, 20, 33, 21, 2, -33 },
  { 4368, 15, 23, 19, 2, -23 },
  { 4412, 22, 43, 10, -6, -33 },
  { 4531, 20, 33, 21, 0, -23 },
  { 4614, 18, 33, 21, 1, -33 },
  { 4689, 8, 31, 8, 1, -31 },
  { 4720, 15, 41, 8, -6, -31 },
  { 4797, 17, 33, 17, 1, -33 },
  { 4868, 8, 33, 8, 1, -33 },
  { 4901, 28, 23, 32, 1, -23 },
  { 4982, 18, 23, 21, 1, -23 },
  { 5034, 17, 23, 21, 2, -23 },
  { 5083, 20, 33, 21, -1, -23 },
  { 5166, 18, 33, 21, 2, -23 },
  { 5241, 14, 23, 14, 1, -23 },
  { 5282, 15, 23, 16, 0, -23 },
  { 5326, 10, 28, 11, 2, -28 },
  { 5361, 18, 23, 21, 2, -23 },
  { 5413, 16, 23, 15, 2, -23 },
  { 5459, 24, 23, 25, 2, -23 },
  { 5528, 20, 23, 17, -2, -23 },
  { 5586, 23, 33, 16, -5, -23 },
  { 5681, 17, 23, 15, -1, -23 },
  { 5730, 15, 38, 14, 1, -31 },
  { 5802, 1, 43, 20, 10, -33 },
  { 5808, 15, 38, 14, -2, -31 },
  { 5880, 17, 4, 22, 3, -17 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC43PT7B_H_
