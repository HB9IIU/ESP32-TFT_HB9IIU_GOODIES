#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0x80, 0x14, 0x29, 0xF9, 0x22, 0x97,
  0x92, 0x28, 0x50, 0x08, 0xF5, 0x14, 0x30, 0x41, 0x8A, 0xA9, 0xC2, 0x00,
  0xF3, 0x2A, 0xA5, 0x7B, 0xAD, 0x4A, 0xA9, 0x8C, 0x3C, 0x48, 0xA1, 0x83,
  0x0A, 0x63, 0x44, 0xF4, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x40, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x2C, 0x7A, 0x20, 0x21, 0x09, 0xF2, 0x10,
  0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x80, 0x7C, 0x63,
  0x18, 0xC6, 0x52, 0xE0, 0x75, 0x24, 0x94, 0x80, 0x3C, 0x10, 0x41, 0x08,
  0x42, 0x10, 0xF8, 0x7C, 0x10, 0x42, 0x38, 0x20, 0x82, 0xF0, 0x04, 0x21,
  0x4A, 0x4A, 0x2F, 0xC2, 0x10, 0x3C, 0x84, 0x1C, 0x08, 0x10, 0x42, 0xF0,
  0x3A, 0x21, 0xE8, 0xC6, 0x32, 0xE0, 0x78, 0x44, 0x22, 0x11, 0x08, 0x80,
  0x3D, 0x14, 0x4A, 0x31, 0x28, 0x62, 0x78, 0x3D, 0x14, 0x51, 0x4C, 0xD0,
  0x82, 0xF0, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x3A, 0x20, 0xC1, 0x80,
  0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xF1, 0x12, 0x48, 0x80, 0x80, 0x3E,
  0x41, 0x99, 0xA5, 0xA5, 0xC9, 0xCA, 0xB4, 0x80, 0x78, 0x04, 0x31, 0x45,
  0x24, 0xF4, 0x51, 0x84, 0x3E, 0x45, 0x0A, 0x27, 0x88, 0x91, 0x42, 0xF8,
  0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x78, 0x3C, 0x45, 0x0A, 0x14, 0x28,
  0x50, 0xC2, 0xF8, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x20, 0xF8, 0x3C, 0x84,
  0x10, 0x79, 0x04, 0x20, 0x80, 0x3E, 0x82, 0x04, 0x08, 0xD0, 0xA1, 0x42,
  0x78, 0x21, 0x21, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x84, 0x84, 0x32, 0x24,
  0x44, 0x44, 0xC0, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x22, 0x49,
  0x22, 0x87, 0x0A, 0x12, 0x44, 0x88, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x20,
  0x90, 0x54, 0x6A, 0x35, 0x2A, 0xA5, 0x55, 0x32, 0x89, 0x00, 0x21, 0x21,
  0x51, 0x52, 0x4A, 0x4A, 0x4A, 0x84, 0x84, 0x7C, 0x86, 0x0C, 0x18, 0x30,
  0xA1, 0x42, 0x78, 0x3C, 0x94, 0x51, 0x79, 0x04, 0x20, 0x80, 0x7C, 0x86,
  0x0C, 0x18, 0x30, 0xA1, 0x42, 0x68, 0x20, 0x40, 0x3C, 0x94, 0x51, 0x79,
  0x44, 0xA2, 0x88, 0x3D, 0x04, 0x08, 0x10, 0x20, 0x82, 0xF0, 0xFC, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x80, 0x42, 0x86, 0x0C, 0x28, 0x50, 0xA1, 0x44,
  0xF0, 0x86, 0x28, 0xA4, 0x92, 0x8A, 0x10, 0x40, 0x88, 0x62, 0x29, 0x4A,
  0x54, 0xA5, 0x29, 0x8C, 0x61, 0x10, 0x84, 0x00, 0x22, 0x28, 0x50, 0x41,
  0x05, 0x0A, 0x24, 0x84, 0x8E, 0x29, 0x18, 0x41, 0x04, 0x10, 0x40, 0x3C,
  0x10, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x39, 0x10, 0x84, 0x22, 0x10, 0x84,
  0x30, 0xA9, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x42, 0x21, 0x38, 0x32,
  0x95, 0x18, 0x80, 0xF0, 0xC0, 0x7C, 0x63, 0x19, 0x4B, 0xC0, 0x20, 0x82,
  0x1F, 0x45, 0x14, 0x61, 0x8B, 0xC0, 0x78, 0x88, 0x88, 0xF0, 0x04, 0x10,
  0x5E, 0x8A, 0x28, 0xA4, 0x93, 0xC0, 0x79, 0x9E, 0x88, 0xF0, 0x06, 0x10,
  0x20, 0xA1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x0C, 0x00, 0x3D, 0x14,
  0x61, 0x8A, 0x27, 0x82, 0x0B, 0xC0, 0x20, 0x82, 0x1F, 0x45, 0x14, 0x62,
  0x8A, 0x20, 0x21, 0x24, 0xA4, 0x80, 0x08, 0x04, 0x21, 0x08, 0x44, 0x21,
  0x09, 0x80, 0x20, 0x82, 0x13, 0x49, 0x46, 0x14, 0x92, 0x40, 0x24, 0xA4,
  0x94, 0x90, 0x7B, 0xA2, 0x51, 0x29, 0x18, 0x8C, 0x4A, 0x24, 0x7D, 0x14,
  0x51, 0x8A, 0x28, 0x80, 0x74, 0x63, 0x18, 0xCB, 0x80, 0x7D, 0x14, 0x51,
  0x86, 0x2F, 0x20, 0x82, 0x00, 0x7C, 0x63, 0x19, 0x4B, 0xC2, 0x11, 0x00,
  0x7A, 0x10, 0x88, 0x42, 0x00, 0x7A, 0x10, 0x41, 0x0B, 0xC0, 0x24, 0x74,
  0x44, 0x88, 0xC0, 0x8C, 0x63, 0x19, 0x4B, 0xC0, 0x99, 0xAA, 0xC8, 0x80,
  0x93, 0x26, 0xD6, 0xAD, 0x91, 0x24, 0x00, 0x4A, 0x4C, 0x46, 0x4A, 0x40,
  0x44, 0x92, 0x4A, 0x30, 0xC2, 0x08, 0x43, 0x00, 0x78, 0x84, 0x44, 0x43,
  0xC0, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF8, 0x18, 0x44,
  0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 7, 9, 9, 1, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 1, 3, 2, 1, -9 },
  { 41, 4, 11, 3, 0, -9 },
  { 47, 4, 11, 3, -1, -9 },
  { 53, 4, 5, 6, 2, -10 },
  { 56, 5, 6, 7, 1, -8 },
  { 60, 2, 3, 2, -1, -1 },
  { 61, 3, 1, 4, 0, -4 },
  { 62, 1, 1, 2, 0, -1 },
  { 63, 6, 9, 4, -1, -9 },
  { 70, 5, 9, 6, 1, -9 },
  { 76, 3, 9, 6, 2, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 1, -9 },
  { 114, 5, 9, 6, 1, -9 },
  { 120, 6, 9, 6, 0, -9 },
  { 127, 6, 9, 6, 0, -9 },
  { 134, 2, 7, 2, 0, -7 },
  { 136, 3, 9, 2, -1, -7 },
  { 140, 5, 5, 7, 1, -7 },
  { 144, 5, 3, 7, 1, -6 },
  { 146, 5, 5, 7, 1, -7 },
  { 150, 4, 9, 4, 1, -9 },
  { 155, 8, 10, 9, 1, -9 },
  { 165, 6, 9, 6, -1, -9 },
  { 172, 7, 9, 7, 0, -9 },
  { 180, 6, 9, 7, 1, -9 },
  { 187, 7, 9, 8, 0, -9 },
  { 195, 6, 9, 6, 0, -9 },
  { 202, 6, 9, 6, 0, -9 },
  { 209, 7, 9, 8, 1, -9 },
  { 217, 8, 9, 8, 0, -9 },
  { 226, 4, 9, 3, 0, -9 },
  { 231, 5, 11, 3, -2, -9 },
  { 238, 7, 9, 6, 0, -9 },
  { 246, 4, 9, 5, 0, -9 },
  { 251, 9, 9, 9, 0, -9 },
  { 262, 8, 9, 8, 0, -9 },
  { 271, 7, 9, 8, 1, -9 },
  { 279, 6, 9, 6, 0, -9 },
  { 286, 7, 11, 8, 1, -9 },
  { 296, 6, 9, 6, 0, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 5, 1, -9 },
  { 317, 7, 9, 8, 1, -9 },
  { 325, 6, 9, 6, 1, -9 },
  { 332, 10, 9, 10, 1, -9 },
  { 344, 7, 9, 5, -1, -9 },
  { 352, 6, 9, 5, 1, -9 },
  { 359, 6, 9, 6, 0, -9 },
  { 366, 5, 11, 4, 0, -9 },
  { 373, 2, 9, 4, 1, -9 },
  { 376, 5, 11, 4, -1, -9 },
  { 383, 5, 5, 6, 1, -9 },
  { 387, 4, 1, 4, -1, 1 },
  { 388, 1, 2, 3, 2, -10 },
  { 389, 5, 7, 6, 1, -7 },
  { 394, 6, 10, 6, 0, -10 },
  { 402, 4, 7, 5, 1, -7 },
  { 406, 6, 10, 6, 1, -10 },
  { 414, 4, 7, 6, 1, -7 },
  { 418, 7, 13, 3, -2, -10 },
  { 430, 6, 10, 6, 0, -7 },
  { 438, 6, 10, 6, 0, -10 },
  { 446, 3, 9, 2, 0, -9 },
  { 450, 5, 12, 2, -2, -9 },
  { 458, 6, 10, 5, 0, -10 },
  { 466, 3, 10, 2, 0, -10 },
  { 470, 9, 7, 10, 0, -7 },
  { 478, 6, 7, 6, 0, -7 },
  { 484, 5, 7, 6, 1, -7 },
  { 489, 6, 10, 6, 0, -7 },
  { 497, 5, 10, 6, 1, -7 },
  { 504, 5, 7, 4, 0, -7 },
  { 509, 5, 7, 5, 0, -7 },
  { 514, 4, 9, 3, 0, -9 },
  { 519, 5, 7, 6, 1, -7 },
  { 524, 4, 7, 5, 1, -7 },
  { 528, 7, 7, 8, 1, -7 },
  { 535, 5, 7, 5, 0, -7 },
  { 540, 6, 10, 5, -1, -7 },
  { 548, 5, 7, 5, 0, -7 },
  { 553, 5, 11, 4, 0, -9 },
  { 560, 1, 13, 6, 3, -10 },
  { 562, 5, 11, 4, -1, -9 },
  { 569, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC13PT7B_H_
