#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x35, 0x76, 0xFA, 0x34, 0x42, 0x6C, 0x9E, 0xAD,
  0xBA, 0x75, 0x2F, 0x9F, 0xC0, 0x5A, 0xA8, 0x24, 0x92, 0xB0, 0xCF, 0x00,
  0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x75, 0x99, 0x9E, 0x75,
  0xA0, 0x71, 0x12, 0x4E, 0x71, 0x16, 0x1E, 0x12, 0x5A, 0xF2, 0x74, 0xE1,
  0x1E, 0x34, 0xE9, 0x9E, 0xE5, 0x29, 0x00, 0x75, 0x66, 0x9E, 0x79, 0x96,
  0x2E, 0x10, 0x18, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x64, 0xA9, 0x00, 0x39,
  0x1B, 0x75, 0xDA, 0x87, 0x00, 0x2D, 0xFB, 0x40, 0x75, 0x5B, 0x9E, 0x72,
  0x49, 0x80, 0x75, 0x59, 0x9E, 0x74, 0x68, 0x8E, 0x74, 0x4A, 0x88, 0x78,
  0x8B, 0xAE, 0x4A, 0x5B, 0x29, 0x48, 0x56, 0xA0, 0x24, 0xA4, 0xB0, 0x55,
  0x6A, 0xAA, 0x49, 0x49, 0xC0, 0x45, 0x14, 0xAD, 0xAA, 0xA0, 0x4A, 0x53,
  0x6B, 0x48, 0x69, 0x99, 0x9E, 0x75, 0x56, 0x88, 0x69, 0x99, 0x9A, 0x40,
  0x75, 0x5A, 0xAA, 0x78, 0x42, 0x2E, 0xEA, 0x49, 0x00, 0x99, 0x99, 0xAE,
  0xB6, 0xE9, 0x00, 0xAD, 0x7B, 0x69, 0x50, 0x56, 0x44, 0xAA, 0xB7, 0x49,
  0x00, 0x71, 0x24, 0x8E, 0x69, 0x49, 0x20, 0xFC, 0x24, 0x92, 0x70, 0x26,
  0x59, 0xE0, 0x80, 0x79, 0xAE, 0x46, 0x59, 0x9E, 0x72, 0x70, 0x13, 0x59,
  0x9E, 0x7E, 0x70, 0x36, 0x24, 0x44, 0x48, 0x79, 0x9E, 0x2E, 0x49, 0xDB,
  0x40, 0x46, 0xA0, 0x20, 0xA4, 0x94, 0x49, 0xAD, 0x40, 0x56, 0xA0, 0x7C,
  0xEB, 0x50, 0x76, 0xD0, 0x79, 0x9E, 0x79, 0x9E, 0x88, 0x79, 0x9E, 0x22,
  0x72, 0x40, 0xE8, 0xF0, 0x6A, 0x80, 0x99, 0xAE, 0xB7, 0x40, 0xAF, 0x5D,
  0x40, 0x6B, 0x50, 0x55, 0x64, 0x4C, 0x6A, 0x60, 0x29, 0x65, 0x30, 0xFF,
  0x55, 0x58, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 4, 6, 5, 1, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 3, 7, 2, -1, -6 },
  { 22, 3, 3, 4, 1, -6 },
  { 24, 4, 4, 4, 0, -5 },
  { 26, 1, 2, 1, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 6, 2, 0, -6 },
  { 32, 4, 6, 4, 0, -6 },
  { 35, 2, 6, 4, 1, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 3, 6, 4, 1, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 1, 4, 2, 0, -4 },
  { 62, 1, 5, 2, 0, -4 },
  { 63, 4, 4, 4, 0, -5 },
  { 65, 4, 2, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 3, 6, 3, 0, -6 },
  { 71, 6, 7, 6, 0, -6 },
  { 77, 3, 6, 4, 0, -6 },
  { 80, 4, 6, 4, 0, -6 },
  { 83, 3, 6, 4, 1, -6 },
  { 86, 4, 6, 5, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 4, 6, 3, 0, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 3, 7, 2, -1, -6 },
  { 107, 4, 6, 4, 0, -6 },
  { 110, 3, 6, 3, 0, -6 },
  { 113, 6, 6, 6, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 4, 6, 5, 1, -6 },
  { 125, 4, 6, 4, 0, -6 },
  { 128, 4, 7, 5, 1, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 3, 6, 3, 1, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 3, 6, 4, 1, -6 },
  { 147, 5, 6, 6, 1, -6 },
  { 151, 4, 6, 3, 0, -6 },
  { 154, 3, 6, 3, 1, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 3, 7, 2, 0, -6 },
  { 163, 1, 6, 2, 1, -6 },
  { 164, 3, 7, 2, -1, -6 },
  { 167, 4, 4, 4, 0, -6 },
  { 169, 3, 1, 3, -1, 0 },
  { 170, 1, 1, 2, 1, -6 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 4, 6, 4, 0, -6 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 4, 8, 2, -1, -6 },
  { 187, 4, 6, 4, 0, -4 },
  { 190, 3, 6, 4, 0, -6 },
  { 193, 2, 6, 2, 0, -6 },
  { 195, 3, 8, 2, -1, -6 },
  { 198, 3, 6, 3, 0, -6 },
  { 201, 2, 6, 1, 0, -6 },
  { 203, 5, 4, 6, 0, -4 },
  { 206, 3, 4, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 4, 6, 4, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 2, 5, 2, 0, -5 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 5, 4, 5, 0, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 4, 6, 3, -1, -4 },
  { 234, 3, 4, 3, 0, -4 },
  { 236, 3, 7, 3, 0, -6 },
  { 239, 1, 8, 4, 1, -6 },
  { 240, 2, 7, 3, 0, -6 },
  { 242, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC8PT7B_H_
