#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x24, 0x44, 0x44, 0x00, 0x08, 0x4C, 0x65,
  0x29, 0x4A, 0x40, 0x02, 0x20, 0x42, 0x04, 0x20, 0x44, 0x04, 0x47, 0xFF,
  0x08, 0x40, 0x88, 0x10, 0x81, 0x08, 0x11, 0x0F, 0xFE, 0x21, 0x02, 0x20,
  0x22, 0x04, 0x20, 0x42, 0x04, 0x40, 0x01, 0x00, 0x40, 0xF8, 0x49, 0x22,
  0x08, 0x82, 0x20, 0x90, 0x14, 0x03, 0x00, 0x60, 0x24, 0x08, 0x82, 0x20,
  0x88, 0x24, 0x93, 0x1F, 0x01, 0x00, 0x40, 0x3C, 0x09, 0x10, 0x44, 0x42,
  0x21, 0x08, 0x84, 0x42, 0x11, 0x08, 0x48, 0x21, 0x4E, 0x89, 0x46, 0x2A,
  0x1F, 0x48, 0x41, 0x21, 0x09, 0x04, 0x44, 0x21, 0x10, 0x88, 0x42, 0x41,
  0x11, 0x03, 0x80, 0x07, 0x80, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08,
  0x09, 0x00, 0xE0, 0x08, 0x03, 0x40, 0x42, 0x18, 0x22, 0x81, 0x28, 0x14,
  0x80, 0x88, 0x08, 0x83, 0x47, 0xC2, 0x6A, 0xA8, 0x06, 0x08, 0x20, 0x82,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x04, 0x08, 0x00, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x41, 0x02, 0x18, 0x00,
  0x04, 0x04, 0x22, 0x0D, 0x01, 0xF8, 0xC0, 0x91, 0x88, 0x02, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x24, 0xA5, 0x00, 0xFC, 0x80, 0x00, 0x60, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00, 0x07, 0x82,
  0x11, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x42, 0x0F, 0x00, 0x09, 0xD3, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x00, 0x07, 0xC1, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xF0, 0x07, 0xC1,
  0x82, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x0F, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x8F,
  0xE0, 0x00, 0x20, 0x0C, 0x02, 0x80, 0x90, 0x14, 0x04, 0x81, 0x10, 0x42,
  0x08, 0x42, 0x10, 0x82, 0x20, 0x48, 0x08, 0xFF, 0xC0, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x02, 0xF0, 0x30, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x0F, 0xE0, 0x03, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0xF8, 0x60, 0x88, 0x12, 0x01, 0x40, 0x28, 0x05, 0x01,
  0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x82, 0x08, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x84, 0x20, 0x48, 0x06, 0x03, 0x41, 0x84, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x24, 0x04, 0x81, 0x0F, 0xC0, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x05, 0x01, 0x40, 0x48, 0x71, 0xE4, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x3E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x44, 0x21, 0x10, 0x00, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x80, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x3E, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xF8, 0x03, 0x04, 0x0C, 0x02, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x61, 0x41, 0x11, 0x42, 0x11, 0x44, 0x11, 0x84, 0x21, 0x88,
  0x21, 0x88, 0x21, 0x88, 0x42, 0x88, 0x64, 0x87, 0xB8, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x40, 0x18, 0x05, 0x00,
  0xA0, 0x24, 0x04, 0x81, 0x10, 0x22, 0x08, 0x21, 0x04, 0x7F, 0x88, 0x12,
  0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x0F, 0x81, 0x02, 0x10,
  0x11, 0x01, 0x10, 0x12, 0x02, 0x20, 0x22, 0x04, 0x3F, 0x84, 0x08, 0x40,
  0x44, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x08, 0x81, 0x8F, 0xE0, 0x07,
  0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x03, 0xF0, 0x0F, 0x80, 0x83, 0x04, 0x04, 0x20, 0x21, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x20,
  0x12, 0x01, 0x10, 0x10, 0x83, 0x07, 0xE0, 0x00, 0x0F, 0xE2, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0x88, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xE0, 0x0F, 0xE2, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xF1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x07, 0xF0,
  0x40, 0x44, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x0F, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08,
  0x40, 0x41, 0xFC, 0x00, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x20,
  0x08, 0x80, 0x22, 0x00, 0x88, 0x04, 0x3F, 0xF1, 0x00, 0x44, 0x01, 0x10,
  0x04, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x00,
  0x1E, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x41, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x87, 0x80, 0x10, 0x08, 0x81, 0x84, 0x10, 0x21, 0x02,
  0x10, 0x11, 0x00, 0x90, 0x05, 0x00, 0x34, 0x03, 0x20, 0x11, 0x00, 0x84,
  0x04, 0x20, 0x20, 0x82, 0x04, 0x10, 0x20, 0x80, 0x84, 0x04, 0x00, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0xFF, 0x08, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x51, 0x80, 0x31, 0x40, 0x28, 0x90, 0x24, 0x48, 0x12, 0x24, 0x11,
  0x22, 0x09, 0x11, 0x08, 0x88, 0x84, 0x44, 0x44, 0x22, 0x22, 0x12, 0x0A,
  0x11, 0x06, 0x08, 0x83, 0x04, 0x41, 0x02, 0x00, 0x10, 0x04, 0x60, 0x11,
  0x80, 0x46, 0x02, 0x24, 0x08, 0x90, 0x22, 0x20, 0x88, 0x82, 0x22, 0x11,
  0x04, 0x44, 0x11, 0x10, 0x44, 0x40, 0xA1, 0x02, 0x88, 0x0A, 0x20, 0x18,
  0x80, 0x62, 0x01, 0x00, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x40, 0x24, 0x00,
  0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28,
  0x01, 0x40, 0x12, 0x00, 0x90, 0x08, 0x40, 0x81, 0xF8, 0x00, 0x0F, 0x02,
  0x08, 0x40, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x48, 0x61,
  0xF0, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x07,
  0xC0, 0xC1, 0x08, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90,
  0x08, 0x40, 0x81, 0xD8, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x0F,
  0x82, 0x08, 0x40, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x87,
  0xE1, 0x08, 0x21, 0x04, 0x20, 0x82, 0x20, 0x44, 0x08, 0x80, 0x90, 0x10,
  0x07, 0xE1, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x20, 0x04, 0x01, 0x1F,
  0xC0, 0xFF, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x81, 0x03, 0xF0, 0x00, 0x80, 0x38, 0x02, 0x80,
  0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04, 0x10, 0x42, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x20, 0x02, 0x00, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x60, 0x50, 0x30, 0x28, 0x28, 0x14, 0x14, 0x12,
  0x12, 0x09, 0x09, 0x08, 0x88, 0x84, 0x44, 0x44, 0x24, 0x22, 0x12, 0x12,
  0x09, 0x09, 0x05, 0x04, 0x82, 0x82, 0x81, 0x81, 0x40, 0xC0, 0x40, 0x40,
  0x20, 0x00, 0x08, 0x08, 0x40, 0x42, 0x04, 0x08, 0x40, 0x44, 0x02, 0x20,
  0x0A, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x40, 0x12, 0x01, 0x10, 0x08,
  0x40, 0x82, 0x08, 0x10, 0x40, 0x44, 0x02, 0x00, 0x80, 0x70, 0x09, 0x02,
  0x20, 0x44, 0x10, 0x84, 0x08, 0x81, 0x20, 0x28, 0x05, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x07, 0xF8, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x07, 0xFE, 0x00, 0x0F, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x07, 0x80, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x11,
  0x11, 0x07, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x3E, 0x00, 0x02, 0x00, 0x60, 0x14, 0x04, 0x80, 0x88,
  0x21, 0x08, 0x21, 0x02, 0x40, 0x50, 0x0C, 0xFF, 0xA5, 0x1F, 0x48, 0x32,
  0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x0C,
  0x7D, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0xC2, 0xC8, 0xC1,
  0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xB0,
  0x4B, 0xE0, 0x1F, 0x90, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x03, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x62, 0x19, 0xA2, 0x0A, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80,
  0x48, 0x08, 0x80, 0x88, 0x18, 0x81, 0x88, 0x28, 0x7D, 0x00, 0x0F, 0x88,
  0x48, 0x28, 0x14, 0x14, 0x33, 0xA1, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03,
  0xE0, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x0F, 0xC0,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0xC0, 0x00, 0x0F, 0xD1, 0x05, 0x10, 0x22, 0x02, 0x20, 0x24, 0x02,
  0x40, 0x24, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xC4, 0x18, 0x3E, 0x80, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0xFC, 0x00, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0xC2, 0xC8, 0xC1, 0x20, 0x48, 0x14, 0x05, 0x02, 0x40,
  0x90, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x10, 0x11, 0x00, 0x02, 0x22,
  0x44, 0x44, 0x48, 0x88, 0x88, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x12, 0x08, 0x84, 0x22, 0x11, 0x04, 0x81, 0x40, 0x68, 0x12, 0x08, 0x42,
  0x10, 0x84, 0x20, 0x88, 0x20, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x88, 0x88, 0x80, 0x2F, 0x9F, 0x30, 0xA1, 0x20, 0x41, 0x20, 0x81, 0x40,
  0x81, 0x40, 0x81, 0x40, 0x81, 0x41, 0x02, 0x81, 0x02, 0x81, 0x02, 0x81,
  0x02, 0x81, 0x04, 0x82, 0x04, 0x2F, 0x8C, 0x12, 0x04, 0x81, 0x40, 0x50,
  0x24, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x00, 0x1F, 0x88,
  0x12, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x09,
  0x04, 0x3E, 0x00, 0x0B, 0xE0, 0xC1, 0x08, 0x10, 0x81, 0x10, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x23, 0x04, 0x2F, 0x84, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x1F, 0xA4, 0x14, 0x81,
  0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x32, 0x06, 0x41,
  0x47, 0xD0, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x2F,
  0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1F, 0x90, 0x08, 0x04, 0x02, 0x00, 0x80, 0x30, 0x04, 0x02, 0x00, 0x80,
  0x80, 0x4F, 0xC0, 0x10, 0x82, 0x3F, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x3C, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x24, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x12, 0x0C, 0x7D, 0x00, 0x80, 0xC0, 0xA0, 0x48,
  0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14, 0x04, 0x02, 0x00, 0x81,
  0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x0A, 0x24, 0x48, 0x91, 0x14,
  0x48, 0x51, 0x21, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x80, 0x10, 0x21,
  0x08, 0x22, 0x04, 0x40, 0x50, 0x0C, 0x01, 0x00, 0x50, 0x12, 0x02, 0x20,
  0x84, 0x20, 0x88, 0x08, 0x08, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x42,
  0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x38, 0x00, 0x0F,
  0xC0, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0x00, 0x03, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x60, 0xC0, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x02, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x78, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 5, 1, -18 },
  { 10, 5, 7, 7, 3, -18 },
  { 15, 12, 18, 13, 1, -18 },
  { 42, 10, 20, 12, 1, -19 },
  { 67, 14, 18, 17, 2, -18 },
  { 99, 12, 18, 14, 1, -18 },
  { 126, 2, 7, 4, 3, -18 },
  { 128, 7, 22, 6, 1, -18 },
  { 148, 7, 22, 6, -2, -18 },
  { 168, 9, 9, 11, 3, -19 },
  { 179, 11, 12, 13, 1, -15 },
  { 196, 3, 6, 4, -1, -3 },
  { 199, 6, 1, 7, 1, -7 },
  { 200, 1, 1, 5, 1, -1 },
  { 201, 11, 18, 8, -1, -18 },
  { 226, 10, 18, 12, 1, -18 },
  { 249, 5, 18, 12, 4, -18 },
  { 261, 11, 18, 12, 0, -18 },
  { 286, 12, 18, 12, 0, -18 },
  { 313, 11, 18, 12, 0, -18 },
  { 338, 12, 18, 12, 0, -18 },
  { 365, 11, 18, 12, 1, -18 },
  { 390, 10, 18, 12, 2, -18 },
  { 413, 11, 18, 12, 1, -18 },
  { 438, 10, 18, 12, 1, -18 },
  { 461, 3, 13, 5, 1, -13 },
  { 466, 5, 16, 5, -1, -13 },
  { 476, 11, 10, 13, 1, -14 },
  { 490, 11, 6, 13, 1, -12 },
  { 499, 11, 10, 13, 1, -14 },
  { 513, 8, 18, 9, 1, -18 },
  { 531, 16, 20, 18, 1, -18 },
  { 571, 11, 18, 12, -1, -18 },
  { 596, 12, 18, 13, 1, -18 },
  { 623, 12, 18, 13, 2, -18 },
  { 650, 13, 18, 14, 1, -18 },
  { 680, 11, 18, 12, 1, -18 },
  { 705, 11, 18, 11, 1, -18 },
  { 730, 13, 18, 15, 2, -18 },
  { 760, 14, 18, 15, 1, -18 },
  { 792, 7, 18, 6, 0, -18 },
  { 808, 9, 22, 5, -4, -18 },
  { 833, 13, 18, 12, 1, -18 },
  { 863, 8, 18, 11, 1, -18 },
  { 881, 17, 18, 18, 1, -18 },
  { 920, 14, 18, 15, 1, -18 },
  { 952, 13, 18, 15, 2, -18 },
  { 982, 11, 18, 12, 1, -18 },
  { 1007, 13, 22, 15, 2, -18 },
  { 1043, 11, 18, 12, 1, -18 },
  { 1068, 11, 18, 11, 0, -18 },
  { 1093, 11, 18, 10, 2, -18 },
  { 1118, 13, 18, 15, 2, -18 },
  { 1148, 12, 18, 12, 2, -18 },
  { 1175, 17, 18, 19, 3, -18 },
  { 1214, 13, 18, 11, -1, -18 },
  { 1244, 11, 18, 10, 2, -18 },
  { 1269, 13, 18, 11, -1, -18 },
  { 1299, 9, 22, 7, 0, -18 },
  { 1324, 4, 18, 8, 2, -18 },
  { 1333, 10, 22, 7, -2, -18 },
  { 1361, 11, 10, 12, 1, -18 },
  { 1375, 8, 1, 8, -2, 2 },
  { 1376, 2, 4, 5, 4, -19 },
  { 1377, 10, 13, 12, 1, -13 },
  { 1394, 10, 19, 12, 1, -19 },
  { 1418, 9, 13, 10, 1, -13 },
  { 1433, 12, 19, 12, 1, -19 },
  { 1462, 9, 13, 11, 1, -13 },
  { 1477, 12, 25, 6, -3, -19 },
  { 1515, 12, 19, 12, 0, -13 },
  { 1544, 10, 19, 12, 1, -19 },
  { 1568, 4, 18, 5, 1, -18 },
  { 1577, 8, 24, 5, -3, -18 },
  { 1601, 10, 19, 10, 1, -19 },
  { 1625, 4, 19, 5, 1, -19 },
  { 1635, 16, 13, 18, 1, -13 },
  { 1661, 10, 13, 12, 1, -13 },
  { 1678, 10, 13, 12, 1, -13 },
  { 1695, 12, 19, 12, -1, -13 },
  { 1724, 11, 19, 12, 1, -13 },
  { 1751, 8, 13, 8, 1, -13 },
  { 1764, 9, 13, 9, 0, -13 },
  { 1779, 6, 16, 7, 1, -16 },
  { 1791, 10, 13, 12, 1, -13 },
  { 1808, 9, 13, 9, 1, -13 },
  { 1823, 14, 13, 15, 1, -13 },
  { 1846, 11, 13, 10, -1, -13 },
  { 1864, 13, 19, 9, -3, -13 },
  { 1895, 10, 13, 9, -1, -13 },
  { 1912, 8, 22, 8, 1, -18 },
  { 1934, 1, 25, 12, 6, -19 },
  { 1938, 8, 22, 8, -1, -18 },
  { 1960, 11, 2, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC25PT7B_H_
