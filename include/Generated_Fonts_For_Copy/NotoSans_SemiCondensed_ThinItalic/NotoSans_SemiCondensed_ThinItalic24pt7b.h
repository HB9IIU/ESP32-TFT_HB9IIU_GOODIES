#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0x80, 0x8C, 0xA5,
  0x29, 0x50, 0x04, 0x20, 0x44, 0x04, 0x40, 0x84, 0x08, 0x47, 0xFF, 0x08,
  0x81, 0x08, 0x11, 0x01, 0x10, 0x21, 0x0F, 0xFC, 0x22, 0x04, 0x20, 0x42,
  0x04, 0x40, 0x44, 0x00, 0x02, 0x00, 0x81, 0xFC, 0x88, 0x22, 0x09, 0x02,
  0x40, 0x90, 0x14, 0x03, 0x00, 0xA0, 0x24, 0x08, 0x82, 0x41, 0x10, 0x48,
  0x7C, 0x04, 0x01, 0x00, 0x3C, 0x12, 0x21, 0x11, 0x09, 0x08, 0x88, 0x48,
  0x42, 0x42, 0x24, 0xD1, 0x49, 0x8A, 0x8D, 0xA4, 0x51, 0x42, 0x12, 0x11,
  0x10, 0x88, 0x88, 0x84, 0x48, 0x22, 0xC1, 0xE0, 0x0F, 0x81, 0x10, 0x41,
  0x08, 0x41, 0x08, 0x22, 0x02, 0x80, 0x60, 0x14, 0x04, 0x85, 0x08, 0xC1,
  0x18, 0x15, 0x01, 0x20, 0x64, 0x12, 0x7C, 0x40, 0xFC, 0x04, 0x21, 0x04,
  0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x40, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x20, 0x82, 0x0C, 0x00, 0x08, 0x08, 0xC8, 0x29,
  0x16, 0x28, 0x48, 0x84, 0x04, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F,
  0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x25, 0x25, 0x00, 0xF8, 0x80,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x84,
  0x12, 0x04, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x11, 0x08, 0x3C, 0x00, 0x19, 0x74, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x0F, 0xC2, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0x80, 0x0F, 0xC2, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x0C, 0x0F, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0xFE, 0x00, 0x00, 0x60, 0x14, 0x03, 0x00,
  0xA0, 0x24, 0x08, 0x82, 0x10, 0x44, 0x10, 0x84, 0x11, 0x02, 0x20, 0x8F,
  0xFE, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0xF8, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0xFE, 0x00, 0x07, 0xC2, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0xE1, 0xC4, 0xC0, 0xB0, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x11, 0x08, 0x3C, 0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x21, 0x10,
  0x28, 0x1E, 0x18, 0x48, 0x12, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x7E,
  0x00, 0x0F, 0x84, 0x22, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40,
  0x8D, 0xE0, 0x88, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0xF8, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x44, 0x21, 0x10, 0x00, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x00, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x04, 0x04,
  0x08, 0x02, 0x10, 0x02, 0x20, 0x01, 0x41, 0xF1, 0x42, 0x21, 0x44, 0x21,
  0x88, 0x21, 0x88, 0x22, 0x88, 0x42, 0x88, 0x42, 0x88, 0xC4, 0x8D, 0x28,
  0x82, 0x10, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x80,
  0x10, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x7F, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x1F, 0xC2,
  0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0xEC, 0x43, 0x08, 0x11,
  0x01, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x24, 0x08, 0xFC, 0x00, 0x07, 0xE3,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x00, 0x1F, 0xC1,
  0x02, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x04, 0x80, 0x88, 0x30, 0xFC, 0x00,
  0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFE, 0x00,
  0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F,
  0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00,
  0x07, 0xF1, 0x80, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x83, 0xC8, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x44, 0x04,
  0x3F, 0x80, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08,
  0x80, 0x47, 0xFE, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40,
  0x12, 0x01, 0x10, 0x08, 0x80, 0x40, 0x1E, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0xE0, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0F, 0x00, 0x10, 0x11, 0x02,
  0x10, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24, 0x02, 0x80, 0x54, 0x06, 0x40,
  0x44, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x80, 0x80, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0xFE, 0x10, 0x01, 0x18, 0x01, 0x18, 0x03, 0x28, 0x05, 0x28, 0x05,
  0x28, 0x0A, 0x28, 0x0A, 0x24, 0x12, 0x44, 0x12, 0x44, 0x22, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x84, 0x84, 0x84, 0x85, 0x04, 0x82, 0x08, 0x82, 0x08,
  0x10, 0x08, 0xC0, 0x46, 0x02, 0x50, 0x12, 0x40, 0x92, 0x08, 0x90, 0x44,
  0x42, 0x42, 0x12, 0x11, 0x10, 0x48, 0x82, 0x44, 0x12, 0x40, 0x52, 0x03,
  0x10, 0x08, 0x80, 0x40, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x01, 0x40, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x1F, 0x82, 0x08, 0x40, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x11, 0x02, 0x41, 0x8F, 0xC1, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x01,
  0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x04, 0x80, 0x84, 0x08, 0x3B, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x1F, 0x82, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11,
  0x04, 0x43, 0x0F, 0xC1, 0x08, 0x21, 0x04, 0x21, 0x02, 0x20, 0x44, 0x08,
  0x80, 0x80, 0x0F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0xFE, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x00,
  0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10,
  0x7E, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x44, 0x08, 0x82, 0x10, 0x42,
  0x10, 0x42, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x00,
  0x20, 0x00, 0x81, 0x01, 0x81, 0x01, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90,
  0xA0, 0x90, 0xA0, 0xA0, 0xC0, 0xA0, 0xC0, 0xC0, 0x80, 0xC0, 0x80, 0x80,
  0x08, 0x08, 0x40, 0x82, 0x08, 0x08, 0x80, 0x44, 0x02, 0x40, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x80, 0x40, 0x80, 0x60, 0x24, 0x09, 0x04, 0x42, 0x10, 0x82,
  0x40, 0xA0, 0x28, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0xFF, 0x80, 0x0F, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x0F, 0x00, 0x88, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11,
  0x10, 0x07, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0F,
  0x80, 0x02, 0x01, 0x40, 0x90, 0x24, 0x10, 0x88, 0x22, 0x09, 0x01, 0x40,
  0x60, 0x10, 0xFF, 0xA4, 0x0F, 0x44, 0x32, 0x0D, 0x02, 0x40, 0xA0, 0x28,
  0x0A, 0x02, 0x81, 0x20, 0x48, 0x32, 0x14, 0x79, 0x00, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x09, 0xC3, 0x88, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01,
  0x80, 0x60, 0x28, 0x0A, 0x04, 0xC3, 0x2F, 0x00, 0x0F, 0x88, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03, 0xE0, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF4, 0x10, 0xC2, 0x04, 0x40,
  0x44, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08, 0x30, 0x83,
  0x07, 0xD0, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x14, 0x13, 0xF1, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x03, 0xE0, 0x00, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x0C, 0x00, 0x07, 0xA1, 0x0C, 0x40, 0x90, 0x12, 0x02,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x06, 0x20, 0xC3, 0xE8, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x10, 0x41, 0xF0, 0x00, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x38, 0xE2, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0C, 0x06,
  0x05, 0x02, 0x81, 0x40, 0x80, 0x10, 0x00, 0x22, 0x24, 0x44, 0x44, 0x88,
  0x88, 0x80, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20,
  0xC0, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x04, 0x84, 0x44, 0x44, 0x24,
  0x14, 0x0D, 0x0C, 0x84, 0x42, 0x11, 0x08, 0x84, 0x41, 0x00, 0x11, 0x12,
  0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x88, 0x2F, 0x1C, 0x61, 0x44, 0x83,
  0x09, 0x04, 0x14, 0x08, 0x28, 0x10, 0x50, 0x40, 0xA0, 0x81, 0x81, 0x03,
  0x02, 0x0A, 0x04, 0x14, 0x10, 0x28, 0x20, 0x40, 0x27, 0x1C, 0x48, 0x24,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0xA0, 0x50, 0x28, 0x10, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28,
  0x11, 0x08, 0x7C, 0x00, 0x09, 0xC0, 0xE2, 0x08, 0x10, 0x81, 0x10, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x20, 0x22, 0x02, 0x20, 0x43, 0x0C, 0x4F, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x44, 0x32,
  0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x32, 0x0C,
  0x7D, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x2E, 0x60, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1F, 0x90, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x80, 0x4F, 0xC0,
  0x10, 0x82, 0x3F, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x3C,
  0x20, 0x48, 0x14, 0x05, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x81, 0x20,
  0x48, 0x32, 0x14, 0x79, 0x00, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x22, 0x21,
  0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x04, 0x00, 0x81, 0x06, 0x08, 0x28,
  0x30, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x42,
  0x85, 0x06, 0x18, 0x10, 0x20, 0x41, 0x00, 0x10, 0x22, 0x08, 0x22, 0x04,
  0x40, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x12, 0x02, 0x40, 0x84, 0x20, 0x88,
  0x10, 0x08, 0x08, 0x40, 0x41, 0x04, 0x08, 0x20, 0x42, 0x02, 0x10, 0x11,
  0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x38, 0x00, 0x1F, 0xC0, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0xFF,
  0x00, 0x07, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x30, 0xFF, 0xFF,
  0xFF, 0x0C, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x03,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x30, 0x33,
  0x10, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 5, 6, 7, 3, -17 },
  { 14, 12, 17, 13, 1, -17 },
  { 40, 10, 19, 11, 1, -18 },
  { 64, 13, 17, 16, 2, -17 },
  { 92, 11, 17, 13, 1, -17 },
  { 116, 1, 6, 4, 3, -17 },
  { 117, 6, 21, 6, 1, -17 },
  { 133, 7, 21, 6, -2, -17 },
  { 152, 8, 9, 11, 3, -18 },
  { 161, 10, 11, 12, 1, -14 },
  { 175, 3, 6, 4, -1, -3 },
  { 178, 5, 1, 7, 1, -7 },
  { 179, 1, 1, 5, 1, -1 },
  { 180, 10, 17, 7, -1, -17 },
  { 202, 10, 17, 11, 1, -17 },
  { 224, 5, 17, 11, 4, -17 },
  { 235, 11, 17, 11, 0, -17 },
  { 259, 11, 17, 11, 0, -17 },
  { 283, 11, 17, 11, 0, -17 },
  { 307, 11, 17, 11, 0, -17 },
  { 331, 10, 17, 11, 1, -17 },
  { 353, 10, 17, 11, 2, -17 },
  { 375, 10, 17, 11, 1, -17 },
  { 397, 10, 17, 11, 1, -17 },
  { 419, 4, 13, 5, 0, -13 },
  { 426, 5, 16, 5, -1, -13 },
  { 436, 10, 11, 12, 1, -14 },
  { 450, 10, 5, 12, 1, -11 },
  { 457, 10, 11, 12, 1, -14 },
  { 471, 8, 17, 8, 1, -17 },
  { 488, 16, 19, 17, 1, -17 },
  { 526, 11, 17, 11, -1, -17 },
  { 550, 11, 17, 12, 1, -17 },
  { 574, 11, 17, 12, 2, -17 },
  { 598, 12, 17, 14, 1, -17 },
  { 624, 11, 17, 11, 1, -17 },
  { 648, 11, 17, 10, 1, -17 },
  { 672, 12, 17, 14, 2, -17 },
  { 698, 13, 17, 14, 1, -17 },
  { 726, 7, 17, 6, 0, -17 },
  { 741, 9, 21, 5, -4, -17 },
  { 765, 12, 17, 11, 1, -17 },
  { 791, 7, 17, 10, 1, -17 },
  { 806, 16, 17, 17, 1, -17 },
  { 840, 13, 17, 14, 1, -17 },
  { 868, 12, 17, 15, 2, -17 },
  { 894, 11, 17, 12, 1, -17 },
  { 918, 12, 21, 15, 2, -17 },
  { 950, 11, 17, 12, 1, -17 },
  { 974, 11, 17, 11, 0, -17 },
  { 998, 10, 17, 10, 2, -17 },
  { 1020, 12, 17, 14, 2, -17 },
  { 1046, 11, 17, 11, 2, -17 },
  { 1070, 16, 17, 18, 3, -17 },
  { 1104, 13, 17, 10, -1, -17 },
  { 1132, 10, 17, 10, 2, -17 },
  { 1154, 12, 17, 11, 0, -17 },
  { 1180, 9, 21, 7, 0, -17 },
  { 1204, 4, 17, 7, 2, -17 },
  { 1213, 9, 21, 7, -2, -17 },
  { 1237, 10, 10, 12, 1, -17 },
  { 1250, 8, 1, 8, -2, 2 },
  { 1251, 2, 3, 5, 4, -18 },
  { 1252, 10, 13, 12, 1, -13 },
  { 1269, 10, 18, 12, 1, -18 },
  { 1292, 9, 13, 9, 1, -13 },
  { 1307, 12, 18, 12, 1, -18 },
  { 1334, 9, 13, 10, 1, -13 },
  { 1349, 12, 24, 6, -3, -18 },
  { 1385, 11, 19, 12, 0, -13 },
  { 1412, 9, 18, 12, 1, -18 },
  { 1433, 4, 17, 5, 1, -17 },
  { 1442, 8, 23, 5, -3, -17 },
  { 1465, 9, 18, 9, 1, -18 },
  { 1486, 4, 18, 4, 1, -18 },
  { 1495, 15, 13, 18, 1, -13 },
  { 1520, 9, 13, 12, 1, -13 },
  { 1535, 10, 13, 12, 1, -13 },
  { 1552, 12, 19, 12, -1, -13 },
  { 1581, 10, 19, 12, 1, -13 },
  { 1605, 7, 13, 8, 1, -13 },
  { 1617, 9, 13, 9, 0, -13 },
  { 1632, 6, 16, 6, 1, -16 },
  { 1644, 10, 13, 12, 1, -13 },
  { 1661, 9, 13, 9, 1, -13 },
  { 1676, 14, 13, 14, 1, -13 },
  { 1699, 11, 13, 9, -1, -13 },
  { 1717, 13, 19, 9, -3, -13 },
  { 1748, 10, 13, 9, -1, -13 },
  { 1765, 8, 21, 8, 1, -17 },
  { 1786, 1, 24, 11, 5, -18 },
  { 1789, 8, 21, 8, -1, -17 },
  { 1810, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC24PT7B_H_
