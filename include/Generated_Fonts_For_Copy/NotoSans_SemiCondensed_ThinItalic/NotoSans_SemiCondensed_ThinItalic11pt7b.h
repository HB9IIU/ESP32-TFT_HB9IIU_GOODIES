#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x52, 0xFC, 0x14, 0xA7, 0xCA, 0x53, 0xE5, 0x14, 0x3A, 0x94,
  0xC1, 0x14, 0xDC, 0x40, 0xE6, 0xAB, 0x2B, 0xF5, 0x55, 0x66, 0x38, 0xA2,
  0x8C, 0x52, 0x58, 0xBE, 0xE0, 0x25, 0x29, 0x24, 0x88, 0x24, 0x92, 0x49,
  0x50, 0xA5, 0x61, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x11, 0x22, 0x44,
  0x88, 0x79, 0x99, 0x99, 0xAE, 0x75, 0xAA, 0x38, 0x42, 0x11, 0x11, 0x1E,
  0x78, 0x42, 0x61, 0x04, 0x3E, 0x08, 0xCA, 0x55, 0x7C, 0x42, 0x3A, 0x10,
  0xE0, 0x84, 0x3E, 0x34, 0x8E, 0x99, 0x9E, 0xF1, 0x12, 0x24, 0x88, 0x3A,
  0x52, 0x65, 0x46, 0x3E, 0x3A, 0x52, 0x97, 0x84, 0x5C, 0x40, 0x20, 0x20,
  0x00, 0xB0, 0x3C, 0xC3, 0xFF, 0xC3, 0x3C, 0xE4, 0xA9, 0x04, 0x1E, 0x21,
  0x49, 0x55, 0xA5, 0xAA, 0xB4, 0x80, 0x78, 0x08, 0x61, 0x8A, 0x3D, 0x14,
  0x61, 0x39, 0x14, 0x5E, 0x49, 0x28, 0xBC, 0x3A, 0x21, 0x08, 0x42, 0x1E,
  0x39, 0x14, 0x51, 0x45, 0x18, 0xBC, 0x3A, 0x10, 0xE4, 0x22, 0x1E, 0x3A,
  0x10, 0x87, 0x22, 0x10, 0x3D, 0x08, 0x20, 0x9A, 0x28, 0xBE, 0x22, 0x85,
  0x13, 0xE4, 0x48, 0xA1, 0x44, 0x65, 0x24, 0xA6, 0x11, 0x11, 0x11, 0x22,
  0x2C, 0x25, 0x25, 0x18, 0x61, 0x49, 0x22, 0x24, 0x44, 0x44, 0x8F, 0x21,
  0x21, 0x23, 0x65, 0x66, 0x6A, 0x92, 0x92, 0x22, 0x45, 0x92, 0xA5, 0x4A,
  0xA2, 0x44, 0x7C, 0x63, 0x18, 0xC6, 0x3E, 0x3A, 0x52, 0x97, 0x22, 0x10,
  0x7C, 0x63, 0x18, 0xC6, 0x3A, 0x21, 0x00, 0x3A, 0x52, 0x97, 0x2A, 0x51,
  0x3A, 0x10, 0xC1, 0x08, 0x5E, 0xFA, 0x10, 0x84, 0x22, 0x10, 0x46, 0x18,
  0xA2, 0x8A, 0x29, 0x3C, 0x8C, 0x65, 0x2A, 0x51, 0x10, 0x91, 0x91, 0x92,
  0xAA, 0xAC, 0xCC, 0x88, 0x88, 0x24, 0x91, 0x84, 0x10, 0xA4, 0xA2, 0x8C,
  0xA9, 0x44, 0x22, 0x10, 0x38, 0x44, 0x22, 0x22, 0x1E, 0x74, 0x44, 0x48,
  0x88, 0x8C, 0xAA, 0x95, 0x31, 0x11, 0x11, 0x22, 0x2C, 0x11, 0x92, 0x98,
  0x80, 0xF0, 0x80, 0x3A, 0x63, 0x19, 0x78, 0x42, 0x1E, 0x94, 0xC6, 0x3E,
  0x34, 0x88, 0x86, 0x04, 0x13, 0x92, 0x8A, 0x29, 0x3C, 0x77, 0xC9, 0xC0,
  0x19, 0x0C, 0x42, 0x11, 0x08, 0x42, 0x20, 0x3A, 0x63, 0x19, 0x78, 0x42,
  0xE0, 0x42, 0x1E, 0x94, 0xC6, 0x32, 0x45, 0x6A, 0x10, 0x11, 0x12, 0x22,
  0x22, 0xC0, 0x42, 0x12, 0xA6, 0x52, 0x92, 0x55, 0x6A, 0x7F, 0x49, 0x49,
  0x92, 0x92, 0x92, 0x7A, 0x53, 0x19, 0x48, 0x3A, 0x63, 0x18, 0xB8, 0x7A,
  0x53, 0x18, 0xFA, 0x10, 0x80, 0x3A, 0x63, 0x19, 0x78, 0x42, 0x10, 0x74,
  0x48, 0x88, 0x78, 0x42, 0x1E, 0x4D, 0x29, 0x30, 0x4A, 0x53, 0x19, 0x78,
  0xB6, 0xE9, 0x00, 0xA6, 0x9E, 0xAA, 0xB2, 0x40, 0x4A, 0x88, 0x8A, 0x48,
  0x45, 0x22, 0x8C, 0x20, 0x82, 0x10, 0x80, 0x71, 0x24, 0x8E, 0x12, 0x24,
  0xC4, 0x44, 0x84, 0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22, 0x2C, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 3, 3, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 8, 7, 1, -8 },
  { 22, 6, 8, 6, 0, -8 },
  { 28, 1, 3, 2, 1, -8 },
  { 29, 3, 10, 3, 0, -8 },
  { 33, 3, 10, 3, -1, -8 },
  { 37, 4, 4, 5, 1, -8 },
  { 39, 4, 5, 6, 1, -6 },
  { 42, 1, 2, 2, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 1, 1, 2, 0, -1 },
  { 45, 4, 8, 3, 0, -8 },
  { 49, 4, 8, 5, 1, -8 },
  { 53, 2, 8, 5, 2, -8 },
  { 55, 5, 8, 5, 0, -8 },
  { 60, 5, 8, 5, 0, -8 },
  { 65, 5, 8, 5, 0, -8 },
  { 70, 5, 8, 5, 0, -8 },
  { 75, 4, 8, 5, 1, -8 },
  { 79, 4, 8, 5, 1, -8 },
  { 83, 5, 8, 5, 0, -8 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 2, 6, 2, 0, -6 },
  { 95, 3, 7, 2, -1, -6 },
  { 98, 4, 4, 6, 1, -6 },
  { 100, 4, 2, 6, 1, -5 },
  { 101, 4, 4, 6, 1, -6 },
  { 103, 3, 8, 4, 1, -8 },
  { 106, 8, 9, 8, 0, -8 },
  { 115, 6, 8, 5, -1, -8 },
  { 121, 6, 8, 6, 0, -8 },
  { 127, 5, 8, 6, 1, -8 },
  { 132, 6, 8, 6, 0, -8 },
  { 138, 5, 8, 5, 0, -8 },
  { 143, 5, 8, 5, 0, -8 },
  { 148, 6, 8, 7, 1, -8 },
  { 154, 7, 8, 7, 0, -8 },
  { 161, 3, 8, 3, 0, -8 },
  { 164, 4, 10, 2, -2, -8 },
  { 169, 6, 8, 5, 0, -8 },
  { 175, 4, 8, 5, 0, -8 },
  { 179, 8, 8, 8, 0, -8 },
  { 187, 7, 8, 7, 0, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 5, 0, -8 },
  { 204, 5, 10, 7, 1, -8 },
  { 211, 5, 8, 5, 0, -8 },
  { 216, 5, 8, 5, 0, -8 },
  { 221, 5, 8, 5, 1, -8 },
  { 226, 6, 8, 7, 1, -8 },
  { 232, 5, 8, 5, 1, -8 },
  { 237, 8, 8, 8, 1, -8 },
  { 245, 6, 8, 5, -1, -8 },
  { 251, 5, 8, 5, 1, -8 },
  { 256, 5, 8, 5, 0, -8 },
  { 261, 4, 10, 3, 0, -8 },
  { 266, 2, 8, 3, 1, -8 },
  { 268, 4, 10, 3, -1, -8 },
  { 273, 5, 5, 5, 0, -8 },
  { 277, 4, 1, 4, -1, 1 },
  { 278, 1, 1, 2, 2, -8 },
  { 279, 5, 6, 5, 0, -6 },
  { 283, 5, 8, 5, 0, -8 },
  { 288, 4, 6, 4, 0, -6 },
  { 291, 6, 8, 5, 0, -8 },
  { 297, 3, 6, 5, 1, -6 },
  { 300, 5, 11, 3, -1, -8 },
  { 307, 5, 9, 5, 0, -6 },
  { 313, 5, 8, 5, 0, -8 },
  { 318, 2, 8, 2, 0, -8 },
  { 320, 4, 11, 2, -2, -8 },
  { 326, 5, 8, 4, 0, -8 },
  { 331, 2, 8, 2, 0, -8 },
  { 333, 8, 6, 8, 0, -6 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 5, 6, 5, 0, -6 },
  { 347, 5, 9, 5, 0, -6 },
  { 353, 5, 9, 5, 0, -6 },
  { 359, 4, 6, 4, 0, -6 },
  { 362, 4, 6, 4, 0, -6 },
  { 365, 3, 7, 3, 0, -7 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 3, 6, 4, 1, -6 },
  { 375, 6, 6, 6, 1, -6 },
  { 380, 5, 6, 4, 0, -6 },
  { 384, 6, 9, 4, -1, -6 },
  { 391, 4, 6, 4, 0, -6 },
  { 394, 4, 10, 4, 0, -8 },
  { 399, 1, 11, 5, 2, -8 },
  { 401, 4, 10, 4, -1, -8 },
  { 406, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC11PT7B_H_
