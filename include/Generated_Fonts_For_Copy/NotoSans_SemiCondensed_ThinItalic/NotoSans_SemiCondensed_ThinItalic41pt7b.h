#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x30, 0x90, 0x88, 0x44, 0x24, 0x12,
  0x09, 0x08, 0x84, 0x42, 0x41, 0x00, 0x00, 0x30, 0x20, 0x01, 0x02, 0x00,
  0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x40, 0x03, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x02,
  0x06, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x80,
  0x06, 0x04, 0x00, 0x20, 0x20, 0x01, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x04, 0x04, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x01, 0xD3, 0x80, 0x84,
  0x10, 0x41, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x01, 0x10, 0x00, 0x34, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x08, 0xC0, 0x02, 0x10, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x83,
  0x08, 0xC0, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x19, 0x80, 0x10, 0x41, 0x00, 0x41, 0x82,
  0x01, 0x82, 0x04, 0x02, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x40, 0x40, 0x41, 0x01, 0x00, 0x86, 0x02, 0x01, 0x08, 0x04, 0x06, 0x20,
  0x08, 0x08, 0x47, 0x90, 0x11, 0x19, 0xA0, 0x64, 0x41, 0x40, 0x89, 0x82,
  0xC2, 0x22, 0x06, 0xD8, 0xCC, 0x0C, 0x61, 0x10, 0x18, 0x04, 0x20, 0x20,
  0x18, 0x40, 0x40, 0x21, 0x80, 0x80, 0x82, 0x01, 0x03, 0x04, 0x06, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x60, 0x20, 0x60, 0x80, 0x40, 0x82, 0x00,
  0x42, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x60, 0x00, 0x81,
  0x00, 0x10, 0x18, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x20,
  0x10, 0x02, 0x01, 0x00, 0x20, 0x20, 0x03, 0x06, 0x00, 0x10, 0xC0, 0x01,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x24, 0x00, 0x0C, 0x20, 0x01,
  0x82, 0x01, 0x20, 0x10, 0x36, 0x01, 0x02, 0x40, 0x08, 0x6C, 0x00, 0x84,
  0x80, 0x04, 0x88, 0x00, 0x68, 0x80, 0x03, 0x08, 0x00, 0x30, 0xC0, 0x05,
  0x04, 0x00, 0x88, 0x60, 0x30, 0x81, 0xFC, 0x04, 0x32, 0x22, 0x44, 0x44,
  0x48, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x20, 0x40, 0x41, 0x00, 0xC4, 0x00, 0xD0, 0xC0,
  0xFC, 0x05, 0x00, 0x24, 0x01, 0x08, 0x08, 0x20, 0x40, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xC0,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x46, 0x23, 0x10, 0x88,
  0xC0, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xE7, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x04, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x34,
  0x00, 0x1A, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x01,
  0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x18, 0x80, 0x08, 0x40, 0x0C, 0x10, 0x04, 0x08, 0x04, 0x02, 0x04, 0x00,
  0xFC, 0x00, 0x01, 0x83, 0x83, 0x46, 0x26, 0x14, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x39, 0xC0, 0x30, 0x08, 0x08, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x1C, 0x70,
  0x0C, 0x03, 0x02, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x0C, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x62, 0x00, 0x10, 0x80, 0x08, 0x60, 0x04, 0x10, 0x03, 0x04, 0x01, 0x81,
  0x00, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x02, 0x00, 0x81,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x04, 0x3F, 0xFF, 0xF0, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x82, 0x00, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x40,
  0x0E, 0x20, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x21, 0xF0, 0x19, 0x86, 0x05, 0x80, 0x41, 0xC0, 0x08, 0x60, 0x02, 0x10,
  0x00, 0x8C, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x30, 0x03, 0x04, 0x00, 0x81, 0x00, 0x40,
  0x20, 0x20, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x31, 0xC0, 0x30, 0x18, 0x08, 0x02,
  0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x30, 0x01, 0x04, 0x00, 0xC1,
  0x00, 0x20, 0x40, 0x18, 0x08, 0x0C, 0x03, 0x06, 0x00, 0x66, 0x00, 0x0E,
  0x00, 0x0E, 0xC0, 0x0E, 0x18, 0x06, 0x03, 0x02, 0x00, 0x61, 0x00, 0x08,
  0x40, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x02, 0x20,
  0x00, 0x84, 0x00, 0x61, 0x00, 0x30, 0x30, 0x18, 0x07, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x73, 0x80, 0x30, 0x10, 0x18, 0x06, 0x04, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x61, 0x00, 0x18, 0x40, 0x0A, 0x08,
  0x05, 0x01, 0xCE, 0x40, 0x1C, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x04, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x20, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0xE7,
  0x08, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01,
  0x10, 0x07, 0xC0, 0x4C, 0x07, 0x0C, 0x12, 0x03, 0x02, 0x05, 0x81, 0x80,
  0x81, 0x40, 0x40, 0x20, 0x50, 0x20, 0x10, 0x14, 0x08, 0x04, 0x06, 0x04,
  0x01, 0x01, 0x81, 0x00, 0xC0, 0xE0, 0x40, 0x20, 0x28, 0x10, 0x08, 0x0A,
  0x04, 0x06, 0x04, 0x81, 0x01, 0x81, 0x20, 0x40, 0xA0, 0x88, 0x10, 0x68,
  0x62, 0x03, 0xE3, 0xF0, 0x80, 0x20, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x08, 0x08, 0x01, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06,
  0x02, 0x00, 0x40, 0x7F, 0xF8, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x09,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x02, 0x03, 0xFF, 0x80, 0x20, 0x0C,
  0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00, 0x40, 0x80,
  0x08, 0x08, 0x03, 0x00, 0xFF, 0xC0, 0x18, 0x06, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x82, 0x00, 0x0C, 0x20, 0x00, 0x82,
  0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x30,
  0x40, 0x06, 0x04, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x07,
  0x8E, 0x01, 0x80, 0x10, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x10, 0x0E, 0x00, 0x80, 0x18, 0x04, 0x00, 0x60, 0x20, 0x01,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04,
  0x60, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80, 0x03, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xFE, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xC7, 0x80, 0x60, 0x02, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x1F, 0xE4, 0x00, 0x01, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00,
  0x18, 0xC0, 0x00, 0x82, 0x00, 0x04, 0x18, 0x00, 0x20, 0x40, 0x01, 0x01,
  0x80, 0x18, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x30, 0x20, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00,
  0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x20, 0x00,
  0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0xFF, 0xFE, 0x06, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x81,
  0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x30,
  0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x1C, 0x08, 0x00, 0xC0, 0x20,
  0x06, 0x00, 0x80, 0x30, 0x02, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x60,
  0x01, 0x03, 0x00, 0x04, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x86, 0x00, 0x02,
  0x30, 0x00, 0x09, 0x80, 0x00, 0x2F, 0x00, 0x01, 0x64, 0x00, 0x07, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x01, 0x03, 0x00, 0x08, 0x04, 0x00,
  0x20, 0x10, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x18, 0x03, 0x00, 0x40,
  0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x05, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x0D, 0x02, 0x40, 0x00, 0x58, 0x12,
  0x00, 0x06, 0x80, 0x90, 0x00, 0x24, 0x04, 0x80, 0x02, 0x20, 0x64, 0x00,
  0x11, 0x02, 0x20, 0x01, 0x18, 0x10, 0x80, 0x08, 0x80, 0x84, 0x00, 0x84,
  0x04, 0x20, 0x0C, 0x20, 0x61, 0x00, 0x41, 0x02, 0x08, 0x06, 0x10, 0x10,
  0x40, 0x20, 0x80, 0x82, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x41,
  0x01, 0x02, 0x02, 0x08, 0x10, 0x10, 0x10, 0x80, 0x80, 0x80, 0x8C, 0x04,
  0x0C, 0x04, 0x40, 0x20, 0x40, 0x26, 0x03, 0x02, 0x01, 0x20, 0x10, 0x10,
  0x06, 0x00, 0x80, 0x80, 0x30, 0x04, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x80, 0x02, 0x02,
  0x80, 0x06, 0x04, 0x80, 0x04, 0x04, 0x40, 0x04, 0x04, 0x40, 0x04, 0x04,
  0x60, 0x04, 0x0C, 0x20, 0x08, 0x08, 0x20, 0x08, 0x08, 0x30, 0x08, 0x08,
  0x10, 0x08, 0x08, 0x10, 0x18, 0x18, 0x18, 0x10, 0x10, 0x08, 0x10, 0x10,
  0x08, 0x10, 0x10, 0x0C, 0x10, 0x10, 0x04, 0x30, 0x20, 0x04, 0x20, 0x20,
  0x06, 0x20, 0x20, 0x02, 0x20, 0x20, 0x02, 0x20, 0x60, 0x03, 0x40, 0x40,
  0x01, 0x40, 0x40, 0x01, 0x40, 0x40, 0x01, 0xC0, 0x40, 0x00, 0xC0, 0xC0,
  0x00, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0x40, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00, 0x01, 0x20,
  0x00, 0x09, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00,
  0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x82, 0x00, 0x0C, 0x10, 0x00,
  0xC0, 0x40, 0x0C, 0x01, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x40, 0x30, 0x08, 0x01, 0x01, 0x00, 0x30, 0x20, 0x02, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x20, 0x01, 0x04,
  0x00, 0x20, 0x80, 0x08, 0x10, 0x03, 0x06, 0x00, 0x80, 0xFF, 0xE0, 0x1F,
  0x80, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x1C, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x40, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00,
  0x62, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x02,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x82,
  0x00, 0x0C, 0x10, 0x00, 0xC0, 0x40, 0x0C, 0x03, 0x00, 0xC0, 0x07, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x40,
  0x30, 0x08, 0x01, 0x01, 0x00, 0x30, 0x20, 0x02, 0x08, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x20, 0x01, 0x04, 0x00,
  0x60, 0x80, 0x08, 0x10, 0x06, 0x06, 0x03, 0x80, 0xFF, 0x80, 0x10, 0x10,
  0x02, 0x02, 0x00, 0x40, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x18,
  0x20, 0x01, 0x0C, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1E, 0x78, 0x0C, 0x00,
  0x81, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x08,
  0x01, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00,
  0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x18, 0x20, 0x00,
  0x40, 0x80, 0x03, 0x03, 0x00, 0x08, 0x04, 0x00, 0x40, 0x08, 0x06, 0x00,
  0x1F, 0xF0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x02, 0x08, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x08, 0x20, 0x20, 0x80, 0x82, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x60, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x08, 0x40, 0x23, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80,
  0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x00, 0x80, 0x20, 0x03, 0x01, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x60, 0x00, 0x41, 0x00, 0x00, 0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0x41, 0x00, 0x02, 0x04,
  0x00, 0x10, 0x10, 0x00, 0xC0, 0x20, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x08, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0x80, 0x01, 0x80, 0x80,
  0x01, 0xC0, 0x01, 0x20, 0x00, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41,
  0x00, 0x40, 0xC0, 0x60, 0x20, 0x20, 0x10, 0x20, 0x08, 0x30, 0x06, 0x10,
  0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xF8, 0x00,
  0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x04, 0x00, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x03, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x28, 0x00, 0x14, 0x00, 0x11,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x10, 0x0C, 0x08, 0x04, 0x04, 0x04,
  0x01, 0x06, 0x00, 0x82, 0x00, 0x42, 0x00, 0x13, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x01, 0xFF, 0xF8, 0x84, 0x42, 0x11, 0x01, 0xF0, 0x83, 0x04, 0x43,
  0x01, 0x43, 0x00, 0x61, 0x00, 0x31, 0x00, 0x18, 0x80, 0x0C, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x0A, 0x18,
  0x0D, 0x06, 0x0C, 0x81, 0xF8, 0x80, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x1F, 0x00, 0x8C, 0x30, 0x24, 0x04, 0x0A, 0x00, 0x83,
  0x00, 0x21, 0xC0, 0x08, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x19, 0x80, 0x04,
  0x60, 0x01, 0x18, 0x00, 0x86, 0x00, 0x21, 0x80, 0x10, 0xB0, 0x08, 0x26,
  0x04, 0x08, 0xFE, 0x00, 0x01, 0xFC, 0x1C, 0x10, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x20, 0x7F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x3F, 0x10, 0x1C, 0x32, 0x06, 0x03, 0x41,
  0x80, 0x28, 0x20, 0x06, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x61, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20,
  0x01, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x50, 0x40,
  0x1A, 0x0C, 0x06, 0x80, 0xC1, 0x90, 0x0F, 0xC2, 0x00, 0x01, 0xF0, 0x06,
  0x18, 0x30, 0x10, 0x40, 0x21, 0x00, 0x64, 0x00, 0x88, 0x01, 0x20, 0x06,
  0x40, 0x18, 0x80, 0xE3, 0x3E, 0x07, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x01,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x09, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x20, 0x38, 0x64, 0x0C, 0x06, 0x83, 0x00, 0x50, 0x40, 0x0A, 0x10, 0x00,
  0x82, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x18,
  0x20, 0x03, 0x04, 0x00, 0xA0, 0x80, 0x38, 0x18, 0x0D, 0x01, 0x83, 0x20,
  0x1F, 0x84, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x01, 0x00, 0x60, 0x38, 0x38, 0x00,
  0xF8, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x3F, 0x02,
  0x30, 0xC1, 0x60, 0x20, 0xA0, 0x08, 0x60, 0x04, 0x60, 0x02, 0x30, 0x03,
  0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x00,
  0x10, 0x80, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x8C, 0x00, 0x44, 0x00, 0x22, 0x00, 0x20, 0x02, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x11, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x01, 0x08, 0x02, 0x08, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80,
  0x13, 0x00, 0x27, 0x00, 0x2D, 0x80, 0x38, 0x80, 0x30, 0x80, 0x60, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x30, 0x80, 0x10,
  0x80, 0x10, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x08, 0x7C, 0x0F,
  0x81, 0x30, 0xC6, 0x18, 0x28, 0x09, 0x81, 0x87, 0x00, 0xE0, 0x10, 0xC0,
  0x18, 0x02, 0x30, 0x02, 0x00, 0x46, 0x00, 0xC0, 0x08, 0x80, 0x10, 0x01,
  0x10, 0x02, 0x00, 0x42, 0x00, 0x40, 0x08, 0x80, 0x08, 0x01, 0x10, 0x03,
  0x00, 0x22, 0x00, 0x40, 0x04, 0x40, 0x08, 0x01, 0x18, 0x01, 0x00, 0x22,
  0x00, 0x20, 0x04, 0x40, 0x08, 0x00, 0x88, 0x01, 0x00, 0x31, 0x00, 0x20,
  0x04, 0x60, 0x04, 0x00, 0x88, 0x00, 0x80, 0x11, 0x00, 0x20, 0x02, 0x00,
  0x08, 0x7E, 0x04, 0x61, 0x82, 0xC0, 0x41, 0x40, 0x30, 0xC0, 0x08, 0xC0,
  0x04, 0x60, 0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x62, 0x00, 0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x40, 0x01,
  0xF8, 0x03, 0x0C, 0x0C, 0x02, 0x18, 0x03, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0xC0,
  0x08, 0x40, 0x10, 0x60, 0x60, 0x1F, 0xC0, 0x02, 0x1F, 0x00, 0x23, 0x0C,
  0x02, 0x40, 0x40, 0x28, 0x02, 0x03, 0x00, 0x20, 0x70, 0x02, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x41, 0x80, 0x04, 0x18,
  0x00, 0x81, 0x80, 0x08, 0x18, 0x01, 0x03, 0xC0, 0x20, 0x26, 0x04, 0x02,
  0x3F, 0x80, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x83, 0x06, 0x43, 0x01, 0xA3, 0x00, 0x51, 0x00, 0x29,
  0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32, 0x00, 0x11, 0x00, 0x18, 0x80,
  0x0C, 0x40, 0x0A, 0x20, 0x0F, 0x18, 0x0D, 0x06, 0x0C, 0x81, 0xF8, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x08, 0x78, 0x4C,
  0x02, 0xC0, 0x14, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x0C,
  0x1C, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x08, 0x06,
  0x0F, 0xF0, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x1F, 0xF9, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F,
  0xC0, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0x46, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0x80,
  0x18, 0x40, 0x0C, 0x20, 0x0A, 0x10, 0x09, 0x0C, 0x09, 0x03, 0xF8, 0x80,
  0x80, 0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10,
  0x0C, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x10,
  0x0C, 0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x40, 0x03, 0x00, 0x06, 0x00, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xA0, 0x16, 0x01, 0x40, 0x24, 0x06, 0x80, 0x88, 0x09, 0x01, 0x10,
  0x32, 0x06, 0x20, 0x44, 0x08, 0x40, 0x88, 0x10, 0x82, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x10, 0x42, 0x04, 0x20, 0x84, 0x08, 0x81, 0x10, 0x11, 0x02,
  0x20, 0x24, 0x04, 0xC0, 0x48, 0x09, 0x00, 0xA0, 0x12, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x50, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x20, 0x40, 0x08, 0x08, 0x02, 0x00, 0x80, 0x80, 0x10, 0x30, 0x02, 0x04,
  0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0xD8, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x10, 0x80,
  0x04, 0x08, 0x01, 0x01, 0x00, 0x40, 0x20, 0x18, 0x02, 0x02, 0x00, 0x41,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x02, 0x00, 0x30, 0x08, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x08, 0x02, 0x00, 0x20,
  0x10, 0x00, 0x80, 0x40, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x40,
  0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x44, 0x00, 0x01, 0x20, 0x00, 0x02, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x08, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x70, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x0F, 0x00, 0x20, 0x00, 0x3F, 0x00, 0xA0, 0x60, 0x60, 0x0F,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 29, 8, 1, -29 },
  { 30, 9, 10, 12, 4, -29 },
  { 42, 21, 29, 21, 1, -29 },
  { 119, 18, 33, 19, 1, -31 },
  { 194, 23, 30, 28, 3, -30 },
  { 281, 20, 30, 23, 1, -30 },
  { 356, 4, 10, 7, 4, -29 },
  { 361, 12, 35, 10, 1, -29 },
  { 414, 12, 35, 10, -3, -29 },
  { 467, 14, 15, 19, 5, -31 },
  { 494, 17, 19, 21, 2, -24 },
  { 535, 5, 9, 7, -2, -4 },
  { 541, 10, 1, 12, 1, -12 },
  { 543, 2, 2, 8, 1, -2 },
  { 544, 18, 29, 12, -2, -29 },
  { 610, 17, 30, 19, 2, -30 },
  { 674, 9, 29, 19, 6, -29 },
  { 707, 18, 30, 19, 0, -30 },
  { 775, 19, 30, 19, 0, -30 },
  { 847, 18, 30, 19, 0, -30 },
  { 915, 18, 29, 19, 1, -29 },
  { 981, 18, 30, 19, 2, -30 },
  { 1049, 16, 29, 19, 4, -29 },
  { 1107, 18, 30, 19, 1, -30 },
  { 1175, 18, 30, 19, 1, -30 },
  { 1243, 6, 22, 8, 1, -22 },
  { 1260, 9, 27, 8, -2, -22 },
  { 1291, 17, 18, 21, 2, -24 },
  { 1330, 17, 9, 21, 2, -19 },
  { 1350, 17, 18, 21, 2, -24 },
  { 1389, 13, 30, 14, 2, -30 },
  { 1438, 26, 33, 29, 2, -29 },
  { 1546, 19, 29, 19, -2, -29 },
  { 1615, 20, 29, 21, 1, -29 },
  { 1688, 20, 30, 21, 3, -30 },
  { 1763, 21, 29, 24, 1, -29 },
  { 1840, 19, 29, 19, 1, -29 },
  { 1909, 19, 29, 17, 1, -29 },
  { 1978, 21, 30, 25, 3, -30 },
  { 2057, 23, 29, 24, 1, -29 },
  { 2141, 13, 29, 10, -1, -29 },
  { 2189, 16, 36, 8, -7, -29 },
  { 2261, 22, 29, 19, 1, -29 },
  { 2341, 13, 29, 17, 1, -29 },
  { 2389, 29, 29, 30, 1, -29 },
  { 2495, 24, 29, 24, 1, -29 },
  { 2582, 21, 30, 25, 3, -30 },
  { 2661, 19, 29, 20, 1, -29 },
  { 2730, 21, 37, 25, 3, -30 },
  { 2828, 19, 29, 20, 1, -29 },
  { 2897, 19, 30, 18, 0, -30 },
  { 2969, 17, 29, 17, 4, -29 },
  { 3031, 22, 29, 24, 3, -29 },
  { 3111, 18, 29, 19, 4, -29 },
  { 3177, 28, 29, 30, 5, -29 },
  { 3279, 22, 29, 17, -2, -29 },
  { 3359, 17, 29, 17, 4, -29 },
  { 3421, 21, 29, 19, -1, -29 },
  { 3498, 15, 35, 12, 0, -29 },
  { 3564, 6, 29, 13, 4, -29 },
  { 3586, 15, 35, 12, -3, -29 },
  { 3652, 17, 16, 20, 2, -29 },
  { 3686, 13, 1, 14, -3, 4 },
  { 3688, 4, 6, 9, 6, -31 },
  { 3691, 17, 22, 20, 2, -22 },
  { 3738, 18, 31, 20, 1, -31 },
  { 3808, 14, 22, 16, 2, -22 },
  { 3847, 19, 31, 20, 2, -31 },
  { 3921, 15, 22, 18, 2, -22 },
  { 3963, 20, 41, 10, -5, -31 },
  { 4066, 19, 32, 20, 0, -22 },
  { 4142, 17, 31, 20, 1, -31 },
  { 4208, 7, 29, 8, 1, -29 },
  { 4234, 15, 39, 8, -6, -29 },
  { 4308, 16, 31, 16, 1, -31 },
  { 4370, 8, 31, 8, 1, -31 },
  { 4401, 27, 22, 30, 1, -22 },
  { 4476, 17, 22, 20, 1, -22 },
  { 4523, 16, 22, 20, 2, -22 },
  { 4567, 20, 31, 20, -1, -22 },
  { 4645, 17, 32, 20, 2, -22 },
  { 4713, 13, 22, 13, 1, -22 },
  { 4749, 15, 22, 15, 0, -22 },
  { 4791, 10, 27, 11, 2, -27 },
  { 4825, 17, 22, 20, 2, -22 },
  { 4872, 15, 22, 15, 2, -22 },
  { 4914, 23, 22, 24, 2, -22 },
  { 4978, 19, 22, 16, -2, -22 },
  { 5031, 22, 32, 15, -5, -22 },
  { 5119, 16, 22, 15, -1, -22 },
  { 5163, 15, 35, 13, 1, -29 },
  { 5229, 1, 41, 19, 10, -31 },
  { 5235, 14, 36, 13, -2, -29 },
  { 5298, 17, 3, 21, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC41PT7B_H_
