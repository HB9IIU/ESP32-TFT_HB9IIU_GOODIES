#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C,
  0x06, 0x18, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x84, 0x02,
  0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x80, 0x41, 0x00, 0x86, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x20, 0x10, 0x40, 0x21, 0x80, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3C, 0x18, 0x1C, 0x01, 0xC0,
  0x40, 0x10, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x38, 0x20, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xF6,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x02, 0x07, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x08, 0x01, 0x83, 0x80, 0x3E, 0x04, 0x3C, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x07, 0x0E, 0x00, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x30, 0x08, 0x18, 0x00, 0x60, 0xC0, 0xFE, 0x30, 0x00, 0xC1,
  0x83, 0x8E, 0x60, 0x03, 0x06, 0x0C, 0x06, 0xC0, 0x06, 0x18, 0x30, 0x0D,
  0x80, 0x18, 0x30, 0xC0, 0x1B, 0x00, 0x30, 0xC1, 0x80, 0x1B, 0x00, 0xC3,
  0x06, 0x00, 0x36, 0x03, 0x06, 0x0C, 0x00, 0x66, 0x1C, 0x18, 0x30, 0x00,
  0xCF, 0xF0, 0x70, 0x60, 0x01, 0x83, 0x00, 0xC0, 0x80, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x04, 0x00, 0x06, 0x06, 0x00, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x30, 0x00, 0x07,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x0C,
  0x70, 0x00, 0xC0, 0x06, 0x38, 0x00, 0x38, 0x01, 0x8C, 0x00, 0x06, 0x00,
  0xC6, 0x00, 0x00, 0xC0, 0x31, 0x80, 0x00, 0x30, 0x18, 0xC0, 0x00, 0x06,
  0x04, 0x30, 0x00, 0x01, 0x83, 0x0C, 0x00, 0x00, 0x31, 0x83, 0x00, 0x00,
  0x0C, 0xE0, 0xC0, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x00, 0x78, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x03, 0xE0, 0x30,
  0x00, 0x01, 0xCC, 0x06, 0x00, 0x00, 0xE3, 0x01, 0xC0, 0x00, 0x60, 0x60,
  0x38, 0x00, 0x70, 0x18, 0x07, 0x80, 0xF8, 0x03, 0x00, 0x7F, 0xF8, 0x00,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0xE0, 0x08, 0x00, 0x38, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x01, 0xD0, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x04, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x02, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x18, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xF8, 0x07, 0x30, 0x1C, 0x40, 0x71, 0x83, 0x83, 0x0E, 0x06,
  0x70, 0x09, 0xC0, 0x31, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x02, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x38, 0x00, 0x18,
  0x1F, 0xFC, 0x00, 0xC3, 0xC0, 0xF0, 0x04, 0x70, 0x01, 0xC0, 0x67, 0x00,
  0x07, 0x03, 0x60, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x60, 0xB0, 0x00, 0x03,
  0x0F, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x43, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x04, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x78, 0x18, 0x00, 0x03, 0x40, 0x60, 0x00, 0x1B, 0x00, 0xC0, 0x00,
  0xCC, 0x03, 0x80, 0x0E, 0x30, 0x07, 0x80, 0xF0, 0x80, 0x07, 0xFF, 0x06,
  0x00, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x78, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x1E, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x7F, 0xF0, 0x03, 0x06, 0x00, 0x0F, 0x03, 0xC0, 0x18, 0x60, 0x00,
  0xE0, 0x0C, 0x00, 0x43, 0x00, 0x0E, 0x00, 0x60, 0x02, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x11, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x98, 0x00, 0xE0, 0x01,
  0x80, 0x0C, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x60, 0x00, 0x60,
  0x03, 0x30, 0x03, 0x00, 0x03, 0x00, 0x1B, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xD8, 0x01, 0x80, 0x01, 0x80, 0x06, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x66,
  0x00, 0xC0, 0x00, 0x40, 0x03, 0x20, 0x06, 0x00, 0x06, 0x00, 0x1B, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x98, 0x01, 0x80, 0x01, 0x80, 0x0C, 0xC0, 0x0C,
  0x00, 0x1C, 0x00, 0x66, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x30, 0x03, 0x00,
  0x0E, 0x00, 0x31, 0x80, 0x18, 0x00, 0x70, 0x03, 0x0C, 0x00, 0xC0, 0x07,
  0x80, 0x38, 0x60, 0x06, 0x00, 0x64, 0x01, 0x83, 0x00, 0x30, 0x07, 0x20,
  0x18, 0x18, 0x00, 0xC0, 0x71, 0x81, 0x80, 0xC0, 0x03, 0xDF, 0x0F, 0x78,
  0x03, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x04, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x03, 0x80, 0x10, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x01, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xE1, 0x80, 0x00, 0x3F, 0xFF,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x10, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x10, 0x70, 0x00,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x00, 0x67,
  0x60, 0x00, 0x00, 0x03, 0x33, 0x80, 0x00, 0x00, 0x33, 0x0C, 0x00, 0x00,
  0x01, 0xB0, 0x60, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xD8, 0x01,
  0x90, 0x00, 0x00, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x66, 0x00, 0x33, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x60,
  0x03, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x80, 0x18, 0x08, 0x00, 0x01, 0x80,
  0x80, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x20, 0x04, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x10, 0x01, 0x80, 0x04, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x81, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x02, 0x60, 0x00, 0x20, 0x03, 0x00, 0x01,
  0xB0, 0x00, 0x30, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x38, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x24, 0x00, 0x00, 0x06, 0x00,
  0x66, 0x00, 0x00, 0x04, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x00, 0x62, 0x00,
  0x00, 0x0C, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x00, 0xC1, 0x00, 0x00, 0x08, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x80, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x01, 0x80, 0x60, 0x00, 0x30, 0x01, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x08, 0x00, 0x03, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x18, 0x00, 0x01, 0x83, 0x00, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x30, 0x00, 0x00, 0x66, 0x00, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x30, 0x00, 0x00, 0x66, 0x00, 0x60, 0x00, 0x00,
  0x34, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x68, 0x00, 0x00, 0x66, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x32, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x40,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x02, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x08,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x18, 0x00, 0x04, 0x18, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x23, 0x00, 0x00, 0x13, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x09, 0x80, 0x00, 0x04, 0x80, 0x00, 0x05, 0x80, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x03, 0x81, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0xC0,
  0x0F, 0x87, 0x86, 0x00, 0xE0, 0x0E, 0x30, 0x0E, 0x00, 0x31, 0x00, 0xC0,
  0x00, 0xC8, 0x0C, 0x00, 0x02, 0xC0, 0xE0, 0x00, 0x1E, 0x06, 0x00, 0x00,
  0xF0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x06, 0xC0,
  0x60, 0x00, 0x64, 0x03, 0x00, 0x07, 0x20, 0x0C, 0x00, 0x73, 0x00, 0x70,
  0x07, 0x18, 0x01, 0xE0, 0xE0, 0xC0, 0x07, 0xFE, 0x04, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x81, 0xFF, 0x80, 0x06, 0x1E, 0x0F, 0x00, 0x18, 0xE0,
  0x0E, 0x00, 0x47, 0x00, 0x1C, 0x03, 0x38, 0x00, 0x30, 0x0D, 0xC0, 0x00,
  0x60, 0x36, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x08,
  0x1E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x30, 0x16, 0x00,
  0x01, 0xC0, 0xCC, 0x00, 0x0E, 0x03, 0x30, 0x00, 0x70, 0x0C, 0x70, 0x03,
  0x80, 0x30, 0xF0, 0x78, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x04, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0F, 0xFC,
  0x0C, 0x00, 0x1F, 0x07, 0x86, 0x00, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0x00,
  0x33, 0x00, 0x18, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x06, 0xC0, 0x1C, 0x00,
  0x01, 0x60, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0xD8,
  0x01, 0x00, 0x00, 0xEC, 0x00, 0xC0, 0x00, 0x64, 0x00, 0x60, 0x00, 0x62,
  0x00, 0x18, 0x00, 0x63, 0x00, 0x0E, 0x00, 0xE1, 0x80, 0x03, 0xC1, 0xE0,
  0xC0, 0x00, 0xFF, 0xC0, 0x40, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x83, 0x80, 0x0F, 0x00, 0x60, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x20, 0x00, 0x70, 0x30, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x38, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x03, 0x00, 0x0F, 0x83, 0xC3, 0x00,
  0x1C, 0x00, 0xE3, 0x00, 0x38, 0x00, 0x62, 0x00, 0x60, 0x00, 0x36, 0x00,
  0xC0, 0x00, 0x36, 0x01, 0xC0, 0x00, 0x16, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x07, 0xC0, 0x18, 0x00, 0x0E, 0xC0, 0x18, 0x00, 0x0C, 0x80, 0x18,
  0x00, 0x19, 0x80, 0x0C, 0x00, 0x31, 0x80, 0x0E, 0x00, 0xE1, 0x80, 0x07,
  0x83, 0xC1, 0x80, 0x03, 0xFF, 0x01, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x01, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x01, 0x80, 0x01,
  0x81, 0xFF, 0x80, 0x18, 0x78, 0x3C, 0x01, 0x8E, 0x00, 0xE0, 0x11, 0x80,
  0x07, 0x03, 0x30, 0x00, 0x30, 0x36, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x30,
  0x2C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x83, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x10, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x02, 0x00, 0x70, 0x00, 0x60, 0x0E,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x86, 0xC0, 0x00, 0x18, 0xCC, 0x00, 0x01, 0x98, 0xC0, 0x00,
  0x1B, 0x06, 0x00, 0x01, 0x60, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x06, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x18, 0x70, 0x78, 0x0E, 0x0F, 0x00, 0x43, 0x00, 0x60,
  0xE0, 0x0E, 0x01, 0x38, 0x00, 0xC7, 0x00, 0x18, 0x0C, 0xC0, 0x03, 0x18,
  0x00, 0x30, 0x36, 0x00, 0x04, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x16, 0x00,
  0x03, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x18, 0x1F,
  0xF8, 0x01, 0x87, 0x83, 0xC0, 0x10, 0xE0, 0x0E, 0x01, 0x18, 0x00, 0x70,
  0x33, 0x00, 0x03, 0x03, 0x60, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x02, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x07, 0xFE, 0x00, 0x01, 0x87, 0xC3,
  0xC0, 0x00, 0x43, 0x80, 0x38, 0x00, 0x11, 0xC0, 0x07, 0x00, 0x0C, 0xE0,
  0x00, 0xC0, 0x03, 0x70, 0x00, 0x18, 0x00, 0xD8, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x0B, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x1E, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x01, 0x30, 0x00, 0x38,
  0x00, 0xCC, 0x00, 0x1C, 0x00, 0x31, 0x80, 0x0E, 0x00, 0x0C, 0x38, 0x1E,
  0x00, 0x03, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xF0, 0x30, 0x03, 0xE0,
  0xF0, 0xC0, 0x1C, 0x00, 0xE3, 0x00, 0xE0, 0x01, 0x88, 0x06, 0x00, 0x03,
  0x60, 0x30, 0x00, 0x0D, 0x81, 0xC0, 0x00, 0x16, 0x06, 0x00, 0x00, 0x78,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xF0, 0x10, 0x00,
  0x0E, 0xC0, 0x60, 0x00, 0x32, 0x01, 0x80, 0x01, 0x98, 0x03, 0x00, 0x0C,
  0x60, 0x0E, 0x00, 0xE1, 0x80, 0x1E, 0x0F, 0x06, 0x00, 0x3F, 0xF0, 0x30,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x03, 0x03, 0xFC, 0x06, 0x1E, 0x10, 0x08, 0x70,
  0x00, 0x11, 0x80, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00,
  0x02, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x07,
  0xE0, 0x38, 0x00, 0x20, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x20, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0F, 0x80, 0x78, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xC0, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x04, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0xD0, 0x18, 0x00, 0x0C, 0x80, 0xC0, 0x00, 0xCC, 0x03, 0x00, 0x0E, 0x60,
  0x1C, 0x00, 0xE2, 0x00, 0x78, 0x3C, 0x10, 0x01, 0xFF, 0xC1, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x08,
  0x01, 0x80, 0x04, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x01, 0x98,
  0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x00, 0xCC,
  0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x21, 0x80, 0x06, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00, 0x60,
  0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x30, 0x10, 0x03, 0x02, 0x00, 0x60,
  0x20, 0x04, 0x04, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x04, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x30, 0x80, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0xC0, 0x00, 0x98,
  0x00, 0x1B, 0x00, 0x01, 0x30, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78,
  0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE4, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x5E, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0xBE,
  0x40, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 50, 14, 2, -50 },
  { 83, 15, 18, 20, 7, -50 },
  { 117, 35, 50, 37, 2, -50 },
  { 336, 30, 57, 33, 2, -53 },
  { 550, 39, 52, 47, 5, -51 },
  { 804, 34, 52, 39, 2, -51 },
  { 1025, 6, 18, 11, 7, -50 },
  { 1039, 19, 61, 17, 2, -50 },
  { 1184, 20, 61, 17, -5, -50 },
  { 1337, 24, 25, 32, 9, -53 },
  { 1412, 29, 32, 35, 4, -41 },
  { 1528, 9, 16, 12, -3, -7 },
  { 1546, 16, 2, 21, 2, -20 },
  { 1550, 3, 4, 13, 2, -4 },
  { 1552, 30, 50, 21, -3, -50 },
  { 1740, 29, 52, 33, 3, -51 },
  { 1929, 15, 50, 33, 10, -50 },
  { 2023, 31, 51, 33, 0, -51 },
  { 2221, 32, 52, 33, 0, -51 },
  { 2429, 31, 50, 33, 0, -50 },
  { 2623, 32, 51, 33, 1, -50 },
  { 2827, 29, 52, 33, 4, -51 },
  { 3016, 29, 50, 33, 6, -50 },
  { 3198, 31, 52, 33, 2, -51 },
  { 3400, 30, 52, 33, 2, -51 },
  { 3595, 11, 37, 13, 1, -37 },
  { 3646, 15, 46, 13, -3, -37 },
  { 3733, 29, 30, 35, 4, -40 },
  { 3842, 29, 16, 35, 4, -33 },
  { 3900, 29, 30, 35, 4, -40 },
  { 4009, 22, 51, 24, 4, -51 },
  { 4150, 45, 56, 50, 3, -50 },
  { 4465, 33, 50, 33, -4, -50 },
  { 4672, 33, 50, 36, 2, -50 },
  { 4879, 34, 52, 35, 5, -51 },
  { 5100, 36, 50, 41, 2, -50 },
  { 5325, 33, 50, 32, 2, -50 },
  { 5532, 33, 50, 30, 2, -50 },
  { 5739, 37, 52, 42, 5, -51 },
  { 5980, 40, 50, 42, 2, -50 },
  { 6230, 21, 50, 17, -1, -50 },
  { 6362, 26, 62, 14, -11, -50 },
  { 6564, 37, 50, 33, 2, -50 },
  { 6796, 22, 50, 30, 2, -50 },
  { 6934, 49, 50, 51, 2, -50 },
  { 7241, 40, 50, 42, 2, -50 },
  { 7491, 36, 52, 43, 5, -51 },
  { 7725, 32, 50, 34, 2, -50 },
  { 7925, 36, 63, 43, 5, -51 },
  { 8209, 32, 50, 34, 2, -50 },
  { 8409, 32, 52, 31, 0, -51 },
  { 8617, 29, 50, 29, 6, -50 },
  { 8799, 37, 51, 42, 5, -50 },
  { 9035, 31, 50, 33, 7, -50 },
  { 9229, 49, 50, 52, 8, -50 },
  { 9536, 39, 50, 29, -4, -50 },
  { 9780, 29, 50, 29, 6, -50 },
  { 9962, 36, 50, 32, -1, -50 },
  { 10187, 26, 61, 20, -1, -50 },
  { 10386, 10, 50, 22, 7, -50 },
  { 10449, 26, 61, 20, -5, -50 },
  { 10648, 29, 28, 34, 3, -50 },
  { 10750, 24, 2, 23, -6, 7 },
  { 10756, 8, 12, 15, 10, -54 },
  { 10768, 29, 39, 34, 3, -38 },
  { 10910, 30, 54, 35, 2, -53 },
  { 11113, 25, 39, 27, 3, -38 },
  { 11235, 33, 54, 35, 3, -53 },
  { 11458, 25, 39, 30, 3, -38 },
  { 11580, 35, 71, 16, -9, -54 },
  { 11891, 32, 55, 35, 1, -38 },
  { 12111, 28, 53, 34, 2, -53 },
  { 12297, 12, 50, 13, 2, -50 },
  { 12372, 25, 67, 13, -10, -50 },
  { 12582, 28, 53, 27, 2, -53 },
  { 12768, 13, 53, 13, 2, -53 },
  { 12855, 46, 38, 51, 2, -38 },
  { 13074, 28, 38, 34, 2, -38 },
  { 13207, 28, 39, 34, 3, -38 },
  { 13344, 34, 54, 35, -2, -38 },
  { 13574, 30, 54, 35, 3, -38 },
  { 13777, 23, 38, 22, 2, -38 },
  { 13887, 25, 39, 26, 0, -38 },
  { 14009, 17, 47, 18, 3, -46 },
  { 14109, 29, 38, 34, 3, -37 },
  { 14247, 25, 37, 25, 4, -37 },
  { 14363, 39, 37, 41, 4, -37 },
  { 14544, 32, 37, 27, -3, -37 },
  { 14692, 37, 54, 26, -8, -37 },
  { 14942, 27, 37, 25, -1, -37 },
  { 15067, 24, 61, 22, 2, -50 },
  { 15250, 1, 70, 33, 17, -53 },
  { 15259, 25, 61, 22, -4, -50 },
  { 15450, 29, 6, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC70PT7B_H_
