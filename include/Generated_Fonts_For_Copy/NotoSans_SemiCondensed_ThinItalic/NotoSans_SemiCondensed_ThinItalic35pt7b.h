#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x84, 0x00, 0x00, 0x00, 0x30, 0x80, 0x42, 0x85, 0x12, 0x28,
  0x50, 0xA1, 0x44, 0x88, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02,
  0x08, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x3F, 0xFF,
  0xC0, 0x82, 0x00, 0x20, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x40, 0xFF, 0xFE, 0x02, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x08, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x07, 0x80, 0x34, 0xE1, 0x88,
  0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00,
  0xC8, 0x00, 0x50, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x30, 0x02, 0x20, 0x08,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x42, 0x10, 0xFF, 0xC0,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x00, 0x1F, 0x00, 0xC4, 0x20,
  0x10, 0x84, 0x04, 0x20, 0x40, 0x84, 0x08, 0x21, 0x02, 0x08, 0x20, 0x41,
  0x04, 0x08, 0x40, 0x81, 0x10, 0x10, 0x22, 0x02, 0x08, 0x8F, 0x41, 0x22,
  0x28, 0x44, 0x83, 0x09, 0x20, 0x7E, 0x44, 0x08, 0x08, 0x81, 0x02, 0x20,
  0x20, 0xC4, 0x08, 0x10, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x20, 0x41,
  0x08, 0x08, 0x21, 0x01, 0x08, 0x40, 0x1E, 0x00, 0x01, 0xF8, 0x01, 0x86,
  0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x30, 0x08,
  0x10, 0x04, 0x10, 0x01, 0x10, 0x00, 0xB0, 0x00, 0x60, 0x00, 0x50, 0x00,
  0xC4, 0x00, 0xC1, 0x02, 0xC0, 0x82, 0x40, 0x21, 0x40, 0x11, 0x20, 0x04,
  0x90, 0x02, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x90, 0x80, 0x88, 0x3F,
  0x82, 0x00, 0x55, 0xAA, 0x80, 0x00, 0xC0, 0x40, 0x30, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x00, 0x01, 0x00, 0x08, 0x00, 0x41,
  0x04, 0x06, 0x20, 0x09, 0x00, 0x3F, 0xE0, 0xC0, 0x0A, 0x00, 0x88, 0x08,
  0x40, 0x81, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x08,
  0x44, 0x22, 0x11, 0x18, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x84, 0x01,
  0x10, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00,
  0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x0C, 0x10, 0x60, 0x3E,
  0x00, 0x03, 0x06, 0x1A, 0x22, 0xC2, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x01, 0xFC, 0x06, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x0E, 0x02, 0x04, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x80, 0x20, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0A,
  0x00, 0x0A, 0x00, 0x12, 0x00, 0x22, 0x00, 0x44, 0x00, 0x84, 0x00, 0x84,
  0x01, 0x04, 0x02, 0x04, 0x04, 0x08, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x10, 0x40, 0x11, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x01, 0xFF, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x18, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x80, 0x60, 0x7F, 0xC0, 0x00, 0xFE,
  0x02, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x3F, 0x82, 0x81, 0x8A, 0x01, 0x18, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x04, 0x10, 0x10, 0x20, 0x60, 0x3F, 0x00, 0x7F, 0xFC, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x0C, 0x08, 0x10, 0x08, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x10,
  0x08, 0xC0, 0x0E, 0x00, 0x7C, 0x01, 0x04, 0x0C, 0x04, 0x20, 0x08, 0x40,
  0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x10, 0x04,
  0x30, 0x10, 0x1F, 0xC0, 0x03, 0xF8, 0x0C, 0x18, 0x20, 0x10, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x19, 0x00, 0x22, 0x00, 0xC2, 0x02, 0x83, 0xF1, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0xFE, 0x00, 0x08, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x20, 0x01, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0x84, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x81, 0x80, 0x30, 0x01, 0x01, 0x80,
  0x02, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x11, 0x00, 0x00, 0x48, 0x07, 0x81,
  0x20, 0x61, 0x05, 0x03, 0x04, 0x14, 0x18, 0x10, 0x60, 0x40, 0x81, 0x82,
  0x02, 0x06, 0x08, 0x08, 0x18, 0x20, 0x20, 0xA1, 0x01, 0x02, 0x84, 0x04,
  0x0A, 0x10, 0x30, 0x48, 0x40, 0xC1, 0x20, 0x85, 0x08, 0x81, 0xE3, 0xC2,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x40, 0x01, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x14, 0x00, 0x14, 0x00, 0x22, 0x00, 0x22, 0x00, 0x42, 0x00,
  0x42, 0x00, 0x82, 0x00, 0x82, 0x01, 0x02, 0x01, 0x02, 0x02, 0x02, 0x07,
  0xFE, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x07, 0xFC, 0x02,
  0x01, 0x01, 0x00, 0x40, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x10, 0x02, 0x08, 0x01, 0x08, 0x01, 0x04, 0x01, 0x03, 0xFF, 0x01, 0x03,
  0x80, 0x80, 0x60, 0x80, 0x10, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x88, 0x00, 0x84, 0x00, 0x42, 0x00, 0x61, 0x00, 0x61, 0x00, 0x60,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0xC0, 0x40, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01,
  0x01, 0x80, 0x40, 0x10, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00, 0x10, 0x80,
  0x04, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x04, 0x10, 0x02, 0x04, 0x01,
  0x02, 0x03, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x30, 0x0C, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x7F, 0x20, 0x00, 0x24, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20,
  0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x10, 0x0F, 0xFC, 0x00, 0x04, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41, 0x00, 0x04, 0x10,
  0x00, 0x41, 0xFF, 0xF8, 0x10, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0x82,
  0x00, 0x08, 0x20, 0x01, 0x02, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x00, 0x03, 0xE0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0xFC, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x06, 0x00, 0x83, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x04,
  0x60, 0x01, 0x30, 0x00, 0x5C, 0x00, 0x15, 0x00, 0x06, 0x20, 0x03, 0x08,
  0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x30, 0x10, 0x04, 0x04, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0xFF, 0xE0, 0x06,
  0x00, 0x01, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x05, 0x0A,
  0x00, 0x05, 0x09, 0x00, 0x0A, 0x09, 0x00, 0x12, 0x09, 0x00, 0x12, 0x09,
  0x00, 0x22, 0x11, 0x00, 0x24, 0x11, 0x00, 0x44, 0x11, 0x00, 0x44, 0x11,
  0x00, 0x84, 0x10, 0x80, 0x84, 0x20, 0x81, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x10, 0x40,
  0x48, 0x10, 0x40, 0x50, 0x10, 0x40, 0x50, 0x10, 0x80, 0x60, 0x10, 0x80,
  0x40, 0x20, 0x04, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x20, 0x50, 0x02,
  0x09, 0x00, 0x20, 0x90, 0x02, 0x08, 0x80, 0x20, 0x88, 0x04, 0x08, 0x80,
  0x41, 0x04, 0x04, 0x10, 0x40, 0x41, 0x04, 0x04, 0x10, 0x20, 0x81, 0x02,
  0x08, 0x20, 0x20, 0x82, 0x01, 0x08, 0x20, 0x11, 0x02, 0x01, 0x10, 0x40,
  0x09, 0x04, 0x00, 0x90, 0x40, 0x09, 0x04, 0x00, 0x60, 0x40, 0x06, 0x08,
  0x00, 0x60, 0x80, 0x02, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x40, 0x40, 0x08,
  0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x02, 0x10, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x60, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x04, 0x04, 0x04, 0x02, 0x04, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x04, 0x10, 0x08, 0x1F, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x40, 0x40, 0x08, 0x20,
  0x01, 0x18, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x02, 0x10, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x60, 0x0F, 0xE0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x07, 0xF8, 0x04, 0x06, 0x04, 0x02, 0x04, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x06,
  0x10, 0x0C, 0x10, 0x38, 0x1F, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40,
  0x20, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x80, 0x08, 0x80, 0x08, 0x01, 0xFE, 0x02, 0x01, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x80, 0x60, 0x7F, 0xC0, 0xFF, 0xFE, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00,
  0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x40, 0x80, 0x08, 0x10, 0x02, 0x01,
  0x01, 0x80, 0x1F, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x20, 0x40, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x20, 0x80, 0x21,
  0x00, 0x21, 0x00, 0x22, 0x00, 0x22, 0x00, 0x24, 0x00, 0x24, 0x00, 0x28,
  0x00, 0x28, 0x00, 0x30, 0x00, 0x30, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0x08, 0x80, 0x88, 0x08,
  0x80, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x0A,
  0x00, 0xA0, 0x0A, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00,
  0x20, 0x40, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x10, 0x01, 0x04,
  0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x08, 0x80,
  0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80,
  0x60, 0x10, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x00, 0x80, 0x07,
  0x00, 0x09, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x80, 0x42, 0x00, 0x44, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80,
  0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xF0, 0x00, 0xC1, 0x04, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x40, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x02,
  0x80, 0x08, 0x80, 0x11, 0x00, 0x42, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x20, 0x08, 0x40, 0x11, 0x00, 0x26, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xF0,
  0x84, 0x42, 0x21, 0x01, 0xE0, 0x0C, 0x24, 0x20, 0x28, 0x80, 0x51, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x48, 0x01, 0x90, 0x02, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x50, 0xC1,
  0x20, 0xFC, 0x80, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0xF0, 0x26, 0x10, 0x58, 0x10,
  0xE0, 0x21, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x60, 0x08,
  0xA0, 0x31, 0x40, 0xC2, 0x7E, 0x00, 0x03, 0xE0, 0xC1, 0x18, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x01, 0xE1, 0x03, 0x0D, 0x03, 0x02, 0x82, 0x00,
  0xC1, 0x00, 0x61, 0x00, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x02, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC1, 0x00, 0x60,
  0x80, 0x60, 0x40, 0x50, 0x30, 0x48, 0x0F, 0xC4, 0x00, 0x03, 0xC0, 0x42,
  0x18, 0x11, 0x01, 0x20, 0x14, 0x01, 0x40, 0x28, 0x06, 0x81, 0x8F, 0xE0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x04,
  0x3F, 0x80, 0x00, 0x03, 0xC0, 0x03, 0x10, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x6F,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x81,
  0x86, 0x81, 0x81, 0x41, 0x00, 0x60, 0x80, 0x30, 0x80, 0x10, 0x40, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x60, 0x80, 0x30, 0x40, 0x30, 0x20, 0x28, 0x18, 0x24, 0x07,
  0xE2, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x40, 0x20, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0xF0, 0x4C,
  0x21, 0x40, 0x46, 0x01, 0x18, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x04, 0x40, 0x21, 0x01, 0x04,
  0x08, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x26, 0x00, 0xA8, 0x05,
  0x20, 0x18, 0x40, 0x41, 0x01, 0x04, 0x04, 0x08, 0x20, 0x20, 0x80, 0x42,
  0x01, 0x08, 0x04, 0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x00, 0x00, 0xE0, 0x78, 0x26, 0x23, 0x08, 0x50, 0x2C, 0x08, 0xC0, 0x50,
  0x11, 0x80, 0xC0, 0x22, 0x01, 0x80, 0x4C, 0x02, 0x00, 0x90, 0x04, 0x02,
  0x20, 0x08, 0x04, 0x40, 0x20, 0x08, 0x80, 0x40, 0x12, 0x00, 0x80, 0x24,
  0x01, 0x00, 0x88, 0x02, 0x01, 0x10, 0x08, 0x02, 0x40, 0x10, 0x04, 0x80,
  0x20, 0x09, 0x00, 0x40, 0x22, 0x01, 0x80, 0x40, 0x00, 0xF0, 0x4C, 0x21,
  0x40, 0x46, 0x01, 0x18, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20, 0x08,
  0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x02, 0x00, 0x03, 0xC0, 0x30, 0xC1, 0x81, 0x8C,
  0x02, 0x20, 0x09, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x41,
  0x03, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x02, 0x61, 0x01, 0x60, 0x40, 0xE0,
  0x20, 0x60, 0x08, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08,
  0x60, 0x08, 0x28, 0x0C, 0x14, 0x0C, 0x09, 0xF8, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xE1, 0x06, 0x1A, 0x0C, 0x0A, 0x18, 0x06, 0x10, 0x06,
  0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x80, 0x08, 0x80, 0x18, 0x40, 0x18, 0x40, 0x30, 0x40, 0x50,
  0x60, 0x90, 0x3F, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xE2, 0x60, 0x50,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x03,
  0xC0, 0xC1, 0x10, 0x01, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x48, 0x08, 0x7F, 0x00, 0x08, 0x04, 0x02, 0x01, 0x01, 0x03, 0xFC, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x01, 0xE0, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x88, 0x06, 0x20, 0x28, 0x81, 0x41,
  0xF9, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x80,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x50,
  0x05, 0x00, 0x20, 0x02, 0x00, 0x80, 0x40, 0x38, 0x0C, 0x02, 0x80, 0xA0,
  0x48, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x12, 0x08, 0x82, 0x20, 0x88, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x20, 0x88, 0x22, 0x08, 0x82, 0x40, 0x90,
  0x24, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x02, 0x80, 0x40, 0x30, 0x04,
  0x03, 0x00, 0x08, 0x02, 0x08, 0x08, 0x10, 0x20, 0x20, 0x80, 0x23, 0x00,
  0x44, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x24,
  0x00, 0x84, 0x02, 0x08, 0x0C, 0x08, 0x10, 0x10, 0x40, 0x21, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x40, 0x08, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x10,
  0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x88, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x12,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF,
  0x80, 0x00, 0x70, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x30, 0x0E,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x07, 0x00, 0x80, 0x00, 0x3C, 0x03, 0x86, 0x0E, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 7, 1, -25 },
  { 20, 7, 9, 10, 4, -25 },
  { 28, 18, 25, 18, 1, -25 },
  { 85, 15, 29, 17, 1, -27 },
  { 140, 19, 25, 24, 3, -25 },
  { 200, 17, 25, 19, 1, -25 },
  { 254, 2, 9, 6, 4, -25 },
  { 257, 10, 31, 8, 1, -25 },
  { 296, 9, 31, 8, -2, -25 },
  { 331, 13, 13, 16, 4, -27 },
  { 353, 15, 16, 18, 2, -20 },
  { 383, 5, 8, 6, -2, -4 },
  { 388, 8, 1, 10, 1, -10 },
  { 389, 2, 2, 7, 1, -2 },
  { 390, 15, 25, 11, -2, -25 },
  { 437, 14, 25, 17, 2, -25 },
  { 481, 8, 25, 17, 5, -25 },
  { 506, 16, 25, 17, 0, -25 },
  { 556, 16, 25, 17, 0, -25 },
  { 606, 16, 25, 17, 0, -25 },
  { 656, 16, 25, 17, 0, -25 },
  { 706, 15, 25, 17, 2, -25 },
  { 753, 14, 25, 17, 3, -25 },
  { 797, 15, 25, 17, 1, -25 },
  { 844, 15, 25, 17, 1, -25 },
  { 891, 5, 19, 7, 1, -19 },
  { 903, 8, 23, 7, -2, -19 },
  { 926, 15, 15, 18, 2, -20 },
  { 955, 15, 8, 18, 2, -16 },
  { 970, 15, 15, 18, 2, -20 },
  { 999, 11, 25, 12, 2, -25 },
  { 1034, 22, 28, 25, 2, -25 },
  { 1111, 16, 25, 16, -2, -25 },
  { 1161, 17, 25, 18, 1, -25 },
  { 1215, 17, 25, 18, 2, -25 },
  { 1269, 18, 25, 20, 1, -25 },
  { 1326, 16, 25, 16, 1, -25 },
  { 1376, 16, 25, 15, 1, -25 },
  { 1426, 19, 25, 21, 2, -25 },
  { 1486, 20, 25, 21, 1, -25 },
  { 1549, 11, 25, 8, -1, -25 },
  { 1584, 13, 31, 7, -6, -25 },
  { 1635, 18, 25, 16, 1, -25 },
  { 1692, 11, 25, 15, 1, -25 },
  { 1727, 24, 25, 25, 1, -25 },
  { 1802, 20, 25, 21, 1, -25 },
  { 1865, 18, 25, 22, 2, -25 },
  { 1922, 16, 25, 17, 1, -25 },
  { 1972, 18, 31, 22, 2, -25 },
  { 2042, 16, 25, 17, 1, -25 },
  { 2092, 16, 25, 15, 0, -25 },
  { 2142, 15, 25, 15, 3, -25 },
  { 2189, 19, 25, 21, 2, -25 },
  { 2249, 16, 25, 16, 3, -25 },
  { 2299, 24, 25, 26, 4, -25 },
  { 2374, 19, 25, 15, -2, -25 },
  { 2434, 15, 25, 14, 3, -25 },
  { 2481, 18, 25, 16, -1, -25 },
  { 2538, 13, 31, 10, 0, -25 },
  { 2589, 6, 25, 11, 3, -25 },
  { 2608, 13, 31, 10, -2, -25 },
  { 2659, 15, 14, 17, 1, -25 },
  { 2686, 12, 1, 12, -3, 3 },
  { 2688, 4, 6, 8, 5, -27 },
  { 2691, 15, 19, 17, 1, -19 },
  { 2727, 15, 27, 17, 1, -27 },
  { 2778, 12, 19, 13, 2, -19 },
  { 2807, 17, 27, 17, 1, -27 },
  { 2865, 12, 19, 15, 2, -19 },
  { 2894, 18, 35, 8, -5, -27 },
  { 2973, 17, 27, 17, 0, -19 },
  { 3031, 14, 27, 17, 1, -27 },
  { 3079, 6, 25, 7, 1, -25 },
  { 3098, 12, 33, 7, -5, -25 },
  { 3148, 14, 27, 14, 1, -27 },
  { 3196, 6, 27, 6, 1, -27 },
  { 3217, 23, 19, 26, 1, -19 },
  { 3272, 14, 19, 17, 1, -19 },
  { 3306, 14, 19, 17, 2, -19 },
  { 3340, 17, 27, 17, -1, -19 },
  { 3398, 16, 27, 17, 1, -19 },
  { 3452, 11, 19, 11, 1, -19 },
  { 3479, 12, 19, 13, 0, -19 },
  { 3508, 9, 23, 9, 1, -23 },
  { 3534, 14, 18, 17, 2, -18 },
  { 3566, 12, 18, 13, 2, -18 },
  { 3593, 20, 18, 20, 2, -18 },
  { 3638, 15, 18, 14, -1, -18 },
  { 3672, 19, 27, 13, -4, -18 },
  { 3737, 14, 18, 13, -1, -18 },
  { 3769, 12, 31, 11, 1, -25 },
  { 3816, 1, 35, 16, 8, -27 },
  { 3821, 12, 31, 11, -2, -25 },
  { 3868, 15, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC35PT7B_H_
