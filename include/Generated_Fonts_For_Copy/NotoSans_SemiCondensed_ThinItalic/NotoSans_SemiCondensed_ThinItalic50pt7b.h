#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x10, 0x62,
  0x08, 0xC1, 0x10, 0x22, 0x0C, 0x41, 0x08, 0x23, 0x04, 0x40, 0x88, 0x31,
  0x04, 0x20, 0x88, 0x10, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x02, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x10,
  0x0C, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x40, 0x20, 0x00, 0x30, 0x08, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x04,
  0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00,
  0x18, 0x04, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x0C, 0x20, 0xC0, 0x40, 0x80, 0x02,
  0x06, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x10, 0x30, 0x00, 0x40, 0x80, 0x01, 0x82, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x20, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x58, 0x00, 0x03, 0x30, 0x00, 0x08, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x81,
  0x00, 0x02, 0x04, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00,
  0x04, 0x0C, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x83, 0x02, 0x18, 0x07, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xC1, 0x86, 0x00,
  0x10, 0x60, 0x40, 0x04, 0x08, 0x08, 0x01, 0x83, 0x01, 0x00, 0x20, 0x40,
  0x20, 0x08, 0x18, 0x04, 0x03, 0x02, 0x00, 0x80, 0x40, 0x40, 0x10, 0x10,
  0x18, 0x02, 0x06, 0x03, 0x00, 0x40, 0x80, 0x40, 0x18, 0x30, 0x08, 0x03,
  0x0C, 0x01, 0x00, 0x41, 0x00, 0x20, 0x08, 0x61, 0xC4, 0x03, 0x18, 0xFE,
  0x80, 0x42, 0x30, 0x70, 0x18, 0xC4, 0x06, 0x02, 0x31, 0x80, 0xE0, 0xC4,
  0x20, 0x16, 0x31, 0x8C, 0x02, 0x7C, 0x21, 0x00, 0x40, 0x08, 0x20, 0x08,
  0x03, 0x0C, 0x01, 0x00, 0x41, 0x00, 0x60, 0x10, 0x20, 0x0C, 0x06, 0x04,
  0x01, 0x00, 0x80, 0x80, 0x20, 0x20, 0x30, 0x04, 0x0C, 0x06, 0x01, 0x81,
  0x00, 0xC0, 0x20, 0x60, 0x18, 0x0C, 0x18, 0x03, 0x01, 0x02, 0x00, 0x20,
  0x60, 0xC0, 0x06, 0x18, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x01, 0x00, 0x20,
  0x00, 0x80, 0x10, 0x00, 0x40, 0x18, 0x00, 0x20, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x18, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0xC0, 0xC0, 0x18, 0xC0, 0x20, 0x08, 0xC0, 0x18, 0x0C, 0x40,
  0x04, 0x04, 0x60, 0x01, 0x06, 0x20, 0x00, 0xC2, 0x10, 0x00, 0x23, 0x18,
  0x00, 0x19, 0x0C, 0x00, 0x05, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x01, 0xE0, 0x40, 0x01, 0x90, 0x30, 0x01, 0x84, 0x0E, 0x03, 0x02,
  0x01, 0xFF, 0x00, 0x80, 0x10, 0x00, 0x00, 0x11, 0x32, 0x22, 0x26, 0x44,
  0x44, 0x80, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x80, 0x40, 0x38,
  0x10, 0x03, 0x04, 0x00, 0x32, 0x00, 0x03, 0x87, 0xC0, 0x3E, 0x00, 0x14,
  0x00, 0x09, 0x00, 0x0C, 0x40, 0x06, 0x08, 0x03, 0x02, 0x01, 0x80, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x30, 0x86, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x87, 0x00,
  0x30, 0x08, 0x03, 0x00, 0x60, 0x30, 0x01, 0x01, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x06, 0x20,
  0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x03,
  0x20, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00,
  0x03, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C, 0xC0, 0x00, 0x46,
  0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00,
  0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x60, 0x04, 0x01, 0x80, 0x60, 0x06,
  0x0E, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x07,
  0x83, 0x20, 0xC4, 0x60, 0xB8, 0x32, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x20, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x30, 0x18, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x81,
  0x00, 0x07, 0x03, 0x80, 0x38, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x0B, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x42, 0x00, 0x02,
  0x18, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x10, 0x10,
  0x00, 0xC0, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x08, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x20, 0x01,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00, 0x02, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0xFF, 0x80, 0x0C,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x02, 0x00, 0x18,
  0x0C, 0x01, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xC0, 0x40, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x83, 0xF0,
  0x0C, 0x71, 0xC0, 0x4C, 0x03, 0x02, 0xC0, 0x0C, 0x1C, 0x00, 0x31, 0xC0,
  0x01, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08,
  0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00,
  0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x18, 0x00, 0x40, 0x40, 0x06, 0x03,
  0x00, 0x60, 0x0C, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xC1, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x02, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x06, 0x03, 0x00, 0x10, 0x06, 0x00,
  0x80, 0x0C, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x60, 0x00, 0xC0, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00,
  0x04, 0x18, 0x00, 0x18, 0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x02,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x10,
  0x00, 0x10, 0x60, 0x00, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x60, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x81, 0x80, 0x0C, 0x03,
  0x00, 0x40, 0x04, 0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x00, 0x83,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x20, 0x00, 0xA0, 0xC0, 0x07, 0x81, 0x00, 0x34, 0x03,
  0x07, 0x10, 0x07, 0xF0, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x08, 0x06, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x07,
  0x06, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0,
  0xC0, 0x00, 0x40, 0x1C, 0x03, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x07, 0xF0, 0x3C, 0x18, 0x20, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x41, 0x00, 0x1F,
  0xE0, 0x21, 0x80, 0x30, 0x10, 0x18, 0x80, 0x30, 0x18, 0x0C, 0xC0, 0x30,
  0x0C, 0x06, 0x40, 0x30, 0x04, 0x03, 0x20, 0x10, 0x02, 0x01, 0x30, 0x18,
  0x03, 0x00, 0x90, 0x08, 0x01, 0x00, 0x48, 0x0C, 0x00, 0x80, 0x24, 0x04,
  0x00, 0x40, 0x36, 0x02, 0x00, 0x60, 0x13, 0x01, 0x00, 0x20, 0x09, 0x81,
  0x80, 0x10, 0x0C, 0xC0, 0xC0, 0x18, 0x04, 0x60, 0x60, 0x0C, 0x06, 0x30,
  0x10, 0x0A, 0x02, 0x18, 0x08, 0x0D, 0x02, 0x0C, 0x06, 0x0C, 0xC3, 0x06,
  0x01, 0xFC, 0x3E, 0x01, 0x00, 0x10, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x58, 0x00, 0x00, 0x98, 0x00, 0x00, 0x88, 0x00,
  0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00,
  0x10, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x04, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x04, 0x01,
  0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x04,
  0x00, 0x06, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x30,
  0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x04, 0x00, 0x70, 0x08,
  0x00, 0x20, 0x30, 0x00, 0x60, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00,
  0x01, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x40, 0x00, 0x41, 0x80, 0x01, 0x03, 0x00, 0x06, 0x04, 0x00, 0x30,
  0x08, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x03, 0x01,
  0x00, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00,
  0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00, 0x20, 0xC0, 0x00,
  0xC1, 0x80, 0x06, 0x02, 0x00, 0x78, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0x03, 0xC0, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x7F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x40, 0x0E, 0x00, 0x20, 0x01, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x08, 0x00, 0x04, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x60,
  0x00, 0x04, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06,
  0x10, 0x00, 0x03, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01,
  0x82, 0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x03,
  0x80, 0x40, 0x07, 0x00, 0x20, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x78, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFC, 0x20, 0x01, 0xFF, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x18, 0x01,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xF0, 0x18,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00,
  0x01, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x40, 0x00, 0x40, 0x10, 0x00, 0x20, 0x04, 0x00, 0x10, 0x03, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x08, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x10, 0x30, 0x00,
  0x04, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x09, 0xE0, 0x00, 0x02, 0xC8, 0x00, 0x01, 0xA3, 0x00, 0x00, 0x50,
  0xC0, 0x00, 0x18, 0x10, 0x00, 0x04, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x20, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x60,
  0x01, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00,
  0x10, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x20, 0x08,
  0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x90, 0x00, 0x01, 0xA0, 0x24, 0x00, 0x00, 0x48, 0x09, 0x00, 0x00, 0x32,
  0x06, 0x40, 0x00, 0x09, 0x81, 0x90, 0x00, 0x06, 0x40, 0x44, 0x00, 0x01,
  0x10, 0x11, 0x80, 0x00, 0xC4, 0x04, 0x60, 0x00, 0x23, 0x03, 0x08, 0x00,
  0x10, 0xC0, 0xC2, 0x00, 0x0C, 0x20, 0x20, 0x80, 0x02, 0x08, 0x08, 0x20,
  0x01, 0x82, 0x02, 0x08, 0x00, 0x41, 0x81, 0x82, 0x00, 0x30, 0x60, 0x40,
  0xC0, 0x08, 0x10, 0x10, 0x30, 0x06, 0x04, 0x04, 0x04, 0x01, 0x01, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x0C, 0x02, 0x02, 0x01, 0x82, 0x01, 0x81, 0x80, 0x61, 0x80,
  0x60, 0x60, 0x08, 0x40, 0x10, 0x10, 0x02, 0x30, 0x04, 0x04, 0x00, 0x88,
  0x01, 0x01, 0x00, 0x24, 0x00, 0xC0, 0xC0, 0x0B, 0x00, 0x30, 0x20, 0x02,
  0x80, 0x08, 0x08, 0x00, 0xE0, 0x02, 0x02, 0x00, 0x30, 0x01, 0x80, 0x01,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00,
  0x02, 0x03, 0xC0, 0x00, 0x20, 0x24, 0x00, 0x06, 0x02, 0x60, 0x00, 0x60,
  0x22, 0x00, 0x04, 0x06, 0x20, 0x00, 0x40, 0x63, 0x00, 0x04, 0x04, 0x10,
  0x00, 0xC0, 0x41, 0x00, 0x0C, 0x04, 0x18, 0x00, 0x80, 0xC0, 0x80, 0x08,
  0x0C, 0x08, 0x00, 0x80, 0x80, 0xC0, 0x18, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x18, 0x06, 0x01, 0x01, 0x00, 0x20, 0x30, 0x10, 0x02, 0x03,
  0x01, 0x00, 0x30, 0x20, 0x30, 0x01, 0x02, 0x03, 0x00, 0x10, 0x20, 0x20,
  0x01, 0x86, 0x02, 0x00, 0x08, 0x60, 0x20, 0x00, 0x84, 0x06, 0x00, 0x0C,
  0x40, 0x60, 0x00, 0x44, 0x04, 0x00, 0x04, 0xC0, 0x40, 0x00, 0x6C, 0x04,
  0x00, 0x02, 0x80, 0xC0, 0x00, 0x28, 0x08, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x18, 0x08, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x07, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x20, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x01, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x40, 0x30, 0x00, 0x20, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x10, 0x03, 0x00, 0x40, 0x06, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20,
  0x00, 0x40, 0x80, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x82,
  0x00, 0x06, 0x08, 0x00, 0x30, 0x20, 0x01, 0x81, 0x80, 0x1C, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0x07, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x40, 0x30, 0x00, 0x20, 0x06, 0x00, 0x30, 0x00,
  0xE0, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x10, 0x03, 0x00, 0x40, 0x06, 0x03,
  0x00, 0x0C, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x06, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x20, 0xC0, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20,
  0x03, 0x01, 0x80, 0x78, 0x07, 0xFF, 0x00, 0x10, 0x08, 0x00, 0x40, 0x30,
  0x03, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02,
  0x00, 0x20, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x00, 0x04, 0x04, 0x00,
  0x10, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x20, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x81, 0x00, 0x06, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x13, 0x00, 0x00, 0x8C, 0x00,
  0x02, 0x30, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x02, 0x04, 0x00, 0x08,
  0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10,
  0x01, 0x00, 0x40, 0x04, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x34, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0xE0, 0x00, 0x64, 0x00,
  0x0A, 0x00, 0x04, 0x40, 0x00, 0xA0, 0x00, 0xC4, 0x00, 0x1A, 0x00, 0x08,
  0x40, 0x01, 0x20, 0x01, 0x84, 0x00, 0x32, 0x00, 0x10, 0x40, 0x02, 0x20,
  0x01, 0x04, 0x00, 0x62, 0x00, 0x20, 0x40, 0x04, 0x20, 0x02, 0x04, 0x00,
  0xC2, 0x00, 0x60, 0x40, 0x08, 0x20, 0x04, 0x04, 0x00, 0x82, 0x00, 0xC0,
  0x40, 0x10, 0x20, 0x08, 0x04, 0x01, 0x02, 0x01, 0x80, 0x40, 0x30, 0x20,
  0x10, 0x04, 0x02, 0x02, 0x01, 0x00, 0x40, 0x60, 0x20, 0x30, 0x04, 0x04,
  0x02, 0x02, 0x00, 0x40, 0xC0, 0x20, 0x60, 0x04, 0x08, 0x02, 0x04, 0x00,
  0x41, 0x80, 0x20, 0xC0, 0x04, 0x10, 0x02, 0x08, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x04, 0x30, 0x02, 0x18, 0x00, 0x42, 0x00, 0x31, 0x00, 0x04, 0x60,
  0x03, 0x30, 0x00, 0x44, 0x00, 0x32, 0x00, 0x04, 0xC0, 0x03, 0x60, 0x00,
  0x48, 0x00, 0x34, 0x00, 0x05, 0x80, 0x03, 0x40, 0x00, 0x50, 0x00, 0x38,
  0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00, 0x30, 0x02, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18,
  0x00, 0x02, 0x80, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0x84, 0x00, 0x18,
  0x40, 0x01, 0x06, 0x00, 0x20, 0x60, 0x06, 0x02, 0x00, 0x40, 0x20, 0x0C,
  0x02, 0x01, 0x80, 0x30, 0x10, 0x01, 0x03, 0x00, 0x10, 0x60, 0x01, 0x04,
  0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x0A,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x81, 0x03, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81,
  0x02, 0x06, 0x04, 0x08, 0x10, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30, 0x00, 0x10, 0x80,
  0x01, 0x84, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0xC0,
  0x30, 0x04, 0x00, 0x80, 0x60, 0x04, 0x02, 0x00, 0x30, 0x20, 0x00, 0x83,
  0x00, 0x04, 0x10, 0x00, 0x31, 0x00, 0x00, 0x98, 0x00, 0x05, 0x80, 0x00,
  0x30, 0xFF, 0xFF, 0x80, 0xC1, 0x06, 0x08, 0x10, 0x60, 0x81, 0x00, 0x3E,
  0x00, 0x07, 0xB8, 0x40, 0xE0, 0x26, 0x0C, 0x00, 0xA0, 0x40, 0x05, 0x04,
  0x00, 0x28, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x21, 0x00, 0x01,
  0x08, 0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x00, 0x14, 0x08, 0x01,
  0xA0, 0x60, 0x19, 0x01, 0x81, 0x88, 0x07, 0xF0, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x83, 0xE0, 0x06, 0x3D, 0xE0,
  0x19, 0x80, 0xC0, 0x4C, 0x01, 0x01, 0x60, 0x06, 0x07, 0x00, 0x08, 0x38,
  0x00, 0x20, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x31, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00,
  0x02, 0x18, 0x00, 0x18, 0x70, 0x00, 0x41, 0x40, 0x03, 0x05, 0x00, 0x18,
  0x16, 0x00, 0xC0, 0xCC, 0x06, 0x02, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x38, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x03, 0x00, 0xFF,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x3E, 0x0C, 0x00, 0xF7, 0x88, 0x03, 0x80, 0xC8, 0x06, 0x00, 0x48,
  0x04, 0x00, 0x38, 0x08, 0x00, 0x38, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40,
  0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0x40, 0x06, 0x80, 0x40, 0x0C, 0x80,
  0x60, 0x19, 0x80, 0x30, 0x31, 0x00, 0x1F, 0xE1, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3D, 0xE0, 0x18, 0x08, 0x0C, 0x03, 0x04, 0x00, 0x43,
  0x00, 0x11, 0x80, 0x04, 0x40, 0x03, 0x30, 0x00, 0x88, 0x00, 0x62, 0x00,
  0x31, 0x80, 0x38, 0x40, 0x78, 0x1F, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0x00, 0xFF,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0x00, 0x3D, 0xE2, 0x00, 0xE0, 0x32, 0x01, 0x80, 0x12, 0x01, 0x00,
  0x0A, 0x02, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x10, 0x30, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xE0, 0x10, 0x01, 0xA0, 0x10, 0x03, 0x60, 0x18, 0x06,
  0x60, 0x0C, 0x0C, 0x40, 0x07, 0xF8, 0x40, 0x00, 0x80, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x0C,
  0x00, 0xF8, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x1F, 0x00, 0x23, 0xDE, 0x03, 0x30, 0x18, 0x12, 0x00, 0x40, 0xA0,
  0x03, 0x07, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x20,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00,
  0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x04,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x02, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x60, 0x04, 0x04, 0x00, 0x80,
  0x40, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0x81, 0x80,
  0x08, 0x30, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x1C, 0x00, 0x13, 0x40,
  0x01, 0x66, 0x00, 0x1C, 0x20, 0x03, 0x82, 0x00, 0x30, 0x30, 0x02, 0x01,
  0x00, 0x20, 0x18, 0x06, 0x00, 0x80, 0x60, 0x08, 0x04, 0x00, 0xC0, 0x40,
  0x04, 0x04, 0x00, 0x40, 0xC0, 0x06, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0x1D, 0xE0, 0xF7,
  0x81, 0x30, 0x18, 0xC0, 0x40, 0x90, 0x04, 0xC0, 0x30, 0x50, 0x02, 0xC0,
  0x08, 0x30, 0x01, 0x40, 0x04, 0x38, 0x00, 0xC0, 0x02, 0x18, 0x00, 0x60,
  0x01, 0x0C, 0x00, 0x20, 0x00, 0x84, 0x00, 0x10, 0x00, 0xC2, 0x00, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x00, 0x10, 0x80, 0x02,
  0x00, 0x08, 0x40, 0x01, 0x00, 0x0C, 0x20, 0x01, 0x80, 0x04, 0x30, 0x00,
  0x80, 0x02, 0x10, 0x00, 0x40, 0x01, 0x08, 0x00, 0x20, 0x01, 0x84, 0x00,
  0x10, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x43, 0x00, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x00, 0x10, 0x80, 0x02, 0x00, 0x18, 0x40, 0x03, 0x00, 0x0C, 0x60,
  0x01, 0x80, 0x04, 0x30, 0x00, 0x80, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x11,
  0xEF, 0x01, 0x18, 0x0C, 0x09, 0x00, 0x20, 0x50, 0x01, 0x03, 0x80, 0x0C,
  0x38, 0x00, 0x61, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x04, 0x30, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40,
  0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x0F, 0x78,
  0x01, 0x80, 0xC0, 0x60, 0x06, 0x04, 0x00, 0x20, 0x80, 0x03, 0x18, 0x00,
  0x11, 0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xC4,
  0x00, 0x08, 0x40, 0x01, 0x06, 0x00, 0x30, 0x30, 0x06, 0x01, 0x81, 0xC0,
  0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x8F, 0x78, 0x01,
  0x18, 0x0C, 0x01, 0x30, 0x04, 0x01, 0x60, 0x06, 0x01, 0xC0, 0x02, 0x03,
  0x80, 0x02, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x08,
  0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x1C, 0x00, 0x10, 0x14,
  0x00, 0x30, 0x14, 0x00, 0x60, 0x16, 0x00, 0xC0, 0x33, 0x03, 0x80, 0x31,
  0xFE, 0x00, 0x20, 0x30, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x04, 0x03, 0xDE, 0x20, 0x38, 0x0C, 0x81, 0x80,
  0x12, 0x04, 0x00, 0x28, 0x20, 0x00, 0xE1, 0x80, 0x03, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x08, 0x40,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00,
  0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83,
  0x00, 0x0E, 0x04, 0x00, 0x68, 0x10, 0x03, 0x20, 0x60, 0x19, 0x80, 0xC0,
  0xC4, 0x01, 0xFE, 0x10, 0x00, 0x80, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0x81, 0x1E, 0x81, 0x18, 0x00, 0x90, 0x00, 0x58,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFB, 0xF0, 0x60, 0x08, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x80, 0x0C, 0x30, 0x06, 0x07, 0xFE,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x07, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x7E, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x82,
  0x00, 0x04, 0x10, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x82, 0x00, 0x04, 0x10, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x10, 0x40,
  0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x10,
  0x40, 0x00, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00,
  0x30, 0x60, 0x02, 0x83, 0x00, 0x34, 0x08, 0x03, 0x20, 0x60, 0x72, 0x01,
  0xFE, 0x10, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xD0,
  0x00, 0x48, 0x00, 0x64, 0x00, 0x23, 0x00, 0x31, 0x80, 0x10, 0x40, 0x18,
  0x20, 0x08, 0x10, 0x0C, 0x08, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x03,
  0x00, 0x81, 0x00, 0x61, 0x80, 0x30, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x02,
  0x40, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x68,
  0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x01, 0x20, 0x08, 0x80, 0x22,
  0x01, 0x88, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20,
  0xC0, 0xC2, 0x02, 0x0C, 0x08, 0x20, 0x60, 0xC1, 0x82, 0x04, 0x0C, 0x10,
  0x20, 0xC0, 0xC3, 0x02, 0x08, 0x0C, 0x20, 0x21, 0x80, 0xC6, 0x03, 0x10,
  0x04, 0x40, 0x31, 0x00, 0x4C, 0x03, 0x20, 0x04, 0x80, 0x12, 0x00, 0x58,
  0x01, 0x60, 0x05, 0x00, 0x14, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x03, 0x00, 0x0E, 0x02,
  0x00, 0x10, 0x06, 0x00, 0x40, 0x04, 0x01, 0x80, 0x08, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x10, 0x20, 0x00, 0x20, 0x80, 0x00, 0x63, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x66, 0x00, 0x00, 0x84, 0x00, 0x02, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00, 0x80, 0x01,
  0x00, 0x30, 0x00, 0x20, 0x04, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x70, 0x1C, 0x0D, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 36, 10, 1, -36 },
  { 46, 11, 13, 15, 5, -36 },
  { 64, 26, 36, 26, 1, -36 },
  { 181, 22, 41, 24, 1, -38 },
  { 294, 27, 37, 34, 4, -36 },
  { 419, 25, 37, 28, 1, -36 },
  { 535, 4, 13, 8, 5, -36 },
  { 542, 14, 44, 12, 1, -36 },
  { 619, 14, 44, 12, -3, -36 },
  { 696, 18, 18, 23, 6, -38 },
  { 737, 21, 23, 25, 3, -29 },
  { 798, 6, 11, 9, -2, -5 },
  { 807, 11, 1, 15, 2, -14 },
  { 809, 3, 3, 9, 1, -3 },
  { 811, 21, 36, 15, -2, -36 },
  { 906, 21, 37, 24, 2, -36 },
  { 1004, 11, 36, 24, 7, -36 },
  { 1054, 22, 36, 24, 0, -36 },
  { 1153, 23, 37, 24, 0, -36 },
  { 1260, 22, 36, 24, 0, -36 },
  { 1359, 22, 37, 24, 1, -36 },
  { 1461, 21, 37, 24, 3, -36 },
  { 1559, 21, 36, 24, 4, -36 },
  { 1654, 22, 37, 24, 1, -36 },
  { 1756, 22, 37, 24, 1, -36 },
  { 1858, 8, 27, 9, 1, -27 },
  { 1885, 11, 33, 10, -2, -27 },
  { 1931, 21, 22, 25, 3, -29 },
  { 1989, 21, 11, 25, 3, -23 },
  { 2018, 21, 22, 25, 3, -29 },
  { 2076, 16, 36, 17, 3, -36 },
  { 2148, 33, 41, 36, 2, -36 },
  { 2318, 24, 36, 23, -3, -36 },
  { 2426, 23, 36, 26, 2, -36 },
  { 2530, 25, 37, 25, 3, -36 },
  { 2646, 25, 36, 29, 2, -36 },
  { 2759, 23, 36, 23, 2, -36 },
  { 2863, 23, 36, 21, 2, -36 },
  { 2967, 27, 37, 30, 3, -36 },
  { 3092, 28, 36, 30, 2, -36 },
  { 3218, 15, 36, 12, -1, -36 },
  { 3286, 19, 45, 10, -8, -36 },
  { 3393, 26, 36, 24, 2, -36 },
  { 3510, 15, 36, 21, 2, -36 },
  { 3578, 34, 36, 36, 2, -36 },
  { 3731, 28, 36, 30, 2, -36 },
  { 3857, 26, 37, 31, 3, -36 },
  { 3978, 22, 36, 24, 2, -36 },
  { 4077, 26, 45, 31, 3, -36 },
  { 4224, 22, 36, 24, 2, -36 },
  { 4323, 23, 37, 22, 0, -36 },
  { 4430, 21, 36, 21, 4, -36 },
  { 4525, 27, 37, 30, 3, -36 },
  { 4650, 22, 36, 23, 5, -36 },
  { 4749, 36, 36, 37, 5, -36 },
  { 4911, 28, 36, 21, -3, -36 },
  { 5037, 20, 36, 21, 5, -36 },
  { 5127, 26, 36, 23, -1, -36 },
  { 5244, 19, 44, 15, -1, -36 },
  { 5349, 7, 36, 16, 5, -36 },
  { 5381, 18, 44, 15, -3, -36 },
  { 5480, 21, 20, 25, 2, -36 },
  { 5533, 17, 1, 17, -4, 5 },
  { 5536, 6, 8, 11, 7, -38 },
  { 5542, 21, 28, 24, 2, -27 },
  { 5616, 22, 39, 25, 1, -38 },
  { 5724, 18, 28, 19, 2, -27 },
  { 5787, 24, 39, 25, 2, -38 },
  { 5904, 18, 28, 22, 2, -27 },
  { 5967, 26, 50, 12, -7, -38 },
  { 6130, 24, 39, 25, 0, -27 },
  { 6247, 21, 38, 24, 1, -38 },
  { 6347, 9, 36, 9, 1, -36 },
  { 6388, 17, 48, 10, -7, -36 },
  { 6490, 20, 38, 19, 1, -38 },
  { 6585, 9, 38, 9, 1, -38 },
  { 6628, 33, 27, 37, 1, -27 },
  { 6740, 21, 27, 24, 1, -27 },
  { 6811, 20, 28, 24, 2, -27 },
  { 6881, 24, 39, 25, -1, -27 },
  { 6998, 22, 39, 25, 2, -27 },
  { 7106, 17, 27, 16, 1, -27 },
  { 7164, 18, 28, 18, 0, -27 },
  { 7227, 12, 34, 13, 2, -33 },
  { 7278, 21, 27, 24, 2, -26 },
  { 7349, 17, 26, 18, 3, -26 },
  { 7405, 28, 26, 29, 3, -26 },
  { 7496, 23, 26, 20, -2, -26 },
  { 7571, 27, 38, 18, -6, -26 },
  { 7700, 20, 26, 18, -1, -26 },
  { 7765, 18, 44, 16, 1, -36 },
  { 7864, 1, 50, 23, 12, -38 },
  { 7871, 18, 44, 16, -3, -36 },
  { 7970, 21, 5, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC50PT7B_H_
