#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x21, 0x90, 0x88, 0x44, 0x24, 0x12,
  0x11, 0x08, 0x84, 0x42, 0x41, 0x21, 0x00, 0x00, 0x20, 0x60, 0x02, 0x04,
  0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x80,
  0x80, 0x08, 0x10, 0x00, 0x81, 0x01, 0xFF, 0xFF, 0x01, 0x03, 0x00, 0x10,
  0x20, 0x01, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04,
  0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x0F, 0xFF, 0xFC, 0x08, 0x08, 0x00,
  0x81, 0x00, 0x08, 0x10, 0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00,
  0x30, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x00, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x1F, 0xC0, 0x31, 0x18, 0x30, 0x80, 0x30, 0x40, 0x10,
  0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x08, 0x00, 0xC4, 0x00,
  0x32, 0x00, 0x0D, 0x00, 0x01, 0x80, 0x00, 0xB0, 0x00, 0x4C, 0x00, 0x23,
  0x00, 0x10, 0x80, 0x08, 0x60, 0x08, 0x10, 0x04, 0x18, 0x02, 0x08, 0x01,
  0x04, 0x01, 0x04, 0x30, 0x8C, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x07, 0x00, 0x08, 0x62, 0x00, 0x41, 0x04, 0x02,
  0x08, 0x10, 0x08, 0x20, 0x40, 0x41, 0x01, 0x03, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x40, 0x80, 0x43, 0x02, 0x01, 0x08, 0x08, 0x08, 0x40, 0x20, 0x23,
  0x00, 0x80, 0x88, 0xFA, 0x04, 0x44, 0x38, 0x11, 0x20, 0x60, 0x88, 0x81,
  0x44, 0x44, 0x04, 0xE1, 0x10, 0x10, 0x08, 0x40, 0x40, 0x42, 0x01, 0x01,
  0x08, 0x0C, 0x08, 0x20, 0x20, 0x60, 0x80, 0x81, 0x02, 0x02, 0x08, 0x08,
  0x10, 0x60, 0x20, 0x41, 0x00, 0x82, 0x08, 0x02, 0x18, 0x60, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x0C, 0x20, 0x01, 0x01, 0x00, 0x10, 0x10, 0x02, 0x01,
  0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x02, 0x00, 0x20,
  0x60, 0x03, 0x0C, 0x00, 0x11, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x03,
  0x40, 0x00, 0xC4, 0x00, 0x18, 0x20, 0x33, 0x02, 0x02, 0x20, 0x10, 0x24,
  0x01, 0x04, 0xC0, 0x08, 0x48, 0x00, 0xC8, 0x80, 0x05, 0x08, 0x00, 0x70,
  0x80, 0x02, 0x08, 0x00, 0x50, 0x40, 0x19, 0x06, 0x03, 0x08, 0x3F, 0xC0,
  0xC0, 0x24, 0x94, 0x92, 0x52, 0x00, 0x00, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x20, 0x40, 0x61, 0x00, 0x48, 0x00, 0xEF, 0xC0, 0xC0, 0x05, 0x00,
  0x64, 0x03, 0x08, 0x10, 0x20, 0x40, 0x40, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x08, 0x46, 0x23, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0x86, 0x02, 0x02, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x10, 0xC0, 0x30, 0x40, 0x20, 0x20, 0xC0, 0x1F, 0x80, 0x01, 0x03, 0x0D,
  0x19, 0x21, 0xC2, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x00, 0x7E, 0x00, 0x60, 0xC0, 0x20, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x70,
  0x60, 0x60, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC3, 0x00, 0x60, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0A, 0x00,
  0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x44, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x0C, 0x10, 0x02, 0x04, 0x01, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20,
  0x30, 0x08, 0x08, 0x06, 0x04, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x40,
  0x04, 0x3F, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xC0, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x17,
  0xE0, 0x06, 0x06, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x82, 0x01, 0x80, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x40, 0x60, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x08, 0x04, 0x7F, 0x82, 0x40, 0x61, 0x40, 0x10, 0xC0, 0x0C,
  0x40, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x04,
  0x0C, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20,
  0x18, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x02,
  0x0C, 0x00, 0x81, 0x00, 0x40, 0x40, 0x30, 0x08, 0x18, 0x01, 0x18, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x18, 0x40, 0x18, 0x08, 0x0C, 0x01, 0x06, 0x00,
  0x61, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x02, 0x30, 0x01, 0x04, 0x00, 0xC0, 0x80, 0x60, 0x1F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xC3, 0x00, 0x80, 0x40, 0x80, 0x20, 0x80, 0x08, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x0C, 0x30, 0x0A, 0x0C, 0x19,
  0x01, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x0F,
  0xF0, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xC1, 0xC3, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0x20, 0x0C, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x30, 0x0F, 0xE0, 0x48, 0x0C, 0x08, 0x12, 0x06, 0x06, 0x05,
  0x01, 0x01, 0x01, 0x40, 0x80, 0x40, 0xD0, 0x20, 0x10, 0x28, 0x10, 0x08,
  0x0A, 0x04, 0x02, 0x02, 0x81, 0x00, 0x80, 0xA0, 0xC0, 0x60, 0x48, 0x20,
  0x18, 0x12, 0x08, 0x0C, 0x08, 0x83, 0x03, 0x02, 0x20, 0x41, 0x21, 0x08,
  0x1D, 0x8D, 0x82, 0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x79, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x02, 0x40, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00,
  0x80, 0x80, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x80, 0xFF,
  0xE0, 0x40, 0x08, 0x10, 0x03, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x03, 0xF8, 0x00, 0x40, 0xF0, 0x08, 0x03, 0x01, 0x00, 0x30,
  0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21,
  0x80, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x40, 0x80, 0x30, 0x1F, 0xFC, 0x04,
  0x1F, 0x00, 0x80, 0x18, 0x10, 0x01, 0x02, 0x00, 0x10, 0x40, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x23, 0x00, 0x08, 0x40,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x0C, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x1C, 0x0C, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x02, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x10,
  0x78, 0x00, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x60, 0x02, 0x02, 0x00, 0x08,
  0x10, 0x00, 0x40, 0x80, 0x03, 0x04, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00,
  0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x40, 0x00, 0x62,
  0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x40, 0x00,
  0x42, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x40,
  0x03, 0x02, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x03,
  0x80, 0x60, 0x02, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03,
  0xFC, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88,
  0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x00,
  0x82, 0x00, 0x08, 0x08, 0x00, 0x40, 0x30, 0x06, 0x00, 0xFF, 0xC0, 0x00,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x60, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x80, 0x80,
  0x01, 0x01, 0xFF, 0xFE, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x06,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0x20, 0x40, 0x00, 0x40,
  0x80, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x08, 0x00,
  0x03, 0xF0, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x08, 0xC0, 0x3E, 0x00, 0x02,
  0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x60, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x18, 0x00, 0x81, 0x80, 0x04, 0x18, 0x00, 0x41,
  0x80, 0x02, 0x18, 0x00, 0x11, 0x80, 0x00, 0x98, 0x00, 0x05, 0xC0, 0x00,
  0x4B, 0x00, 0x02, 0x88, 0x00, 0x18, 0x40, 0x00, 0x81, 0x00, 0x04, 0x08,
  0x00, 0x40, 0x60, 0x02, 0x01, 0x00, 0x10, 0x08, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x0C, 0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x50, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0xA0, 0x48, 0x00,
  0x0A, 0x04, 0x80, 0x01, 0x20, 0x48, 0x00, 0x12, 0x04, 0x80, 0x02, 0x40,
  0xC8, 0x00, 0x64, 0x08, 0x80, 0x04, 0x40, 0x88, 0x00, 0x84, 0x08, 0x80,
  0x08, 0xC0, 0x84, 0x01, 0x08, 0x10, 0x40, 0x10, 0x81, 0x04, 0x02, 0x08,
  0x10, 0x40, 0x20, 0x81, 0x04, 0x04, 0x18, 0x10, 0x40, 0xC1, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x61, 0x01, 0x02, 0x02, 0x10, 0x10, 0x20, 0x22, 0x02,
  0x06, 0x02, 0x20, 0x20, 0x40, 0x24, 0x02, 0x04, 0x02, 0x40, 0x20, 0x40,
  0x28, 0x02, 0x04, 0x03, 0x80, 0x40, 0x80, 0x10, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x20, 0x68, 0x00,
  0x40, 0x90, 0x00, 0x81, 0x20, 0x01, 0x02, 0x20, 0x04, 0x04, 0x40, 0x08,
  0x18, 0x80, 0x10, 0x20, 0x80, 0x20, 0x41, 0x00, 0xC0, 0x82, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x30, 0x20,
  0x10, 0x40, 0x40, 0x20, 0x81, 0x00, 0x21, 0x02, 0x00, 0x42, 0x04, 0x00,
  0x88, 0x08, 0x00, 0x90, 0x30, 0x01, 0x20, 0x40, 0x03, 0x40, 0x80, 0x02,
  0x81, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x00, 0x00, 0x7E,
  0x00, 0x18, 0x18, 0x02, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x31, 0x80,
  0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0xC0, 0x01,
  0x04, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x41, 0xE0, 0x08, 0x06, 0x01, 0x00, 0x60, 0x60, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0x41, 0x80, 0x08, 0x20,
  0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x10, 0x02, 0x04, 0x00, 0x80, 0x80,
  0xE0, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18,
  0x18, 0x02, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x31, 0x80, 0x01, 0x10,
  0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0xC0, 0x01, 0x04, 0x00,
  0x30, 0x60, 0x06, 0x03, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x03, 0xF0, 0x00, 0x87, 0xC0, 0x20, 0x18, 0x08, 0x03, 0x06,
  0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x43, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x60,
  0x7F, 0xE0, 0x10, 0x20, 0x04, 0x0C, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x02, 0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x0C, 0x10, 0x01,
  0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x70,
  0x30, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x82, 0x00, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x21, 0x00,
  0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x20, 0x00, 0x21,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00,
  0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC6, 0x00, 0x04, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x30, 0x10, 0x03, 0x00, 0xC0,
  0x30, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A,
  0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0x40,
  0x0C, 0x10, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40, 0x40, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x10, 0x20, 0x04, 0x18, 0x01,
  0x04, 0x00, 0x43, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x2C,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60,
  0x02, 0x40, 0x0A, 0x00, 0x64, 0x00, 0xA0, 0x04, 0x40, 0x12, 0x00, 0x44,
  0x01, 0x20, 0x08, 0x40, 0x22, 0x00, 0x84, 0x02, 0x20, 0x10, 0x40, 0x62,
  0x01, 0x04, 0x04, 0x20, 0x30, 0x40, 0x42, 0x02, 0x04, 0x08, 0x20, 0x20,
  0x40, 0x82, 0x04, 0x04, 0x10, 0x20, 0x40, 0x41, 0x02, 0x08, 0x04, 0x20,
  0x20, 0x80, 0x42, 0x01, 0x18, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10,
  0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x10,
  0x01, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x08, 0x08,
  0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x02, 0x60, 0x00,
  0x09, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x58, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0x42, 0x00,
  0x02, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x08, 0x06, 0x00, 0x20, 0x10, 0x00, 0x40, 0x80, 0x01,
  0x00, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x10, 0x40, 0x30, 0x60, 0x20, 0x20, 0x40, 0x20, 0xC0, 0x20,
  0x80, 0x21, 0x00, 0x13, 0x00, 0x12, 0x00, 0x14, 0x00, 0x14, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0F, 0xE0, 0x00, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x40, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x04, 0x00, 0xFE, 0x02, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x50, 0x00, 0x90, 0x01, 0x90, 0x01, 0x08, 0x02, 0x08,
  0x06, 0x08, 0x04, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xFF, 0xF8, 0x88, 0x44,
  0x21, 0x10, 0x03, 0xF9, 0x04, 0x09, 0x08, 0x05, 0x10, 0x05, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18,
  0x80, 0x28, 0xC0, 0x50, 0x40, 0x90, 0x3F, 0x10, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x7F, 0x02, 0x40, 0xC1, 0x40, 0x20, 0xC0, 0x08,
  0xE0, 0x04, 0x60, 0x02, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x04, 0x60,
  0x02, 0x30, 0x03, 0x18, 0x01, 0x14, 0x01, 0x09, 0x03, 0x04, 0x7F, 0x00,
  0x03, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x08, 0x1F,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x7F,
  0x10, 0x10, 0x16, 0x04, 0x02, 0x81, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00,
  0xC2, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x60, 0x80, 0x1C,
  0x10, 0x03, 0x02, 0x00, 0xA0, 0x60, 0x34, 0x04, 0x0C, 0x80, 0x7E, 0x10,
  0x00, 0x03, 0xF8, 0x18, 0x30, 0x80, 0x44, 0x01, 0x30, 0x04, 0x80, 0x14,
  0x00, 0x90, 0x06, 0x40, 0x33, 0x07, 0x0F, 0xC0, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x08,
  0x1F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x3B, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x0B, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x20,
  0x20, 0x24, 0x08, 0x05, 0x02, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x84,
  0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x38, 0x20,
  0x06, 0x04, 0x01, 0x40, 0xC0, 0x68, 0x08, 0x19, 0x00, 0xFC, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x08, 0x02, 0x00, 0xF7, 0x80, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0xFE, 0x09, 0x03, 0x0A, 0x01, 0x0C,
  0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x02,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x02, 0x60, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x03, 0x08, 0x04, 0x08, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x27, 0x00,
  0x25, 0x00, 0x29, 0x80, 0x30, 0x80, 0x60, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x20, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x02, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x00, 0x08, 0xFC, 0x1F, 0x82, 0xC1, 0x98, 0x30, 0xA0, 0x2C, 0x04, 0x30,
  0x0A, 0x01, 0x18, 0x03, 0x00, 0x46, 0x00, 0xC0, 0x11, 0x00, 0x20, 0x04,
  0x40, 0x08, 0x01, 0x10, 0x02, 0x00, 0x48, 0x01, 0x00, 0x22, 0x00, 0x40,
  0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00, 0x98, 0x01, 0x00, 0x24, 0x00,
  0x80, 0x11, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01, 0x10, 0x02, 0x00, 0x48,
  0x01, 0x80, 0x32, 0x00, 0x40, 0x08, 0x80, 0x10, 0x02, 0x00, 0x08, 0xFE,
  0x09, 0x03, 0x0A, 0x01, 0x0C, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x60, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x03, 0xF8, 0x04, 0x04, 0x08, 0x02, 0x10, 0x02,
  0x20, 0x03, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x18, 0x40, 0x10, 0x60, 0x60, 0x3F, 0xC0, 0x02, 0x3F,
  0x80, 0x4C, 0x18, 0x0A, 0x01, 0x01, 0x80, 0x10, 0x50, 0x02, 0x0C, 0x00,
  0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x04,
  0x18, 0x01, 0x83, 0x00, 0x20, 0xA0, 0x08, 0x12, 0x06, 0x02, 0x3F, 0x80,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x82, 0x02, 0x42, 0x01, 0x42, 0x00, 0x62, 0x00, 0x31, 0x00, 0x19, 0x00,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x62, 0x00, 0x31, 0x00, 0x38, 0x80, 0x18, 0x40, 0x1C,
  0x30, 0x1A, 0x08, 0x19, 0x03, 0xF1, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x08, 0xF8, 0x48, 0x02, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xFC, 0x30, 0x11, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x20, 0x10,
  0x7F, 0x80, 0x08, 0x04, 0x02, 0x03, 0x01, 0x07, 0xFC, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x00, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x0C, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x30, 0x80, 0x50, 0xC0, 0x90,
  0x7F, 0x10, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x40, 0x11, 0x00,
  0x84, 0x02, 0x10, 0x10, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x41,
  0x01, 0x08, 0x02, 0x60, 0x09, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x10, 0x07, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x34,
  0x02, 0x80, 0x48, 0x05, 0x00, 0x90, 0x12, 0x02, 0x10, 0x24, 0x04, 0x20,
  0x88, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x81, 0x08, 0x21, 0x02, 0x10,
  0x46, 0x04, 0x40, 0x88, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x24, 0x04,
  0x80, 0x50, 0x0A, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x40, 0x40, 0x20, 0x08,
  0x18, 0x02, 0x04, 0x00, 0xC2, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x00, 0xA0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x88, 0x00,
  0x42, 0x00, 0x20, 0x80, 0x10, 0x10, 0x0C, 0x04, 0x06, 0x01, 0x01, 0x00,
  0x20, 0x80, 0x08, 0x00, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x04, 0x00,
  0x20, 0x10, 0x00, 0x80, 0x80, 0x01, 0x02, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x60, 0x00, 0x05, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x02,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF0,
  0x00, 0x04, 0x00, 0xE0, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x03, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x07, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xF0, 0x03, 0x80, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x30,
  0xC0, 0x60, 0x1D, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 29, 8, 1, -29 },
  { 30, 9, 11, 12, 4, -29 },
  { 43, 20, 29, 21, 1, -29 },
  { 116, 17, 32, 19, 1, -30 },
  { 184, 22, 29, 27, 3, -29 },
  { 264, 20, 29, 22, 1, -29 },
  { 337, 3, 11, 6, 4, -29 },
  { 342, 11, 35, 10, 1, -29 },
  { 391, 11, 35, 10, -3, -29 },
  { 440, 14, 14, 18, 5, -30 },
  { 465, 17, 18, 20, 2, -23 },
  { 504, 5, 9, 7, -2, -4 },
  { 510, 9, 1, 12, 1, -11 },
  { 512, 2, 2, 8, 1, -2 },
  { 513, 17, 29, 12, -2, -29 },
  { 575, 16, 29, 19, 2, -29 },
  { 633, 8, 29, 19, 6, -29 },
  { 662, 18, 29, 19, 0, -29 },
  { 728, 18, 29, 19, 0, -29 },
  { 794, 18, 29, 19, 0, -29 },
  { 860, 18, 29, 19, 1, -29 },
  { 926, 17, 29, 19, 2, -29 },
  { 988, 17, 29, 19, 3, -29 },
  { 1050, 18, 29, 19, 1, -29 },
  { 1116, 17, 29, 19, 1, -29 },
  { 1178, 6, 21, 8, 1, -21 },
  { 1194, 9, 26, 8, -2, -21 },
  { 1224, 17, 17, 20, 2, -23 },
  { 1261, 17, 10, 20, 2, -19 },
  { 1283, 17, 17, 20, 2, -23 },
  { 1320, 13, 29, 14, 2, -29 },
  { 1368, 26, 32, 29, 2, -28 },
  { 1472, 18, 29, 19, -2, -29 },
  { 1538, 19, 29, 21, 1, -29 },
  { 1607, 19, 29, 20, 3, -29 },
  { 1676, 21, 29, 23, 1, -29 },
  { 1753, 19, 29, 19, 1, -29 },
  { 1822, 19, 29, 17, 1, -29 },
  { 1891, 21, 29, 24, 3, -29 },
  { 1968, 23, 29, 24, 1, -29 },
  { 2052, 12, 29, 9, -1, -29 },
  { 2096, 14, 36, 8, -6, -29 },
  { 2159, 21, 29, 19, 1, -29 },
  { 2236, 13, 29, 17, 1, -29 },
  { 2284, 28, 29, 29, 1, -29 },
  { 2386, 23, 29, 24, 1, -29 },
  { 2470, 20, 29, 25, 3, -29 },
  { 2543, 19, 29, 19, 1, -29 },
  { 2612, 20, 36, 25, 3, -29 },
  { 2702, 18, 29, 19, 1, -29 },
  { 2768, 18, 29, 18, 0, -29 },
  { 2834, 16, 29, 17, 4, -29 },
  { 2892, 21, 29, 24, 3, -29 },
  { 2969, 18, 29, 19, 4, -29 },
  { 3035, 28, 29, 30, 4, -29 },
  { 3137, 22, 29, 17, -2, -29 },
  { 3217, 16, 29, 17, 4, -29 },
  { 3275, 21, 29, 18, -1, -29 },
  { 3352, 14, 35, 12, 0, -29 },
  { 3414, 6, 29, 12, 4, -29 },
  { 3436, 15, 35, 12, -3, -29 },
  { 3502, 16, 17, 20, 2, -29 },
  { 3536, 13, 1, 13, -3, 4 },
  { 3538, 4, 7, 9, 6, -31 },
  { 3542, 16, 21, 19, 2, -21 },
  { 3584, 17, 30, 20, 1, -30 },
  { 3648, 14, 21, 15, 2, -21 },
  { 3685, 19, 30, 20, 2, -30 },
  { 3757, 14, 21, 17, 2, -21 },
  { 3794, 20, 41, 9, -5, -31 },
  { 3897, 19, 31, 20, 0, -21 },
  { 3971, 16, 30, 19, 1, -30 },
  { 4031, 7, 29, 8, 1, -29 },
  { 4057, 14, 39, 8, -6, -29 },
  { 4126, 16, 30, 15, 1, -30 },
  { 4186, 7, 30, 7, 1, -30 },
  { 4213, 26, 21, 29, 1, -21 },
  { 4282, 16, 21, 19, 1, -21 },
  { 4324, 16, 21, 20, 2, -21 },
  { 4366, 19, 30, 20, -1, -21 },
  { 4438, 17, 30, 20, 2, -21 },
  { 4502, 13, 21, 13, 1, -21 },
  { 4537, 14, 21, 15, 0, -21 },
  { 4574, 9, 26, 10, 2, -26 },
  { 4604, 16, 21, 19, 2, -21 },
  { 4646, 14, 21, 14, 2, -21 },
  { 4683, 23, 21, 23, 2, -21 },
  { 4744, 18, 21, 16, -1, -21 },
  { 4792, 22, 31, 15, -5, -21 },
  { 4878, 16, 21, 14, -1, -21 },
  { 4920, 14, 35, 13, 1, -29 },
  { 4982, 1, 40, 19, 9, -30 },
  { 4987, 14, 35, 13, -2, -29 },
  { 5049, 17, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC40PT7B_H_
