#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x70, 0x30, 0x00, 0x30, 0x4C, 0x12, 0x0C, 0x83, 0x20, 0x88,
  0x26, 0x09, 0x06, 0x41, 0x10, 0x44, 0x12, 0x04, 0x82, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x60, 0x30, 0x00,
  0x20, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xF0,
  0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0x80,
  0x00, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x10,
  0x00, 0x10, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x04, 0x01, 0xFF, 0xFF,
  0xF8, 0x06, 0x03, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80,
  0x40, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x20, 0x00, 0x20, 0x10, 0x00, 0x30,
  0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x03,
  0xFE, 0x00, 0x71, 0x1C, 0x06, 0x18, 0x20, 0x60, 0x80, 0x06, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00, 0x40, 0x80, 0x02, 0x04,
  0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x86,
  0x00, 0x04, 0x10, 0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x10, 0x00,
  0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x10, 0x20,
  0x80, 0x86, 0x03, 0xF7, 0xE0, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x01,
  0x81, 0x84, 0x00, 0x20, 0x60, 0xC0, 0x0C, 0x18, 0x08, 0x03, 0x02, 0x01,
  0x00, 0x40, 0xC0, 0x20, 0x18, 0x10, 0x04, 0x02, 0x02, 0x00, 0x80, 0x80,
  0xC0, 0x10, 0x30, 0x18, 0x06, 0x04, 0x02, 0x00, 0xC1, 0x00, 0x40, 0x10,
  0x60, 0x08, 0x02, 0x08, 0x01, 0x00, 0x42, 0x00, 0x20, 0x18, 0xC7, 0xE4,
  0x02, 0x11, 0x86, 0x80, 0xC4, 0x60, 0x50, 0x11, 0x88, 0x0A, 0x06, 0x23,
  0x01, 0xE1, 0x8C, 0x40, 0x37, 0xE3, 0x08, 0x06, 0x00, 0x43, 0x00, 0x80,
  0x18, 0x40, 0x10, 0x06, 0x08, 0x02, 0x00, 0x83, 0x00, 0x40, 0x30, 0x60,
  0x08, 0x04, 0x08, 0x03, 0x01, 0x01, 0x00, 0x40, 0x60, 0x20, 0x08, 0x08,
  0x04, 0x03, 0x02, 0x00, 0x80, 0x40, 0xC0, 0x10, 0x18, 0x10, 0x03, 0x02,
  0x04, 0x00, 0x20, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x10, 0x00, 0x80, 0x10, 0x00, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x30, 0x01, 0x80, 0x20, 0x00, 0x80, 0x60, 0x00,
  0x80, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0x43, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0x90, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x08, 0x01, 0x18, 0x0C, 0x01, 0x10, 0x04, 0x02, 0x20, 0x02, 0x02, 0x60,
  0x03, 0x04, 0x40, 0x01, 0x04, 0x40, 0x01, 0x88, 0xC0, 0x00, 0x98, 0xC0,
  0x00, 0xD0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x40,
  0x01, 0x10, 0x60, 0x06, 0x10, 0x30, 0x0C, 0x08, 0x1F, 0xF0, 0x0C, 0x33,
  0x22, 0x22, 0x64, 0x44, 0x48, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x0C, 0x04, 0x03, 0x04, 0x00, 0x62, 0x00, 0x09,
  0x01, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0xA0, 0x00, 0x88, 0x00, 0x84, 0x01,
  0x81, 0x01, 0x80, 0x80, 0x80, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x30, 0x86,
  0x18, 0x43, 0x08, 0x61, 0x08, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xF8, 0x00,
  0xE0, 0x40, 0x18, 0x02, 0x01, 0x00, 0x30, 0x20, 0x01, 0x06, 0x00, 0x10,
  0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00,
  0x16, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x64, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0,
  0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x84, 0x00, 0x10, 0x40, 0x02, 0x04,
  0x00, 0x60, 0x60, 0x04, 0x02, 0x00, 0x80, 0x18, 0x30, 0x00, 0xFE, 0x00,
  0x00, 0x60, 0x38, 0x0D, 0x07, 0x21, 0x8C, 0x61, 0xB0, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x20, 0x08,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x03,
  0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00,
  0x83, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x04, 0x02,
  0x00, 0x20, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x00, 0x60, 0x04, 0x01,
  0x00, 0x10, 0x08, 0x00, 0xC0, 0x60, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x40, 0x01, 0x83, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFC, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x9F,
  0x80, 0x03, 0xE7, 0x80, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x80, 0x06, 0x03, 0x00, 0x70, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x3F, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x3F, 0xC0, 0x23, 0x01, 0x81, 0x60, 0x04, 0x0E, 0x00, 0x10, 0xE0,
  0x00, 0x86, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x88, 0x00, 0x0C,
  0x40, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x41, 0x00, 0x06, 0x0C, 0x00, 0x20, 0x20, 0x02, 0x01,
  0x80, 0x30, 0x06, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x40, 0x02, 0x03,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00,
  0x0C, 0x08, 0x00, 0x20, 0x20, 0x01, 0x80, 0xC0, 0x04, 0x01, 0x00, 0x20,
  0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x19, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xB0, 0x00, 0x38, 0x60, 0x03, 0x80, 0xC0, 0x18, 0x01, 0x80, 0xC0, 0x03,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x04, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x18, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x20,
  0x20, 0x01, 0x83, 0x00, 0x04, 0x10, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00,
  0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88,
  0x00, 0x0C, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0x40, 0x02,
  0x83, 0x00, 0x34, 0x0C, 0x06, 0x60, 0x3F, 0xE2, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x04, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x0C, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xC1, 0x80, 0x00, 0x40, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x70, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03,
  0x08, 0x00, 0xFC, 0x03, 0x18, 0x03, 0x87, 0x01, 0x10, 0x06, 0x02, 0x01,
  0x30, 0x0C, 0x02, 0x01, 0x20, 0x18, 0x02, 0x01, 0x20, 0x10, 0x06, 0x03,
  0x60, 0x30, 0x04, 0x03, 0x40, 0x20, 0x04, 0x03, 0x40, 0x60, 0x0C, 0x02,
  0x40, 0x40, 0x0C, 0x02, 0xC0, 0x40, 0x08, 0x06, 0xC0, 0xC0, 0x08, 0x04,
  0xC0, 0xC0, 0x18, 0x04, 0xC0, 0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x30, 0x08,
  0xC0, 0xC0, 0x30, 0x18, 0xC0, 0x40, 0x58, 0x30, 0xC0, 0x60, 0xC8, 0x60,
  0xC0, 0x3F, 0x0F, 0xC0, 0x40, 0x0C, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x03, 0x01,
  0x00, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x10,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xC0, 0x30, 0x00, 0x80,
  0x40, 0x01, 0x01, 0x80, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x10,
  0x00, 0x10, 0x60, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x02, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x08, 0x01, 0xFF, 0xC0, 0x02, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x20, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60,
  0xC0, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x1C, 0x04, 0x00, 0xE0, 0x0F,
  0xFE, 0x00, 0x30, 0x0F, 0x00, 0x40, 0x03, 0x00, 0x80, 0x03, 0x01, 0x00,
  0x03, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x21, 0x80, 0x00, 0x43, 0x00, 0x01, 0x84, 0x00, 0x02,
  0x08, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x80, 0x03, 0x01,
  0x00, 0x38, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x38, 0x03,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x80, 0xF0, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00, 0x10, 0x08, 0x00,
  0x0C, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x08, 0x00, 0x02, 0x04, 0x00, 0x03, 0x02, 0x00, 0x03,
  0x01, 0x00, 0x03, 0x01, 0x80, 0x07, 0x00, 0x80, 0x0E, 0x00, 0x40, 0x3C,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0E,
  0x00, 0xF0, 0x06, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xF3, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x08, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x60, 0x18, 0x00, 0x10, 0x03, 0x80, 0x1C, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10,
  0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0x03, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x04, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x80, 0x80,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x20, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x02,
  0x01, 0x80, 0x01, 0x01, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x41, 0x80, 0x00, 0x21, 0x80, 0x00, 0x11, 0x80, 0x00, 0x19, 0x60, 0x00,
  0x0D, 0x10, 0x00, 0x05, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x0C,
  0x00, 0x10, 0x02, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x18, 0x01, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x80,
  0x00, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x30, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x03, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0A, 0x02, 0x80, 0x00, 0x07,
  0x80, 0xB0, 0x00, 0x01, 0x60, 0x2C, 0x00, 0x00, 0x90, 0x19, 0x00, 0x00,
  0x64, 0x06, 0x40, 0x00, 0x11, 0x01, 0x10, 0x00, 0x0C, 0xC0, 0x44, 0x00,
  0x02, 0x20, 0x11, 0x00, 0x01, 0x88, 0x0C, 0x60, 0x00, 0x42, 0x02, 0x18,
  0x00, 0x31, 0x80, 0x82, 0x00, 0x08, 0x60, 0x20, 0x80, 0x04, 0x10, 0x18,
  0x20, 0x03, 0x04, 0x06, 0x08, 0x00, 0x81, 0x01, 0x02, 0x00, 0x60, 0xC0,
  0x40, 0x80, 0x10, 0x30, 0x10, 0x30, 0x0C, 0x08, 0x0C, 0x0C, 0x02, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x10, 0x20,
  0x10, 0x08, 0x04, 0x18, 0x04, 0x06, 0x01, 0x04, 0x01, 0x01, 0x00, 0x43,
  0x00, 0x40, 0x40, 0x18, 0x80, 0x30, 0x10, 0x06, 0x60, 0x08, 0x04, 0x00,
  0x90, 0x02, 0x03, 0x00, 0x2C, 0x00, 0x80, 0x80, 0x0A, 0x00, 0x60, 0x20,
  0x03, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x04, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x2C, 0x00,
  0x04, 0x04, 0x80, 0x00, 0x80, 0x90, 0x00, 0x10, 0x33, 0x00, 0x06, 0x06,
  0x20, 0x00, 0xC0, 0x84, 0x00, 0x10, 0x10, 0xC0, 0x02, 0x02, 0x08, 0x00,
  0x40, 0xC1, 0x00, 0x18, 0x10, 0x30, 0x02, 0x02, 0x02, 0x00, 0x40, 0x40,
  0x40, 0x08, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x80, 0x60, 0x40, 0x10, 0x08,
  0x08, 0x03, 0x01, 0x01, 0x00, 0x20, 0x20, 0x60, 0x06, 0x0C, 0x0C, 0x00,
  0xC1, 0x81, 0x00, 0x08, 0x20, 0x20, 0x01, 0x84, 0x04, 0x00, 0x30, 0x81,
  0x80, 0x02, 0x30, 0x20, 0x00, 0x64, 0x04, 0x00, 0x0C, 0x80, 0x80, 0x00,
  0x90, 0x10, 0x00, 0x1A, 0x06, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x30, 0x10,
  0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x18, 0x10, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x38,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x04, 0x07, 0x80, 0x30, 0x03,
  0x00, 0xC0, 0x06, 0x02, 0x00, 0x08, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x80, 0x01, 0x06, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00,
  0x03, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x02, 0x00, 0x0C,
  0x08, 0x00, 0x60, 0x60, 0x03, 0x01, 0x00, 0x70, 0x07, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0x40, 0x60, 0x00, 0x18, 0x10, 0x00, 0x02, 0x08, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x04, 0x07, 0x80, 0x30, 0x03,
  0x00, 0xC0, 0x06, 0x02, 0x00, 0x08, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x80, 0x01, 0x06, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x00,
  0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0x80, 0x03, 0x02, 0x00, 0x08,
  0x08, 0x00, 0xC0, 0x60, 0x0E, 0x01, 0xFF, 0xE0, 0x04, 0x02, 0x00, 0x10,
  0x08, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x18, 0x06, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x03, 0x01,
  0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0x80, 0x01, 0x82, 0x00,
  0x02, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0x80, 0x30, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x38, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04,
  0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x10, 0x60, 0x00, 0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x10, 0x00,
  0x03, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01,
  0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00, 0x06, 0x04,
  0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x00, 0x18, 0x04, 0x00,
  0x40, 0x10, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x04, 0x01, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x20, 0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x08,
  0x30, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0,
  0x00, 0x22, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x0B, 0x00, 0x03, 0x00, 0x03, 0x60, 0x00,
  0xE0, 0x00, 0x4C, 0x00, 0x14, 0x00, 0x18, 0x80, 0x02, 0x80, 0x02, 0x10,
  0x00, 0x90, 0x00, 0xC2, 0x00, 0x12, 0x00, 0x10, 0x40, 0x06, 0x40, 0x02,
  0x08, 0x00, 0x8C, 0x00, 0xC1, 0x00, 0x31, 0x80, 0x10, 0x20, 0x04, 0x30,
  0x06, 0x04, 0x01, 0x86, 0x00, 0x80, 0x80, 0x20, 0xC0, 0x30, 0x10, 0x0C,
  0x18, 0x04, 0x02, 0x01, 0x03, 0x00, 0x80, 0x40, 0x20, 0x20, 0x20, 0x08,
  0x0C, 0x04, 0x04, 0x01, 0x01, 0x00, 0x81, 0x80, 0x20, 0x60, 0x10, 0x20,
  0x04, 0x08, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08,
  0x20, 0x02, 0x18, 0x01, 0x08, 0x00, 0x42, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x04, 0x60, 0x01, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x13, 0x00, 0x04,
  0xC0, 0x02, 0x40, 0x00, 0x90, 0x00, 0x48, 0x00, 0x16, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x08,
  0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x30,
  0x00, 0x60, 0x04, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x10,
  0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x01, 0x00, 0x01, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x30, 0x0C, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x90,
  0x00, 0x08, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x04,
  0x04, 0x00, 0x60, 0x30, 0x02, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0x20,
  0x10, 0x01, 0x81, 0x80, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00,
  0x0C, 0xC0, 0x00, 0x64, 0x00, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x10,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x81,
  0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20,
  0x40, 0x81, 0x02, 0x06, 0x04, 0x08, 0x00, 0x7F, 0xC0, 0x20, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x80, 0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x30, 0x80, 0x01,
  0x04, 0x00, 0x10, 0x30, 0x01, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x30,
  0x0C, 0x00, 0x80, 0x40, 0x04, 0x06, 0x00, 0x20, 0x60, 0x01, 0x82, 0x00,
  0x04, 0x30, 0x00, 0x23, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80, 0x00, 0x30,
  0xFF, 0xFF, 0xC2, 0x18, 0x41, 0x0C, 0x20, 0x00, 0xFE, 0x10, 0x18, 0x11,
  0x03, 0x00, 0x90, 0x40, 0x0D, 0x0C, 0x00, 0x71, 0x80, 0x06, 0x10, 0x00,
  0x63, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x44, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x80,
  0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x50, 0x40, 0x09, 0x06, 0x01, 0xB0, 0x30, 0x62, 0x01, 0xFC, 0x20,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x3F, 0x80, 0x67, 0x06, 0x02, 0x60,
  0x18, 0x16, 0x00, 0x40, 0xE0, 0x03, 0x0E, 0x00, 0x08, 0x70, 0x00, 0x43,
  0x00, 0x02, 0x18, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x60, 0x00,
  0x22, 0x00, 0x03, 0x10, 0x00, 0x18, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x40,
  0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80, 0x01, 0x0E, 0x00, 0x18,
  0x50, 0x00, 0x82, 0x80, 0x0C, 0x16, 0x00, 0xC1, 0x98, 0x1C, 0x08, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x20, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0x08, 0x01, 0x81, 0x88, 0x03, 0x00, 0xD8, 0x04, 0x00, 0x50, 0x0C, 0x00,
  0x70, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00,
  0x20, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x80, 0x00,
  0xC0, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x03, 0x80, 0xC0, 0x02,
  0x80, 0xC0, 0x07, 0x80, 0x40, 0x0D, 0x00, 0x60, 0x19, 0x00, 0x30, 0x31,
  0x00, 0x1F, 0xC1, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x60, 0x30, 0x08, 0x18,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x02, 0x20, 0x01,
  0x88, 0x00, 0xC6, 0x00, 0x61, 0x00, 0xE0, 0x7F, 0xE0, 0x1C, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC2, 0x00, 0xC0, 0xC4,
  0x03, 0x00, 0xC8, 0x08, 0x00, 0xA0, 0x30, 0x01, 0xC0, 0xC0, 0x01, 0x81,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60,
  0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x02, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x80, 0x01,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x0A, 0x06, 0x00, 0x3C, 0x04, 0x00, 0xD0,
  0x0C, 0x03, 0x20, 0x0C, 0x0C, 0x40, 0x0F, 0xE1, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x06, 0x00,
  0xC0, 0x07, 0xDF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x21, 0xFC, 0x06, 0x70, 0x60, 0x4C, 0x03, 0x05, 0x80, 0x10, 0x70, 0x01,
  0x0E, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00,
  0x31, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00,
  0x06, 0x30, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x60,
  0x00, 0x86, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x8C,
  0x00, 0x10, 0xC0, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x06, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x03, 0x06, 0x00, 0x60, 0x40, 0x0C,
  0x04, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x18,
  0x00, 0x83, 0x00, 0x08, 0x60, 0x01, 0x8C, 0x00, 0x11, 0xC0, 0x01, 0x34,
  0x00, 0x16, 0x40, 0x01, 0xC6, 0x00, 0x38, 0x20, 0x03, 0x03, 0x00, 0x20,
  0x30, 0x02, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x40, 0x08, 0x04,
  0x00, 0xC0, 0x40, 0x04, 0x0C, 0x00, 0x60, 0x80, 0x02, 0x00, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x18, 0x08, 0x00, 0x06, 0x3F, 0x80, 0xFC, 0x02, 0x30, 0x61, 0x83,
  0x01, 0x20, 0x11, 0x80, 0xC0, 0xA0, 0x0D, 0x80, 0x20, 0x70, 0x03, 0x80,
  0x10, 0x70, 0x01, 0x80, 0x0C, 0x30, 0x00, 0xC0, 0x04, 0x18, 0x00, 0x40,
  0x02, 0x08, 0x00, 0x60, 0x01, 0x04, 0x00, 0x20, 0x00, 0x86, 0x00, 0x10,
  0x00, 0xC2, 0x00, 0x08, 0x00, 0x41, 0x00, 0x04, 0x00, 0x20, 0x80, 0x06,
  0x00, 0x10, 0x40, 0x02, 0x00, 0x08, 0x60, 0x01, 0x00, 0x0C, 0x20, 0x00,
  0x80, 0x04, 0x10, 0x00, 0xC0, 0x02, 0x08, 0x00, 0x40, 0x01, 0x0C, 0x00,
  0x20, 0x01, 0x86, 0x00, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x00, 0x41, 0x00,
  0x0C, 0x00, 0x20, 0x80, 0x04, 0x00, 0x10, 0xC0, 0x02, 0x00, 0x18, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x06, 0x1F, 0xC0, 0x47, 0x06, 0x04, 0xC0, 0x30,
  0x58, 0x01, 0x07, 0x00, 0x10, 0xE0, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00,
  0x21, 0x00, 0x06, 0x10, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x04, 0x20, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x00, 0x7F, 0x00,
  0x18, 0x18, 0x03, 0x00, 0x40, 0x60, 0x06, 0x0C, 0x00, 0x21, 0x80, 0x02,
  0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00,
  0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0,
  0x01, 0x84, 0x00, 0x10, 0x60, 0x02, 0x02, 0x00, 0x60, 0x38, 0x18, 0x00,
  0xFF, 0x00, 0x01, 0x87, 0xF0, 0x02, 0x38, 0x30, 0x04, 0xC0, 0x30, 0x0B,
  0x00, 0x20, 0x14, 0x00, 0x60, 0x70, 0x00, 0x40, 0xE0, 0x00, 0x81, 0x80,
  0x01, 0x03, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0xC1,
  0x80, 0x03, 0x02, 0x80, 0x04, 0x05, 0x00, 0x18, 0x0B, 0x00, 0x60, 0x33,
  0x03, 0x80, 0x63, 0xFC, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x08, 0x0C, 0x0C, 0x40, 0xC0, 0x32, 0x08, 0x00, 0xA0,
  0xC0, 0x07, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00,
  0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x60,
  0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0x80, 0x00, 0xC4, 0x00, 0x0C,
  0x20, 0x00, 0x61, 0x00, 0x07, 0x0C, 0x00, 0x28, 0x60, 0x03, 0xC1, 0x00,
  0x34, 0x0C, 0x03, 0x20, 0x30, 0x31, 0x00, 0xFE, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x1F, 0x04, 0x60, 0x04, 0xC0, 0x05, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x01, 0x80, 0xC1,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x30,
  0x3F, 0xF0, 0x00, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x7F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x07, 0xE0, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80,
  0x03, 0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x10,
  0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0xC6,
  0x00, 0x08, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x18,
  0xC0, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x07, 0x08, 0x00, 0x50, 0xC0, 0x0B,
  0x04, 0x01, 0x20, 0x60, 0x62, 0x03, 0xFC, 0x20, 0x80, 0x01, 0xC0, 0x00,
  0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x80,
  0x10, 0xC0, 0x18, 0x20, 0x08, 0x10, 0x0C, 0x08, 0x04, 0x04, 0x06, 0x02,
  0x02, 0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x31, 0x80, 0x18, 0x80,
  0x04, 0xC0, 0x02, 0x40, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x40, 0x0E, 0x00, 0x68, 0x01, 0x40, 0x09, 0x00, 0x28, 0x01,
  0x20, 0x09, 0x80, 0x44, 0x01, 0x30, 0x08, 0x80, 0x42, 0x03, 0x10, 0x08,
  0x40, 0x42, 0x02, 0x08, 0x18, 0x40, 0x41, 0x02, 0x08, 0x10, 0x20, 0xC1,
  0x82, 0x04, 0x10, 0x30, 0x80, 0x82, 0x06, 0x10, 0x10, 0x80, 0xC6, 0x02,
  0x10, 0x18, 0x80, 0x46, 0x03, 0x30, 0x08, 0x80, 0x24, 0x01, 0x30, 0x05,
  0x80, 0x24, 0x00, 0xA0, 0x05, 0x80, 0x1C, 0x00, 0xA0, 0x03, 0x00, 0x14,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0x00, 0x0C, 0x04,
  0x00, 0x20, 0x10, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x60, 0x02, 0x01,
  0x00, 0x0C, 0x08, 0x00, 0x10, 0x40, 0x00, 0x63, 0x00, 0x00, 0x98, 0x00,
  0x02, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x80, 0x00, 0x32, 0x00, 0x00, 0x8C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40,
  0x01, 0x81, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x10, 0x0C,
  0x00, 0x40, 0x60, 0x01, 0x83, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x30, 0x06, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x20,
  0x04, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00,
  0x30, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x1C, 0x0E, 0x01, 0x80,
  0x3E, 0xE0, 0x00, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 35, 10, 1, -35 },
  { 41, 10, 13, 14, 5, -35 },
  { 58, 25, 35, 26, 1, -35 },
  { 168, 21, 40, 23, 1, -37 },
  { 273, 27, 36, 33, 4, -35 },
  { 395, 24, 36, 27, 1, -36 },
  { 503, 4, 13, 8, 5, -35 },
  { 510, 14, 43, 12, 1, -35 },
  { 586, 13, 43, 12, -3, -35 },
  { 656, 17, 18, 22, 6, -37 },
  { 695, 20, 23, 25, 3, -29 },
  { 753, 6, 11, 8, -2, -5 },
  { 762, 11, 1, 14, 2, -14 },
  { 764, 3, 3, 9, 1, -3 },
  { 766, 21, 35, 15, -2, -35 },
  { 858, 20, 36, 23, 2, -36 },
  { 948, 11, 35, 23, 7, -35 },
  { 997, 22, 35, 23, 0, -35 },
  { 1094, 23, 35, 23, 0, -35 },
  { 1195, 22, 35, 23, 0, -35 },
  { 1292, 22, 35, 23, 1, -35 },
  { 1389, 21, 36, 23, 2, -36 },
  { 1484, 20, 35, 23, 4, -35 },
  { 1572, 22, 35, 23, 1, -35 },
  { 1669, 21, 35, 23, 1, -35 },
  { 1761, 7, 26, 9, 1, -26 },
  { 1784, 10, 32, 9, -2, -26 },
  { 1824, 20, 21, 25, 3, -28 },
  { 1877, 20, 11, 25, 3, -23 },
  { 1905, 20, 21, 25, 3, -28 },
  { 1958, 15, 35, 17, 3, -35 },
  { 2024, 32, 39, 35, 2, -35 },
  { 2180, 23, 35, 23, -3, -35 },
  { 2281, 23, 35, 25, 2, -35 },
  { 2382, 24, 35, 25, 3, -35 },
  { 2487, 25, 35, 28, 2, -35 },
  { 2597, 22, 35, 23, 2, -35 },
  { 2694, 22, 35, 21, 2, -35 },
  { 2791, 26, 35, 30, 3, -35 },
  { 2905, 27, 35, 29, 2, -35 },
  { 3024, 15, 35, 12, -1, -35 },
  { 3090, 18, 43, 10, -8, -35 },
  { 3187, 25, 35, 23, 2, -35 },
  { 3297, 15, 35, 21, 2, -35 },
  { 3363, 34, 35, 36, 2, -35 },
  { 3512, 27, 35, 29, 2, -35 },
  { 3631, 26, 36, 30, 3, -36 },
  { 3748, 22, 35, 24, 2, -35 },
  { 3845, 26, 44, 30, 3, -36 },
  { 3988, 22, 35, 24, 2, -35 },
  { 4085, 22, 35, 22, 0, -35 },
  { 4182, 21, 35, 20, 4, -35 },
  { 4274, 26, 35, 29, 3, -35 },
  { 4388, 22, 35, 23, 5, -35 },
  { 4485, 35, 35, 36, 5, -35 },
  { 4639, 27, 35, 21, -3, -35 },
  { 4758, 21, 35, 20, 4, -35 },
  { 4850, 25, 35, 22, -1, -35 },
  { 4960, 19, 43, 14, -1, -35 },
  { 5063, 7, 35, 15, 5, -35 },
  { 5094, 18, 43, 14, -3, -35 },
  { 5191, 21, 20, 24, 2, -35 },
  { 5244, 16, 1, 16, -4, 5 },
  { 5246, 5, 7, 11, 7, -37 },
  { 5251, 20, 26, 24, 2, -26 },
  { 5316, 21, 37, 24, 1, -37 },
  { 5414, 18, 26, 19, 2, -26 },
  { 5473, 24, 37, 24, 2, -37 },
  { 5584, 18, 26, 21, 2, -26 },
  { 5643, 24, 49, 12, -6, -37 },
  { 5790, 23, 38, 24, 0, -26 },
  { 5900, 20, 37, 24, 1, -37 },
  { 5993, 9, 35, 9, 1, -35 },
  { 6033, 17, 47, 9, -7, -35 },
  { 6133, 20, 37, 19, 1, -37 },
  { 6226, 9, 37, 9, 1, -37 },
  { 6268, 33, 26, 36, 1, -26 },
  { 6376, 20, 26, 24, 1, -26 },
  { 6441, 20, 26, 24, 2, -26 },
  { 6506, 23, 37, 24, -1, -26 },
  { 6613, 21, 37, 24, 2, -26 },
  { 6711, 16, 26, 16, 1, -26 },
  { 6763, 17, 26, 18, 0, -26 },
  { 6819, 12, 32, 13, 2, -32 },
  { 6867, 20, 26, 24, 2, -26 },
  { 6932, 17, 26, 18, 3, -26 },
  { 6988, 27, 26, 28, 3, -26 },
  { 7076, 22, 26, 19, -2, -26 },
  { 7148, 26, 38, 18, -6, -26 },
  { 7272, 19, 26, 18, -1, -26 },
  { 7334, 18, 43, 16, 1, -35 },
  { 7431, 1, 49, 23, 12, -37 },
  { 7438, 17, 43, 16, -3, -35 },
  { 7530, 20, 4, 25, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC49PT7B_H_
