#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x0E, 0x30,
  0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x0C, 0x06, 0x18, 0x0C,
  0x30, 0x18, 0x40, 0x20, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x10,
  0x08, 0x20, 0x10, 0xC0, 0x61, 0x80, 0x80, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x08, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xC4, 0x3F,
  0x00, 0x38, 0x10, 0x18, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0D, 0xE0, 0x00, 0x00,
  0x21, 0xC0, 0x00, 0x00, 0x83, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x40, 0xE0, 0x0F, 0x03,
  0x0F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x38, 0x38,
  0x00, 0x06, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x06, 0x00, 0x60, 0x00, 0x80,
  0x30, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0x03, 0x06, 0x07, 0xE3, 0x00, 0x18, 0x18, 0x3F, 0xCC, 0x00, 0x60, 0xC3,
  0x81, 0xB0, 0x01, 0x86, 0x0C, 0x06, 0xC0, 0x0C, 0x18, 0x60, 0x0F, 0x00,
  0x30, 0xC3, 0x00, 0x3C, 0x01, 0x86, 0x0C, 0x00, 0xD8, 0x0C, 0x18, 0x60,
  0x03, 0x70, 0x60, 0xC1, 0x80, 0x0C, 0xFF, 0x06, 0x04, 0x00, 0x30, 0xF0,
  0x18, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x07,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x40, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x10, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x18, 0x00, 0x03, 0x07, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC3, 0x80, 0x18, 0x00, 0x61, 0xC0,
  0x06, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x18, 0x03, 0x18,
  0x00, 0x06, 0x01, 0x86, 0x00, 0x00, 0xC0, 0x63, 0x00, 0x00, 0x30, 0x30,
  0xC0, 0x00, 0x06, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x0C, 0x00, 0x00, 0x33,
  0x03, 0x00, 0x00, 0x0D, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0D, 0x80, 0xC0, 0x00,
  0x06, 0x60, 0x18, 0x00, 0x03, 0x0C, 0x07, 0x00, 0x03, 0x83, 0x00, 0xE0,
  0x01, 0xC0, 0x60, 0x1E, 0x03, 0xC0, 0x18, 0x01, 0xFF, 0xC0, 0x03, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82,
  0x18, 0x61, 0x84, 0x10, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x08,
  0x00, 0xF0, 0x18, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x10, 0x00, 0x03, 0x10,
  0x03, 0x00, 0xD0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x06, 0x00, 0x60, 0x03, 0x00, 0x40, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xD0,
  0x07, 0x60, 0x38, 0xC0, 0xE1, 0x87, 0x02, 0x1C, 0x0C, 0xE0, 0x18, 0x80,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3E,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x37, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x40, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x02, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x01, 0xFE, 0x00,
  0x18, 0x7F, 0xFC, 0x00, 0x87, 0x00, 0x70, 0x0C, 0x60, 0x00, 0xC0, 0x6E,
  0x00, 0x03, 0x03, 0x60, 0x00, 0x18, 0x16, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x38, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xF0,
  0x30, 0x00, 0x0D, 0x81, 0xC0, 0x00, 0xCC, 0x07, 0x00, 0x1C, 0x40, 0x1C,
  0x03, 0xC6, 0x00, 0x7F, 0xF8, 0x30, 0x00, 0x7F, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x3C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x40,
  0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x78, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xE0, 0x0E,
  0x02, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x07, 0xF8, 0x00, 0x60, 0xC0,
  0x00, 0xFF, 0xF0, 0x03, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x18, 0x60, 0x01,
  0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x1C, 0x00, 0x40, 0x06, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x31, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x98, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0x46, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x60, 0x06, 0x00, 0x06, 0x00, 0x33, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x98, 0x01, 0x00, 0x03, 0x00, 0x0C, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x44,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x60, 0x06, 0x00, 0x06, 0x00, 0x33, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x98, 0x03, 0x00, 0x03, 0x00, 0x18, 0xC0, 0x18,
  0x00, 0x38, 0x00, 0xC6, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x30, 0x06, 0x00,
  0x1E, 0x00, 0x61, 0x80, 0x10, 0x00, 0xF0, 0x06, 0x0C, 0x00, 0xC0, 0x0D,
  0x80, 0x70, 0x60, 0x06, 0x00, 0xCC, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x60,
  0x70, 0x18, 0x00, 0xF1, 0xC1, 0xCF, 0x00, 0xC0, 0x03, 0xFC, 0x07, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02,
  0x0E, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0x01, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x78, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x0C, 0x00, 0x01, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x08, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x03, 0x1B, 0x00, 0x00, 0x00, 0x23, 0x30, 0x00, 0x00,
  0x06, 0x61, 0x80, 0x00, 0x00, 0x6C, 0x18, 0x00, 0x00, 0x07, 0x81, 0x80,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x64, 0x00, 0x00, 0x00, 0x66, 0x00, 0x64, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x46, 0x00, 0x00, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x82, 0x00, 0x00,
  0x06, 0x18, 0x01, 0x82, 0x00, 0x00, 0x06, 0x18, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x00, 0x18, 0x10, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x30, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x00,
  0x60, 0x20, 0x02, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x60,
  0x01, 0x00, 0x18, 0x00, 0x40, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x40, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x63, 0x00, 0x02, 0x00, 0x20, 0x00, 0x63, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x66, 0x00, 0x06, 0x00, 0x60, 0x00, 0x6C, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x2C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x02, 0xC0,
  0x00, 0x00, 0xC0, 0x0D, 0x80, 0x00, 0x01, 0x80, 0x19, 0x80, 0x00, 0x03,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x00, 0x66, 0x00, 0x00, 0x08, 0x00, 0x86,
  0x00, 0x00, 0x30, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x08, 0x00, 0x00,
  0xC0, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x18, 0x30, 0x00, 0x02, 0x00, 0x20,
  0x20, 0x00, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x80, 0x00, 0x60, 0x06, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x00, 0x80, 0x30, 0x03, 0x00, 0x01, 0x80, 0x60, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x30, 0x03, 0x00, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x00, 0x31, 0x80,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x80, 0x00, 0x01, 0xB0, 0x03, 0x00, 0x00, 0x03, 0x60,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x30, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0x43, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x42, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x46, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x46, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x58, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x58, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x50, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x87, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0xC0, 0x1E, 0x03, 0x84, 0x01, 0xC0, 0x06,
  0x60, 0x1C, 0x00, 0x33, 0x01, 0xC0, 0x00, 0xD8, 0x0C, 0x00, 0x06, 0x80,
  0xC0, 0x00, 0x14, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0B, 0x03, 0x00,
  0x00, 0xD0, 0x0C, 0x00, 0x0C, 0x80, 0x60, 0x00, 0xCC, 0x01, 0x80, 0x0C,
  0x60, 0x0E, 0x00, 0xC2, 0x00, 0x38, 0x1C, 0x10, 0x00, 0xFF, 0xC0, 0x80,
  0x00, 0xE0, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x1F, 0xC0, 0x01, 0x83, 0xFF, 0x80, 0x0C, 0x38, 0x0E, 0x00, 0x47, 0x00,
  0x38, 0x06, 0x70, 0x00, 0xE0, 0x37, 0x00, 0x03, 0x01, 0xB0, 0x00, 0x18,
  0x0B, 0x00, 0x00, 0x60, 0x78, 0x00, 0x03, 0x07, 0x80, 0x00, 0x18, 0x38,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x01, 0x81, 0x60, 0x00, 0x18, 0x19, 0x80, 0x01, 0x80, 0xCC, 0x00,
  0x18, 0x06, 0x30, 0x01, 0x80, 0x20, 0xE0, 0x78, 0x01, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0E, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x08, 0x01, 0xE0, 0x3C, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x18, 0x00, 0x1F,
  0xFE, 0x08, 0x00, 0x3C, 0x03, 0x8C, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x38,
  0x00, 0x33, 0x00, 0x38, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x06, 0x80, 0x18,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03,
  0xC0, 0x18, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x01, 0xA0, 0x06, 0x00, 0x01,
  0xD0, 0x01, 0x80, 0x01, 0xD8, 0x00, 0xC0, 0x01, 0xCC, 0x00, 0x30, 0x01,
  0xC6, 0x00, 0x1C, 0x01, 0xC2, 0x00, 0x07, 0x83, 0xC1, 0x00, 0x01, 0xFF,
  0x81, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x40, 0x00, 0xE0, 0x60, 0x01, 0xE0,
  0x30, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x01, 0xE0, 0x3E, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x43,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x01, 0x00, 0x07, 0xFF, 0x82, 0x00, 0x1E, 0x01,
  0xC2, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x70, 0x00, 0x66, 0x00, 0xE0, 0x00,
  0x36, 0x00, 0xC0, 0x00, 0x34, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x06,
  0x80, 0x30, 0x00, 0x0E, 0x80, 0x18, 0x00, 0x1D, 0x80, 0x18, 0x00, 0x39,
  0x80, 0x0C, 0x00, 0x71, 0x80, 0x0E, 0x00, 0xE1, 0x00, 0x07, 0x03, 0xC3,
  0x00, 0x03, 0xFF, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x0F, 0xE0, 0x01, 0x83, 0xFF,
  0x80, 0x18, 0xF0, 0x1C, 0x01, 0x1C, 0x00, 0x60, 0x33, 0x80, 0x06, 0x03,
  0x60, 0x00, 0x30, 0x36, 0x00, 0x03, 0x02, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x83, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x30, 0x04, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x10, 0x03, 0x80,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x08, 0x78, 0x00, 0x03, 0x19, 0x80, 0x00, 0x66, 0x30,
  0x00, 0x0D, 0x86, 0x00, 0x01, 0x60, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0C,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x43, 0x80, 0xE0, 0x70, 0x1C, 0x02, 0x30,
  0x03, 0x0E, 0x00, 0x60, 0x33, 0x00, 0x0C, 0xE0, 0x01, 0x81, 0xB0, 0x00,
  0x66, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x60, 0x50, 0x00, 0x1E,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x18, 0x3F, 0xF8, 0x01, 0x0F, 0x01, 0xC0, 0x11, 0xC0, 0x06,
  0x03, 0x30, 0x00, 0x60, 0x36, 0x00, 0x03, 0x03, 0x40, 0x00, 0x30, 0x2C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0C, 0x1F, 0xFC, 0x00, 0x04, 0x1C, 0x07, 0x00, 0x02, 0x38,
  0x00, 0xC0, 0x03, 0x38, 0x00, 0x70, 0x01, 0x98, 0x00, 0x18, 0x00, 0xD8,
  0x00, 0x0C, 0x00, 0x58, 0x00, 0x03, 0x00, 0x2C, 0x00, 0x01, 0x80, 0x3C,
  0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x00, 0xC0, 0x0B, 0x00, 0x00, 0xC0, 0x04, 0x80, 0x00,
  0xE0, 0x06, 0x60, 0x00, 0xE0, 0x03, 0x18, 0x01, 0xC0, 0x01, 0x87, 0x03,
  0xC0, 0x00, 0xC1, 0xFF, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x04, 0x00, 0x7F, 0xF8, 0x20, 0x07, 0x80, 0x70, 0x80,
  0x38, 0x00, 0xE6, 0x01, 0xC0, 0x01, 0x98, 0x0E, 0x00, 0x03, 0x60, 0x30,
  0x00, 0x0D, 0x01, 0x80, 0x00, 0x14, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0F,
  0x03, 0x00, 0x00, 0x68, 0x0C, 0x00, 0x03, 0xA0, 0x18, 0x00, 0x1D, 0x80,
  0x60, 0x00, 0x66, 0x00, 0xC0, 0x07, 0x18, 0x03, 0x80, 0x38, 0x40, 0x07,
  0x83, 0xC3, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x06, 0x0F,
  0xF0, 0x10, 0xE0, 0x00, 0x47, 0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x38, 0x01, 0xE0, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x1F, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x40, 0x7F, 0xC0, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x14, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x6C, 0x0C, 0x00, 0x0C, 0xC0,
  0x60, 0x01, 0x88, 0x07, 0x00, 0x30, 0x80, 0x38, 0x1E, 0x18, 0x01, 0xFF,
  0x81, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00,
  0x30, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x11, 0x80, 0x00, 0x13, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x12, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80,
  0x00, 0x60, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x80,
  0x00, 0xCC, 0x00, 0x0D, 0x00, 0x01, 0x18, 0x00, 0x1B, 0x00, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x08, 0x60, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x06,
  0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x83,
  0x00, 0x20, 0x10, 0x06, 0x06, 0x00, 0xC0, 0x20, 0x0C, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x06, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x01, 0x00, 0x80,
  0x20, 0x30, 0x02, 0x03, 0x00, 0x40, 0x60, 0x04, 0x04, 0x00, 0x81, 0x80,
  0x08, 0x18, 0x01, 0x03, 0x00, 0x10, 0x20, 0x03, 0x04, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09, 0xE1, 0xE0, 0x00, 0xD8,
  0x03, 0xC0, 0x0F, 0x80, 0x07, 0xC1, 0xC8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 49, 14, 2, -49 },
  { 81, 15, 18, 20, 7, -49 },
  { 115, 35, 49, 36, 2, -49 },
  { 330, 30, 56, 33, 2, -52 },
  { 540, 38, 51, 47, 5, -50 },
  { 783, 34, 51, 38, 2, -50 },
  { 1000, 6, 18, 11, 7, -49 },
  { 1014, 19, 60, 17, 2, -49 },
  { 1157, 19, 60, 17, -4, -49 },
  { 1300, 24, 25, 31, 9, -52 },
  { 1375, 29, 32, 35, 4, -40 },
  { 1491, 9, 16, 12, -3, -7 },
  { 1509, 16, 2, 20, 2, -20 },
  { 1513, 3, 4, 13, 2, -4 },
  { 1515, 29, 49, 21, -3, -49 },
  { 1693, 29, 51, 33, 3, -50 },
  { 1878, 15, 49, 33, 10, -49 },
  { 1970, 31, 50, 33, 0, -50 },
  { 2164, 32, 51, 33, 0, -50 },
  { 2368, 31, 50, 33, 0, -50 },
  { 2562, 31, 50, 33, 1, -49 },
  { 2756, 29, 51, 33, 4, -50 },
  { 2941, 28, 49, 33, 6, -49 },
  { 3113, 30, 51, 33, 2, -50 },
  { 3305, 29, 51, 33, 2, -50 },
  { 3490, 11, 37, 13, 1, -37 },
  { 3541, 15, 46, 13, -3, -37 },
  { 3628, 29, 30, 35, 4, -40 },
  { 3737, 29, 16, 35, 4, -32 },
  { 3795, 29, 30, 35, 4, -40 },
  { 3904, 22, 50, 24, 4, -50 },
  { 4042, 45, 55, 49, 3, -49 },
  { 4352, 32, 49, 32, -4, -49 },
  { 4548, 33, 49, 36, 2, -49 },
  { 4751, 33, 51, 35, 5, -50 },
  { 4962, 36, 49, 40, 2, -49 },
  { 5183, 32, 49, 32, 2, -49 },
  { 5379, 32, 49, 29, 2, -49 },
  { 5575, 36, 51, 42, 5, -50 },
  { 5805, 39, 49, 41, 2, -49 },
  { 6044, 21, 49, 16, -1, -49 },
  { 6173, 26, 61, 14, -11, -49 },
  { 6372, 36, 49, 33, 2, -49 },
  { 6593, 22, 49, 29, 2, -49 },
  { 6728, 48, 49, 50, 2, -49 },
  { 7022, 39, 49, 41, 2, -49 },
  { 7261, 35, 51, 43, 5, -50 },
  { 7485, 32, 49, 33, 2, -49 },
  { 7681, 35, 62, 43, 5, -50 },
  { 7953, 32, 49, 34, 2, -49 },
  { 8149, 32, 51, 30, 0, -50 },
  { 8353, 29, 49, 29, 6, -49 },
  { 8531, 36, 50, 41, 5, -49 },
  { 8756, 30, 49, 32, 7, -49 },
  { 8940, 48, 49, 51, 8, -49 },
  { 9234, 38, 49, 29, -4, -49 },
  { 9467, 29, 49, 29, 6, -49 },
  { 9645, 35, 49, 31, -1, -49 },
  { 9860, 26, 60, 20, -1, -49 },
  { 10055, 10, 49, 21, 7, -49 },
  { 10117, 26, 60, 20, -5, -49 },
  { 10312, 29, 27, 34, 3, -49 },
  { 10410, 23, 2, 23, -6, 7 },
  { 10416, 7, 11, 15, 10, -53 },
  { 10426, 29, 38, 33, 3, -37 },
  { 10564, 29, 53, 34, 2, -52 },
  { 10757, 25, 38, 27, 3, -37 },
  { 10876, 33, 53, 34, 3, -52 },
  { 11095, 25, 38, 30, 3, -37 },
  { 11214, 35, 70, 16, -9, -53 },
  { 11521, 32, 54, 34, 1, -37 },
  { 11737, 28, 52, 33, 2, -52 },
  { 11919, 12, 50, 13, 2, -50 },
  { 11994, 24, 67, 13, -10, -50 },
  { 12195, 27, 52, 27, 2, -52 },
  { 12371, 12, 52, 13, 2, -52 },
  { 12449, 45, 37, 51, 2, -37 },
  { 12658, 28, 37, 33, 2, -37 },
  { 12788, 28, 38, 34, 3, -37 },
  { 12921, 33, 53, 34, -2, -37 },
  { 13140, 30, 53, 34, 3, -37 },
  { 13339, 22, 37, 22, 2, -37 },
  { 13441, 25, 38, 25, 0, -37 },
  { 13560, 16, 46, 18, 3, -45 },
  { 13652, 28, 37, 33, 3, -36 },
  { 13782, 24, 36, 25, 4, -36 },
  { 13890, 39, 36, 40, 4, -36 },
  { 14066, 32, 36, 27, -3, -36 },
  { 14210, 37, 53, 25, -8, -36 },
  { 14456, 27, 36, 25, -1, -36 },
  { 14578, 24, 60, 22, 2, -49 },
  { 14758, 2, 69, 32, 16, -52 },
  { 14776, 24, 60, 22, -4, -49 },
  { 14956, 29, 6, 35, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC69PT7B_H_
