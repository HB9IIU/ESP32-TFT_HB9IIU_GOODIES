#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x10, 0x31,
  0x03, 0x30, 0x23, 0x02, 0x30, 0x62, 0x06, 0x20, 0x46, 0x04, 0x60, 0x44,
  0x0C, 0x40, 0x84, 0x08, 0xC0, 0x88, 0x08, 0x81, 0x80, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x02, 0x04, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18,
  0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x71, 0x0F, 0x01, 0xC1, 0x01, 0x03, 0x01, 0x00, 0x02, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x06, 0x00, 0x04, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x10, 0x60, 0x00, 0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x10, 0x00, 0x20, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20, 0x10, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0, 0x80, 0x41,
  0x80, 0xE0, 0xCF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0C, 0x03, 0x1C, 0x00, 0x18, 0x06, 0x0C, 0x00,
  0x18, 0x0C, 0x04, 0x00, 0x30, 0x18, 0x06, 0x00, 0x20, 0x10, 0x06, 0x00,
  0x60, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x20, 0x06, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x60, 0x04, 0x02, 0x00, 0x40, 0x04, 0x06,
  0x00, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x0C, 0x18,
  0x00, 0xC0, 0x08, 0x30, 0x00, 0xC0, 0x08, 0x20, 0x78, 0xC0, 0x18, 0x61,
  0xFC, 0xC0, 0x10, 0xC3, 0x06, 0xC0, 0x30, 0x86, 0x02, 0xC0, 0x21, 0x8C,
  0x02, 0xC0, 0x61, 0x0C, 0x02, 0x60, 0xC3, 0x18, 0x03, 0x71, 0x86, 0x18,
  0x03, 0x3F, 0x04, 0x10, 0x03, 0x00, 0x0C, 0x30, 0x02, 0x00, 0x18, 0x30,
  0x02, 0x00, 0x10, 0x20, 0x02, 0x00, 0x30, 0x20, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x00, 0x40, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x04, 0x01, 0x80, 0x60,
  0x04, 0x01, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x06, 0x00, 0x40,
  0x18, 0x04, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x00, 0x60,
  0x60, 0x18, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x40, 0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x30,
  0x01, 0x0C, 0x01, 0x80, 0x31, 0x80, 0x18, 0x02, 0x30, 0x00, 0xC0, 0x62,
  0x00, 0x04, 0x04, 0x60, 0x00, 0x60, 0xC6, 0x00, 0x02, 0x08, 0x40, 0x00,
  0x31, 0x84, 0x00, 0x01, 0x30, 0xC0, 0x00, 0x1A, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x04, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x36, 0x06, 0x00,
  0x06, 0x30, 0x30, 0x01, 0xC1, 0x01, 0xC0, 0x70, 0x18, 0x0F, 0xFC, 0x00,
  0x80, 0x18, 0x00, 0x04, 0x11, 0x33, 0x32, 0x26, 0x64, 0x44, 0xC8, 0x80,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x0C, 0x02, 0x00, 0x70, 0x20, 0x01, 0x82, 0x00, 0x06, 0x40,
  0x10, 0x1C, 0x7F, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x20, 0x00, 0x63,
  0x00, 0x0C, 0x10, 0x01, 0x81, 0x80, 0x30, 0x08, 0x06, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x00, 0xFF, 0xF8, 0x6F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0x80, 0x60, 0x06,
  0x00, 0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00,
  0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x90, 0x00, 0x03,
  0x20, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x48, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x41, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x0F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x34, 0x03, 0x60, 0x63, 0x06,
  0x10, 0xE0, 0x9C, 0x04, 0x40, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0x83, 0x80, 0x07, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x0C, 0x03, 0xC0, 0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x20,
  0x00, 0x0C, 0x08, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x10, 0x00, 0x10, 0x04, 0x00, 0x08, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x04,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x7F, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x18, 0x03, 0x80, 0x3C, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0x01, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x21, 0xF7,
  0xC0, 0x23, 0x00, 0x60, 0x6C, 0x00, 0x30, 0x68, 0x00, 0x30, 0x50, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x20, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0x07, 0x80, 0x03, 0x00, 0x70, 0x01, 0x80, 0x04,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x0E, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x10, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x38, 0x00, 0xE0,
  0x18, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00,
  0x06, 0x18, 0x00, 0x0A, 0x08, 0x00, 0x1E, 0x0C, 0x00, 0x34, 0x06, 0x00,
  0xE4, 0x03, 0x83, 0x8C, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x70, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xC3, 0xC0, 0x80, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x80, 0x03, 0xF8, 0x01,
  0x18, 0x00, 0xFB, 0xE0, 0x11, 0x00, 0x18, 0x06, 0x01, 0x30, 0x03, 0x00,
  0x40, 0x13, 0x00, 0x60, 0x04, 0x01, 0x20, 0x0C, 0x00, 0xC0, 0x16, 0x00,
  0x80, 0x0C, 0x01, 0x60, 0x18, 0x00, 0x80, 0x14, 0x01, 0x00, 0x18, 0x03,
  0xC0, 0x30, 0x01, 0x80, 0x3C, 0x02, 0x00, 0x18, 0x03, 0xC0, 0x20, 0x01,
  0x00, 0x28, 0x06, 0x00, 0x30, 0x06, 0x80, 0x60, 0x03, 0x00, 0x68, 0x06,
  0x00, 0x30, 0x04, 0x80, 0x40, 0x06, 0x00, 0xC8, 0x04, 0x00, 0x60, 0x08,
  0x80, 0x60, 0x0E, 0x01, 0x88, 0x06, 0x01, 0xA0, 0x30, 0x80, 0x60, 0x12,
  0x03, 0x08, 0x03, 0x06, 0x30, 0xE0, 0x80, 0x1F, 0xC1, 0xF8, 0x0C, 0x00,
  0x70, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x02, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x18, 0x04, 0x00, 0x04, 0x01,
  0x00, 0x03, 0x00, 0x40, 0x01, 0x80, 0x10, 0x00, 0x60, 0x04, 0x00, 0x30,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x04, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x10, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x40, 0x00, 0xC0, 0x08, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20,
  0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0x80, 0x01, 0xC0, 0x10, 0x01, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0x30, 0x02, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x30, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x06, 0x01, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x1C, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x30, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x04, 0x00, 0x07, 0x00, 0x20, 0x00, 0x70, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x07, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0x8C, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x20, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x01, 0x00, 0x40, 0x00, 0x01, 0x00, 0x40, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x08, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x01,
  0x00, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01,
  0x1C, 0x00, 0x00, 0x19, 0xB0, 0x00, 0x00, 0xD8, 0x80, 0x00, 0x05, 0x86,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x20, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xA0, 0x00, 0x00, 0x1E, 0x00,
  0xA0, 0x00, 0x00, 0x16, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x01, 0xA0, 0x00,
  0x00, 0x24, 0x01, 0x30, 0x00, 0x00, 0x6C, 0x01, 0x30, 0x00, 0x00, 0x4C,
  0x01, 0x30, 0x00, 0x00, 0xCC, 0x03, 0x10, 0x00, 0x01, 0x88, 0x03, 0x10,
  0x00, 0x01, 0x88, 0x02, 0x10, 0x00, 0x03, 0x18, 0x02, 0x10, 0x00, 0x02,
  0x18, 0x06, 0x18, 0x00, 0x06, 0x10, 0x06, 0x18, 0x00, 0x04, 0x10, 0x06,
  0x18, 0x00, 0x0C, 0x10, 0x04, 0x18, 0x00, 0x08, 0x30, 0x04, 0x08, 0x00,
  0x18, 0x30, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x0C, 0x08, 0x00, 0x30, 0x20,
  0x0C, 0x08, 0x00, 0x60, 0x60, 0x08, 0x0C, 0x00, 0x40, 0x60, 0x08, 0x0C,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x06, 0x00, 0x80, 0x30, 0x06, 0x0C,
  0x00, 0x80, 0x20, 0x06, 0x08, 0x01, 0x80, 0x20, 0x06, 0x18, 0x01, 0x80,
  0x60, 0x02, 0x10, 0x01, 0x00, 0x60, 0x02, 0x30, 0x01, 0x00, 0x60, 0x02,
  0x20, 0x03, 0x00, 0x40, 0x02, 0x60, 0x03, 0x00, 0x40, 0x03, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x02, 0x00, 0xA0, 0x00, 0x02,
  0x01, 0xB0, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x06, 0x01, 0x10, 0x00, 0x06,
  0x01, 0x18, 0x00, 0x04, 0x01, 0x18, 0x00, 0x04, 0x03, 0x08, 0x00, 0x0C,
  0x03, 0x0C, 0x00, 0x0C, 0x02, 0x0C, 0x00, 0x0C, 0x02, 0x04, 0x00, 0x08,
  0x06, 0x06, 0x00, 0x08, 0x06, 0x06, 0x00, 0x18, 0x06, 0x02, 0x00, 0x18,
  0x04, 0x03, 0x00, 0x10, 0x04, 0x03, 0x00, 0x10, 0x0C, 0x01, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x08, 0x00, 0x80, 0x20,
  0x08, 0x00, 0xC0, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x18, 0x00, 0x40, 0x60,
  0x10, 0x00, 0x60, 0x60, 0x10, 0x00, 0x20, 0x40, 0x30, 0x00, 0x20, 0x40,
  0x30, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x10, 0xC0, 0x20, 0x00, 0x10, 0xC0,
  0x20, 0x00, 0x18, 0x80, 0x60, 0x00, 0x08, 0x80, 0x60, 0x00, 0x09, 0x80,
  0x60, 0x00, 0x0D, 0x80, 0x40, 0x00, 0x05, 0x00, 0x40, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0C, 0x00, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x3C, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0C,
  0x00, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01,
  0x00, 0x01, 0xC0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x70,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x40, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00,
  0x20, 0x00, 0x40, 0x18, 0x00, 0x10, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x81,
  0xF0, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x1C,
  0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x04, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01,
  0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x80,
  0x10, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x20,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08,
  0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x28,
  0x00, 0x04, 0xC0, 0x00, 0x68, 0x00, 0x0C, 0xC0, 0x00, 0x48, 0x00, 0x08,
  0xC0, 0x00, 0xC8, 0x00, 0x18, 0xC0, 0x00, 0xC8, 0x00, 0x18, 0xC0, 0x01,
  0x88, 0x00, 0x10, 0x40, 0x01, 0x88, 0x00, 0x30, 0x40, 0x01, 0x08, 0x00,
  0x20, 0x40, 0x03, 0x08, 0x00, 0x60, 0x40, 0x02, 0x08, 0x00, 0x40, 0x40,
  0x06, 0x08, 0x00, 0xC0, 0x40, 0x04, 0x08, 0x00, 0xC0, 0x40, 0x0C, 0x0C,
  0x00, 0x80, 0x40, 0x08, 0x0C, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x01, 0x00,
  0x40, 0x18, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x40, 0x30,
  0x0C, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x04, 0x00, 0x40, 0x60, 0x0C, 0x0C,
  0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x08, 0x00, 0x40,
  0x80, 0x0C, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x10, 0x00, 0x41, 0x80, 0x0C,
  0x30, 0x00, 0x43, 0x00, 0x0C, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x60, 0x00,
  0x42, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x04, 0x40, 0x00, 0x64, 0x00,
  0x04, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x05, 0x80,
  0x00, 0x78, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x20,
  0x00, 0x30, 0x20, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x10,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x04, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60,
  0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18,
  0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06,
  0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00, 0x30, 0x20, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x10, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01, 0x00, 0x18,
  0x03, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x02, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x83,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0xE0, 0x61, 0x01, 0x80,
  0x13, 0x03, 0x00, 0x1A, 0x06, 0x00, 0x0A, 0x04, 0x00, 0x0A, 0x0C, 0x00,
  0x0E, 0x08, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x40, 0x00,
  0x60, 0x40, 0x00, 0xE0, 0x40, 0x01, 0xA0, 0x60, 0x01, 0x60, 0x60, 0x02,
  0x60, 0x30, 0x0C, 0x40, 0x18, 0x18, 0x40, 0x0F, 0xF0, 0x40, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x3F, 0xC0, 0x0C, 0x70, 0x30,
  0x06, 0x60, 0x0C, 0x02, 0x60, 0x03, 0x01, 0x60, 0x01, 0x81, 0xE0, 0x00,
  0x40, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x40,
  0x00, 0x0C, 0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x83, 0x80, 0x00, 0x81,
  0xE0, 0x00, 0xC0, 0x90, 0x00, 0xC0, 0x4C, 0x00, 0xC0, 0x23, 0x81, 0xC0,
  0x30, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x01, 0xC0, 0x20, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x0F, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x03, 0x01,
  0x80, 0x03, 0xFE, 0x18, 0x00, 0xE0, 0x31, 0x80, 0x18, 0x01, 0x90, 0x03,
  0x00, 0x09, 0x00, 0x60, 0x00, 0xF0, 0x04, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x04, 0x00, 0x07, 0x00, 0x40, 0x00, 0xD0,
  0x04, 0x00, 0x0F, 0x00, 0x60, 0x01, 0xA0, 0x06, 0x00, 0x32, 0x00, 0x30,
  0x06, 0x20, 0x01, 0x81, 0xC2, 0x00, 0x0F, 0xF0, 0x60, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0xE0, 0x38, 0x02, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33,
  0x00, 0x02, 0x20, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x01, 0x84, 0x00, 0x70,
  0xC0, 0x3C, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x01, 0x01, 0xC0, 0x70, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x10, 0x07,
  0x01, 0x8C, 0x03, 0x00, 0x32, 0x01, 0x80, 0x04, 0x80, 0xC0, 0x01, 0xA0,
  0x20, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08,
  0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C,
  0x18, 0x00, 0x07, 0x06, 0x00, 0x03, 0x80, 0x80, 0x00, 0xE0, 0x20, 0x00,
  0x68, 0x08, 0x00, 0x1E, 0x03, 0x00, 0x0D, 0x00, 0xC0, 0x06, 0x40, 0x18,
  0x03, 0x10, 0x03, 0x03, 0x8C, 0x00, 0x7F, 0x83, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x07,
  0xF8, 0x03, 0x1C, 0x0C, 0x03, 0x30, 0x06, 0x02, 0x60, 0x02, 0x02, 0xC0,
  0x03, 0x07, 0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60, 0x00,
  0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x20, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0xC0, 0x03, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x03,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x23, 0xC0,
  0x00, 0x4D, 0x80, 0x01, 0xB1, 0x00, 0x03, 0xC3, 0x00, 0x07, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x80, 0x80, 0x01, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0x00, 0x04, 0x3F, 0xC0, 0x7F, 0xC0, 0x33, 0x81, 0x83,
  0x03, 0x80, 0x98, 0x02, 0x18, 0x06, 0x02, 0x40, 0x0C, 0xC0, 0x0C, 0x0A,
  0x00, 0x16, 0x00, 0x30, 0x78, 0x00, 0x50, 0x00, 0xC1, 0xC0, 0x01, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x00, 0x30, 0x40,
  0x00, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x30, 0x00, 0x20, 0x00, 0x60, 0x80, 0x00, 0x80, 0x01, 0x82, 0x00,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x10, 0x60, 0x00, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x80, 0x01, 0x06, 0x00, 0x04, 0x00, 0x04, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x40, 0x00, 0x40, 0x00, 0xC1, 0x00, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x0F, 0xF8, 0x03, 0x1C, 0x0C,
  0x02, 0x30, 0x06, 0x02, 0x60, 0x02, 0x02, 0xC0, 0x03, 0x07, 0x80, 0x03,
  0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x10, 0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x20, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00,
  0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x58, 0x00, 0x01, 0x60, 0x00, 0x05,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x63, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xE0, 0x38, 0x00, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08, 0x3F, 0xC0, 0x03,
  0x1C, 0x0C, 0x00, 0x46, 0x00, 0xC0, 0x09, 0x80, 0x0C, 0x01, 0x60, 0x01,
  0x80, 0x78, 0x00, 0x10, 0x0F, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x78, 0x00, 0x30, 0x09,
  0x00, 0x0C, 0x01, 0x30, 0x03, 0x00, 0x23, 0x81, 0xC0, 0x0C, 0x3F, 0xE0,
  0x01, 0x80, 0x40, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xF0, 0x40, 0x38, 0x0C, 0x60, 0x30, 0x03, 0x20, 0x30, 0x00,
  0x90, 0x30, 0x00, 0x68, 0x10, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x40,
  0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC0, 0x80, 0x00, 0xE0,
  0x40, 0x00, 0xD0, 0x20, 0x00, 0x78, 0x18, 0x00, 0x6C, 0x0C, 0x00, 0x64,
  0x03, 0x00, 0x62, 0x00, 0xC0, 0xE3, 0x00, 0x3F, 0xC1, 0x80, 0x02, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x21, 0xFC, 0x0C, 0x60, 0x01, 0x18,
  0x00, 0x26, 0x00, 0x05, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x03, 0x80,
  0x70, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x80, 0x06, 0x0E, 0x01, 0xC0, 0x3F, 0xF8, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x7F, 0xFC, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x21, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x0C,
  0x00, 0x02, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80,
  0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0xA0, 0x80, 0x03, 0xC1, 0x00, 0x0D,
  0x02, 0x00, 0x12, 0x06, 0x00, 0xC4, 0x06, 0x03, 0x08, 0x07, 0xFC, 0x30,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C,
  0x00, 0x04, 0xC0, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x10,
  0x40, 0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0x40, 0x60, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x03, 0x00, 0x20, 0x30, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x18, 0x00, 0x31,
  0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x02, 0x80, 0x06, 0xC0,
  0x02, 0x80, 0x04, 0xC0, 0x04, 0x80, 0x0C, 0x40, 0x04, 0x80, 0x08, 0x40,
  0x0C, 0x80, 0x18, 0x40, 0x08, 0x80, 0x10, 0x40, 0x18, 0xC0, 0x30, 0x40,
  0x10, 0xC0, 0x20, 0x40, 0x30, 0xC0, 0x60, 0x40, 0x20, 0xC0, 0x60, 0x40,
  0x60, 0xC0, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0x40, 0x80, 0x40,
  0x80, 0x41, 0x80, 0x41, 0x80, 0x41, 0x00, 0x41, 0x00, 0x43, 0x00, 0x43,
  0x00, 0x42, 0x00, 0x42, 0x00, 0x42, 0x00, 0x46, 0x00, 0x46, 0x00, 0x44,
  0x00, 0x44, 0x00, 0x6C, 0x00, 0x4C, 0x00, 0x68, 0x00, 0x48, 0x00, 0x78,
  0x00, 0x58, 0x00, 0x78, 0x00, 0x50, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x10, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x64, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x20, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x02,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x04, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x40, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x83, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x60, 0x38, 0x03, 0xC0, 0x0F, 0x0E,
  0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 12, 15, 17, 6, -41 },
  { 81, 30, 41, 30, 1, -41 },
  { 235, 24, 46, 27, 2, -43 },
  { 373, 32, 42, 38, 4, -41 },
  { 541, 28, 42, 31, 1, -41 },
  { 688, 4, 15, 9, 6, -41 },
  { 696, 15, 50, 14, 2, -41 },
  { 790, 16, 50, 14, -4, -41 },
  { 890, 20, 21, 26, 7, -43 },
  { 943, 24, 26, 29, 3, -33 },
  { 1021, 7, 13, 10, -2, -6 },
  { 1033, 13, 1, 17, 2, -16 },
  { 1035, 3, 3, 11, 1, -3 },
  { 1037, 25, 41, 17, -3, -41 },
  { 1166, 23, 42, 27, 3, -41 },
  { 1287, 13, 41, 27, 8, -41 },
  { 1354, 25, 41, 27, 0, -41 },
  { 1483, 26, 42, 27, 0, -41 },
  { 1620, 26, 41, 27, 0, -41 },
  { 1754, 26, 42, 27, 1, -41 },
  { 1891, 24, 42, 27, 3, -41 },
  { 2017, 23, 41, 27, 5, -41 },
  { 2135, 26, 42, 27, 1, -41 },
  { 2272, 24, 42, 27, 2, -41 },
  { 2398, 9, 30, 11, 1, -30 },
  { 2432, 13, 37, 11, -3, -30 },
  { 2493, 24, 25, 29, 3, -33 },
  { 2568, 24, 14, 29, 3, -27 },
  { 2610, 24, 25, 29, 3, -33 },
  { 2685, 18, 41, 20, 3, -41 },
  { 2778, 36, 45, 41, 3, -40 },
  { 2981, 26, 41, 27, -3, -41 },
  { 3115, 27, 41, 29, 2, -41 },
  { 3254, 28, 42, 29, 4, -41 },
  { 3401, 29, 41, 33, 2, -41 },
  { 3550, 26, 41, 26, 2, -41 },
  { 3684, 26, 41, 24, 2, -41 },
  { 3818, 30, 42, 34, 4, -41 },
  { 3976, 32, 41, 34, 2, -41 },
  { 4140, 17, 41, 14, -1, -41 },
  { 4228, 21, 51, 12, -9, -41 },
  { 4362, 29, 41, 27, 2, -41 },
  { 4511, 17, 41, 24, 2, -41 },
  { 4599, 40, 41, 41, 2, -41 },
  { 4804, 32, 41, 34, 2, -41 },
  { 4968, 29, 42, 35, 4, -41 },
  { 5121, 26, 41, 27, 2, -41 },
  { 5255, 29, 51, 35, 4, -41 },
  { 5440, 26, 41, 28, 2, -41 },
  { 5574, 26, 42, 25, 0, -41 },
  { 5711, 24, 41, 24, 5, -41 },
  { 5834, 30, 42, 34, 4, -41 },
  { 5992, 25, 41, 27, 6, -41 },
  { 6121, 40, 41, 42, 6, -41 },
  { 6326, 31, 41, 24, -3, -41 },
  { 6485, 24, 41, 24, 5, -41 },
  { 6608, 29, 41, 26, -1, -41 },
  { 6757, 21, 50, 17, -1, -41 },
  { 6889, 8, 41, 18, 6, -41 },
  { 6930, 21, 50, 17, -4, -41 },
  { 7062, 24, 23, 28, 2, -41 },
  { 7131, 19, 1, 19, -5, 6 },
  { 7134, 6, 9, 12, 8, -44 },
  { 7141, 24, 32, 28, 2, -31 },
  { 7237, 25, 44, 28, 1, -43 },
  { 7375, 20, 32, 22, 3, -31 },
  { 7455, 28, 44, 28, 2, -43 },
  { 7609, 20, 32, 25, 3, -31 },
  { 7689, 29, 58, 13, -8, -44 },
  { 7900, 26, 45, 28, 1, -31 },
  { 8047, 24, 43, 27, 1, -43 },
  { 8176, 11, 41, 11, 1, -41 },
  { 8233, 20, 55, 11, -8, -41 },
  { 8371, 23, 43, 22, 1, -43 },
  { 8495, 11, 43, 11, 1, -43 },
  { 8555, 38, 31, 42, 1, -31 },
  { 8703, 24, 31, 27, 1, -31 },
  { 8796, 22, 32, 28, 3, -31 },
  { 8884, 27, 44, 28, -1, -31 },
  { 9033, 25, 44, 28, 2, -31 },
  { 9171, 19, 31, 18, 1, -31 },
  { 9245, 20, 32, 21, 0, -31 },
  { 9325, 14, 39, 15, 2, -38 },
  { 9394, 23, 31, 27, 3, -30 },
  { 9484, 20, 30, 20, 3, -30 },
  { 9559, 32, 30, 33, 3, -30 },
  { 9679, 26, 30, 22, -2, -30 },
  { 9777, 31, 44, 21, -7, -30 },
  { 9948, 22, 30, 21, -1, -30 },
  { 10031, 20, 50, 18, 2, -41 },
  { 10156, 2, 57, 27, 13, -43 },
  { 10171, 20, 50, 18, -3, -41 },
  { 10296, 24, 5, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC57PT7B_H_
