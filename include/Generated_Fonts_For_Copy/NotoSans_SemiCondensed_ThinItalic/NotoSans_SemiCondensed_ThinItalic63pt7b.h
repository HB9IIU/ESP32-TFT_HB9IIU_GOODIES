#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x80,
  0x70, 0x0C, 0x00, 0x18, 0x19, 0x80, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10,
  0x11, 0x80, 0x8C, 0x0C, 0x60, 0x62, 0x03, 0x10, 0x10, 0x80, 0x8C, 0x0C,
  0x40, 0x62, 0x02, 0x10, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xE2, 0x1F, 0x00, 0x60, 0x40, 0x40, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x08, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x84,
  0x00, 0x00, 0x38, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x70, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x08, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x20, 0x38, 0x00, 0x04, 0x0E, 0x03, 0x01, 0x87, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xC0, 0x70, 0xE0, 0x00, 0x30, 0x38, 0x18, 0x00, 0x18,
  0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00, 0xC0, 0x03, 0x01, 0x00, 0x30, 0x01,
  0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x08, 0x03, 0x00, 0x40, 0x02,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x40, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x01, 0x03, 0x00, 0x08,
  0x00, 0xC1, 0x80, 0x02, 0x00, 0x30, 0x61, 0xFC, 0x80, 0x08, 0x30, 0xE1,
  0xA0, 0x06, 0x18, 0x60, 0x38, 0x01, 0x86, 0x30, 0x0E, 0x00, 0xC3, 0x0C,
  0x03, 0xC0, 0x61, 0x86, 0x00, 0x70, 0x18, 0x61, 0x80, 0x16, 0x1C, 0x30,
  0xC0, 0x04, 0xFE, 0x18, 0x30, 0x01, 0x0C, 0x06, 0x08, 0x00, 0x40, 0x03,
  0x06, 0x00, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x20, 0x06, 0x03, 0x00, 0x18,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x00,
  0x40, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x06, 0x03, 0x00, 0x0C, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x60, 0x30, 0x00, 0x1C, 0x38, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x60, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x00, 0xC6, 0x00, 0x18, 0x03, 0x18,
  0x00, 0x18, 0x06, 0x30, 0x00, 0x10, 0x18, 0xC0, 0x00, 0x30, 0x21, 0x80,
  0x00, 0x30, 0xC3, 0x00, 0x00, 0x63, 0x04, 0x00, 0x00, 0x66, 0x08, 0x00,
  0x00, 0xD8, 0x10, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x07, 0x80, 0xC0, 0x00, 0x1D, 0x01, 0x80, 0x00, 0x63, 0x01, 0x80, 0x01,
  0x82, 0x03, 0x80, 0x0E, 0x06, 0x03, 0xC0, 0x78, 0x06, 0x01, 0xFF, 0xC0,
  0x0C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x19, 0x8C, 0x63, 0x11, 0x8C, 0x62,
  0x10, 0x8C, 0x42, 0x10, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x0C, 0x01, 0x00, 0x1C, 0x04, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x80, 0x00, 0x3A, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x11, 0x00, 0x00, 0x86, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x30, 0x03,
  0x00, 0x40, 0x18, 0x01, 0x80, 0x40, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x5F, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x44, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x80, 0x76, 0x03, 0x18,
  0x38, 0x61, 0x81, 0x1C, 0x0C, 0xE0, 0x31, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x03, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x04, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x3F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x3F, 0xF0, 0x03, 0x1E, 0x07, 0x80,
  0x67, 0x00, 0x30, 0x09, 0x80, 0x03, 0x01, 0x60, 0x00, 0x30, 0x78, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x10, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x04, 0x00, 0x0E, 0x00, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x01, 0x80,
  0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x10, 0x00, 0x03,
  0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x34, 0x06, 0x00, 0x0D, 0x80, 0xE0,
  0x07, 0x30, 0x0F, 0x03, 0xC4, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x78, 0x0E, 0x08,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x3F, 0x80, 0x08, 0x30, 0x00, 0x7F, 0xF0, 0x04, 0x30,
  0x00, 0xE0, 0x18, 0x03, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x88, 0x00, 0xC0,
  0x04, 0x00, 0xCC, 0x00, 0xC0, 0x06, 0x00, 0x66, 0x00, 0x60, 0x03, 0x00,
  0x22, 0x00, 0x60, 0x01, 0x00, 0x13, 0x00, 0x60, 0x00, 0x80, 0x09, 0x80,
  0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x10, 0x00, 0x60, 0x06, 0x40, 0x18, 0x00,
  0x20, 0x03, 0x60, 0x0C, 0x00, 0x30, 0x01, 0x30, 0x04, 0x00, 0x18, 0x01,
  0x98, 0x06, 0x00, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x0C, 0x00, 0x46, 0x01,
  0x80, 0x06, 0x00, 0x63, 0x00, 0xC0, 0x03, 0x00, 0x31, 0x80, 0x60, 0x03,
  0x80, 0x30, 0xC0, 0x30, 0x03, 0xC0, 0x10, 0x60, 0x18, 0x01, 0x60, 0x18,
  0x30, 0x06, 0x01, 0x90, 0x18, 0x18, 0x03, 0x01, 0x8C, 0x18, 0x0C, 0x00,
  0xF7, 0x87, 0xF8, 0x06, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x80, 0x20, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xE0, 0x06, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x60, 0x03, 0xC0, 0x01, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x04, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0x20, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x01, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x40, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x70, 0x00, 0x40, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFC, 0x60, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x10, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x00, 0x33, 0x20, 0x00, 0x00, 0x13, 0x18, 0x00, 0x00, 0x0B,
  0x0C, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x05, 0x00,
  0x00, 0x00, 0x1A, 0x00, 0x58, 0x00, 0x00, 0x01, 0xE0, 0x0D, 0x80, 0x00,
  0x00, 0x36, 0x00, 0xD8, 0x00, 0x00, 0x02, 0x40, 0x0D, 0x80, 0x00, 0x00,
  0x64, 0x00, 0x88, 0x00, 0x00, 0x04, 0xC0, 0x08, 0x80, 0x00, 0x00, 0xCC,
  0x01, 0x88, 0x00, 0x00, 0x18, 0xC0, 0x18, 0x80, 0x00, 0x01, 0x88, 0x01,
  0x8C, 0x00, 0x00, 0x30, 0x80, 0x10, 0xC0, 0x00, 0x03, 0x18, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x03, 0x04, 0x00,
  0x00, 0xC1, 0x00, 0x30, 0x40, 0x00, 0x08, 0x30, 0x02, 0x04, 0x00, 0x01,
  0x83, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x40, 0x60, 0x00, 0xC0, 0x60, 0x0C, 0x02, 0x00, 0x08, 0x06, 0x00, 0xC0,
  0x20, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x10, 0x04, 0x00, 0x80, 0x30,
  0x03, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x0C, 0x01,
  0x80, 0x10, 0x01, 0x01, 0x80, 0x18, 0x03, 0x00, 0x10, 0x10, 0x01, 0x80,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x03, 0x00, 0x18, 0x20, 0x01, 0x00, 0x30,
  0x01, 0x86, 0x00, 0x30, 0x02, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x60, 0x01,
  0x8C, 0x00, 0x30, 0x06, 0x00, 0x09, 0x80, 0x02, 0x00, 0x60, 0x00, 0x98,
  0x00, 0x20, 0x04, 0x00, 0x0B, 0x00, 0x06, 0x00, 0x40, 0x00, 0xE0, 0x00,
  0x60, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x02, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x05, 0x00, 0x00, 0x06, 0x00, 0x58, 0x00, 0x00, 0x60,
  0x0D, 0x80, 0x00, 0x06, 0x00, 0xC8, 0x00, 0x00, 0x40, 0x0C, 0xC0, 0x00,
  0x0C, 0x00, 0x8C, 0x00, 0x00, 0xC0, 0x08, 0x40, 0x00, 0x0C, 0x01, 0x86,
  0x00, 0x00, 0x80, 0x18, 0x60, 0x00, 0x08, 0x01, 0x82, 0x00, 0x01, 0x80,
  0x10, 0x30, 0x00, 0x18, 0x03, 0x03, 0x00, 0x01, 0x80, 0x30, 0x10, 0x00,
  0x10, 0x03, 0x01, 0x80, 0x03, 0x00, 0x30, 0x18, 0x00, 0x30, 0x02, 0x00,
  0x80, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x80, 0x18, 0x00, 0x08, 0x18, 0x01, 0x80, 0x00, 0xC1,
  0x80, 0x10, 0x00, 0x0C, 0x18, 0x03, 0x00, 0x00, 0x61, 0x80, 0x30, 0x00,
  0x06, 0x10, 0x03, 0x00, 0x00, 0x63, 0x00, 0x30, 0x00, 0x03, 0x30, 0x02,
  0x00, 0x00, 0x33, 0x00, 0x60, 0x00, 0x03, 0x30, 0x06, 0x00, 0x00, 0x1A,
  0x00, 0x60, 0x00, 0x01, 0xA0, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x04,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x1C, 0x00, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x80, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x20, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x70, 0x00, 0x20, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x02,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x10, 0x00,
  0x30, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x18, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xA0, 0x00, 0x06,
  0xC0, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xA0, 0x00, 0x0C, 0xC0,
  0x00, 0x32, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x20, 0x00, 0x18, 0xC0, 0x00,
  0x62, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x42,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x82, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x82, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x02, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x20, 0x01, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x0C, 0x00,
  0x40, 0x20, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0x40, 0x30, 0x03, 0x00, 0x80, 0x04, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x60, 0x03, 0x01, 0x00, 0x04, 0x06, 0x00, 0x30, 0x30, 0x00,
  0x40, 0xC0, 0x03, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x40,
  0x80, 0x03, 0x06, 0x00, 0x04, 0x18, 0x00, 0x30, 0x40, 0x00, 0x41, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x30, 0x80, 0x00, 0x43, 0x00, 0x03,
  0x18, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0x46, 0x00, 0x03, 0x30,
  0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x20, 0x00,
  0x04, 0x80, 0x00, 0x36, 0x00, 0x00, 0x58, 0x00, 0x03, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x60, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x00, 0x20, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x80, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x03,
  0x02, 0x06, 0x04, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x30, 0x0E,
  0x03, 0x8C, 0x07, 0x00, 0x22, 0x03, 0x00, 0x0C, 0x81, 0x80, 0x01, 0x60,
  0x60, 0x00, 0x78, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x38, 0x20, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x40, 0xC0,
  0x00, 0xD0, 0x10, 0x00, 0x6C, 0x06, 0x00, 0x33, 0x00, 0xC0, 0x18, 0x80,
  0x38, 0x1C, 0x20, 0x03, 0xFC, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x3E,
  0x00, 0x0C, 0x1F, 0xF8, 0x01, 0x8E, 0x03, 0x80, 0x23, 0x80, 0x30, 0x04,
  0xC0, 0x03, 0x01, 0xB0, 0x00, 0x30, 0x36, 0x00, 0x06, 0x07, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x08, 0x1C, 0x00, 0x01, 0x07, 0x00, 0x00, 0x20, 0xE0,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC0, 0xA0, 0x00, 0x30, 0x36,
  0x00, 0x0E, 0x06, 0xC0, 0x03, 0x80, 0x8C, 0x00, 0xE0, 0x10, 0xE0, 0x70,
  0x06, 0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xF0, 0x0F, 0x00, 0x40, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x0E, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0xF0, 0x18,
  0x40, 0x07, 0x00, 0x33, 0x00, 0x30, 0x00, 0x6C, 0x01, 0x80, 0x00, 0xB0,
  0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x70, 0x08, 0x00, 0x01, 0xC0, 0x20,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x78, 0x03, 0x00, 0x01, 0xA0, 0x0C, 0x00,
  0x0D, 0x80, 0x10, 0x00, 0x66, 0x00, 0x60, 0x03, 0x90, 0x00, 0xC0, 0x1C,
  0x40, 0x03, 0x81, 0xC1, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0x03, 0x80, 0x70, 0x03,
  0x03, 0x80, 0x0C, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x43, 0x00, 0x01, 0x08,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x20, 0x00,
  0x31, 0x80, 0x01, 0xC6, 0x00, 0x1C, 0x18, 0x03, 0xE0, 0x7F, 0xFC, 0x01,
  0xFF, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x10, 0x0E, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xDC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0xC0, 0x0F, 0x01, 0x84, 0x00, 0xE0, 0x06, 0x20, 0x0C, 0x00,
  0x1B, 0x00, 0xC0, 0x00, 0x58, 0x06, 0x00, 0x02, 0xC0, 0x60, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x10,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xE0, 0x20, 0x00,
  0x07, 0x01, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x80, 0x60, 0x00, 0x34,
  0x03, 0x00, 0x03, 0x60, 0x08, 0x00, 0x33, 0x00, 0x60, 0x03, 0x90, 0x01,
  0x80, 0x30, 0x80, 0x0E, 0x07, 0x0C, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x0F, 0xC0, 0x06, 0x0F, 0xFC, 0x01, 0x8E, 0x03,
  0x80, 0x46, 0x00, 0x60, 0x13, 0x00, 0x0C, 0x0D, 0x80, 0x03, 0x03, 0xC0,
  0x00, 0x40, 0xE0, 0x00, 0x10, 0x38, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x07,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x04, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x0C,
  0x00, 0x08, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x10, 0x70, 0x00, 0x04, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0xC7, 0x80, 0x00, 0x23, 0x20, 0x00, 0x09, 0x8C, 0x00, 0x06, 0xC3, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x02, 0x00, 0x04, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x02, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x40,
  0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x61, 0xFF, 0x00, 0xFF, 0xC0, 0x18, 0xC0, 0x60,
  0x70, 0x38, 0x04, 0x60, 0x0C, 0x30, 0x06, 0x01, 0x30, 0x03, 0x18, 0x00,
  0xC0, 0xD8, 0x00, 0x4C, 0x00, 0x30, 0x3C, 0x00, 0x16, 0x00, 0x0C, 0x0A,
  0x00, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x30, 0x00, 0x08, 0x00, 0x06, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x00, 0x40, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x30, 0x00, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x00, 0x40, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x60, 0xFF, 0xC0, 0x18, 0xE0, 0x38, 0x04, 0x60, 0x06, 0x01, 0x30,
  0x00, 0xC0, 0xD8, 0x00, 0x30, 0x3C, 0x00, 0x04, 0x0E, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x04, 0x00, 0x03, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xC1, 0xFF, 0x80, 0x03, 0x1C,
  0x07, 0x00, 0x08, 0xE0, 0x0E, 0x00, 0x27, 0x00, 0x18, 0x01, 0xB8, 0x00,
  0x30, 0x06, 0xC0, 0x00, 0xC0, 0x1E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x04,
  0x01, 0xC0, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x40, 0x38, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x05,
  0x00, 0x01, 0x80, 0x36, 0x00, 0x06, 0x00, 0xD8, 0x00, 0x70, 0x03, 0x30,
  0x03, 0x80, 0x08, 0x70, 0x3C, 0x00, 0x20, 0xFF, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFE,
  0x0C, 0x03, 0x80, 0x61, 0x00, 0xE0, 0x06, 0x20, 0x30, 0x00, 0x64, 0x0C,
  0x00, 0x05, 0x81, 0x80, 0x00, 0xB0, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0x1C, 0x10, 0x00, 0x07, 0x83, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x34, 0x0C, 0x00, 0x0D, 0x80, 0x80, 0x03, 0x30, 0x18,
  0x00, 0xE4, 0x01, 0x80, 0x38, 0x80, 0x38, 0x1C, 0x30, 0x01, 0xFF, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x0C, 0x3F, 0xC0, 0x63, 0x80,
  0x02, 0x30, 0x00, 0x13, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x1C, 0x01, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xF0, 0x0F, 0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x40, 0x3F, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x1C, 0x08,
  0x00, 0x0F, 0x02, 0x00, 0x02, 0xC0, 0xC0, 0x01, 0xB0, 0x30, 0x00, 0xC8,
  0x06, 0x00, 0xE2, 0x01, 0xC0, 0x71, 0x80, 0x1F, 0xF0, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00, 0x62, 0x00,
  0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x01, 0x00, 0x0C,
  0x02, 0x00, 0x30, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x1A, 0x00, 0x07,
  0x00, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x34, 0x00, 0x19, 0x00,
  0x06, 0x80, 0x02, 0x20, 0x01, 0x90, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x10,
  0xC0, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x21, 0x80,
  0x30, 0x60, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x06, 0x00, 0x81, 0x80, 0x60,
  0xC0, 0x30, 0x30, 0x08, 0x18, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x20, 0x18, 0x18, 0x04, 0x0C, 0x03, 0x02, 0x00, 0x81, 0x80,
  0x60, 0xC0, 0x10, 0x60, 0x0C, 0x10, 0x02, 0x0C, 0x01, 0x86, 0x00, 0x41,
  0x00, 0x30, 0x80, 0x08, 0x60, 0x06, 0x30, 0x01, 0x88, 0x00, 0x44, 0x00,
  0x33, 0x00, 0x09, 0x80, 0x06, 0x40, 0x01, 0x30, 0x00, 0xD8, 0x00, 0x2C,
  0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x20, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x0E, 0x80, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 45, 13, 2, -45 },
  { 63, 13, 16, 18, 7, -45 },
  { 89, 33, 45, 33, 1, -45 },
  { 275, 27, 52, 30, 2, -48 },
  { 451, 34, 47, 42, 5, -46 },
  { 651, 31, 47, 35, 2, -46 },
  { 834, 5, 16, 10, 7, -45 },
  { 844, 17, 55, 15, 2, -45 },
  { 961, 17, 55, 15, -4, -45 },
  { 1078, 22, 23, 29, 8, -48 },
  { 1142, 26, 29, 32, 4, -37 },
  { 1237, 8, 15, 11, -3, -7 },
  { 1252, 14, 2, 19, 2, -18 },
  { 1256, 3, 4, 12, 2, -4 },
  { 1258, 27, 45, 19, -3, -45 },
  { 1410, 26, 47, 30, 3, -46 },
  { 1563, 14, 45, 30, 9, -45 },
  { 1642, 28, 46, 30, 0, -46 },
  { 1803, 29, 47, 30, 0, -46 },
  { 1974, 28, 45, 30, 0, -45 },
  { 2132, 28, 46, 30, 1, -45 },
  { 2293, 27, 47, 30, 3, -46 },
  { 2452, 26, 45, 30, 5, -45 },
  { 2599, 27, 47, 30, 2, -46 },
  { 2758, 27, 47, 30, 2, -46 },
  { 2917, 10, 33, 12, 1, -33 },
  { 2959, 14, 41, 12, -3, -33 },
  { 3031, 26, 27, 32, 4, -36 },
  { 3119, 26, 15, 32, 4, -30 },
  { 3168, 26, 27, 32, 4, -36 },
  { 3256, 19, 46, 22, 4, -46 },
  { 3366, 41, 51, 45, 3, -45 },
  { 3628, 30, 45, 29, -4, -45 },
  { 3797, 30, 45, 33, 2, -45 },
  { 3966, 31, 47, 32, 4, -46 },
  { 4149, 32, 45, 36, 2, -45 },
  { 4329, 29, 45, 29, 2, -45 },
  { 4493, 29, 45, 27, 2, -45 },
  { 4657, 33, 47, 38, 4, -46 },
  { 4851, 35, 45, 37, 2, -45 },
  { 5048, 19, 45, 15, -1, -45 },
  { 5155, 23, 56, 13, -10, -45 },
  { 5316, 33, 45, 30, 2, -45 },
  { 5502, 19, 45, 27, 2, -45 },
  { 5609, 44, 45, 46, 2, -45 },
  { 5857, 36, 45, 38, 2, -45 },
  { 6060, 33, 47, 39, 4, -46 },
  { 6254, 29, 45, 30, 2, -45 },
  { 6418, 33, 57, 39, 4, -46 },
  { 6654, 29, 45, 31, 2, -45 },
  { 6818, 29, 47, 28, 0, -46 },
  { 6989, 26, 45, 26, 6, -45 },
  { 7136, 34, 46, 37, 4, -45 },
  { 7332, 28, 45, 29, 6, -45 },
  { 7490, 44, 45, 47, 7, -45 },
  { 7738, 35, 45, 27, -4, -45 },
  { 7935, 26, 45, 26, 6, -45 },
  { 8082, 32, 45, 29, -1, -45 },
  { 8262, 23, 55, 18, -1, -45 },
  { 8421, 9, 45, 20, 6, -45 },
  { 8472, 23, 55, 18, -4, -45 },
  { 8631, 26, 25, 31, 3, -45 },
  { 8713, 21, 2, 21, -5, 6 },
  { 8719, 7, 10, 14, 9, -48 },
  { 8728, 26, 35, 31, 3, -34 },
  { 8842, 27, 49, 31, 1, -48 },
  { 9008, 22, 35, 24, 3, -34 },
  { 9105, 30, 49, 31, 3, -48 },
  { 9289, 22, 35, 27, 3, -34 },
  { 9386, 31, 63, 15, -8, -48 },
  { 9631, 29, 49, 31, 1, -34 },
  { 9809, 26, 48, 30, 1, -48 },
  { 9965, 12, 45, 12, 1, -45 },
  { 10033, 22, 60, 12, -9, -45 },
  { 10198, 26, 48, 24, 1, -48 },
  { 10354, 12, 48, 12, 1, -48 },
  { 10426, 42, 34, 46, 1, -34 },
  { 10605, 26, 34, 30, 1, -34 },
  { 10716, 25, 35, 31, 3, -34 },
  { 10826, 30, 49, 31, -2, -34 },
  { 11010, 27, 49, 31, 3, -34 },
  { 11176, 21, 34, 20, 1, -34 },
  { 11266, 22, 35, 23, 0, -34 },
  { 11363, 16, 42, 17, 2, -41 },
  { 11447, 26, 34, 30, 3, -33 },
  { 11558, 23, 33, 23, 3, -33 },
  { 11653, 35, 33, 37, 4, -33 },
  { 11798, 28, 33, 25, -2, -33 },
  { 11914, 33, 48, 23, -7, -33 },
  { 12112, 24, 33, 23, -1, -33 },
  { 12211, 22, 55, 20, 2, -45 },
  { 12363, 1, 63, 29, 15, -48 },
  { 12371, 22, 55, 20, -4, -45 },
  { 12523, 26, 5, 32, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC63PT7B_H_
