#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_ThinItalic
// Headers: 67

#include "NotoSans_SemiCondensed_ThinItalic6pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic7pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic8pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic9pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic10pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic11pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic12pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic13pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic14pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic15pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic16pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic17pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic18pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic19pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic20pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic21pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic22pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic23pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic24pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic25pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic26pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic27pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic28pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic29pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic30pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic31pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic32pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic33pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic34pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic35pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic36pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic37pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic38pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic39pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic40pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic41pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic42pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic43pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic44pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic45pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic46pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic47pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic48pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic49pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic50pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic51pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic52pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic53pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic54pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic55pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic56pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic57pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic58pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic59pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic60pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic61pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic62pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic63pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic64pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic65pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic66pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic67pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic68pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic69pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic70pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic71pt7b.h"
#include "NotoSans_SemiCondensed_ThinItalic72pt7b.h"
