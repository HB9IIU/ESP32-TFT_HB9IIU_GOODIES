#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xC0, 0xC0, 0x21, 0xB0, 0x90, 0x48,
  0x24, 0x12, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00,
  0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x3F,
  0xFF, 0xFC, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20,
  0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x80,
  0x03, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x60, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x06, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0F,
  0x00, 0x0E, 0xBE, 0x06, 0x10, 0x41, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x10,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0xC1, 0x00, 0x08, 0x40,
  0x01, 0x88, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0x60,
  0x00, 0x23, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x81, 0x00, 0x10, 0xC1,
  0xC2, 0x70, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x60, 0x06, 0x18,
  0x20, 0x04, 0x10, 0x20, 0x08, 0x30, 0x20, 0x18, 0x20, 0x20, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x20, 0x60, 0x40, 0x20, 0x40, 0x40, 0x20, 0x80, 0xC0,
  0x21, 0x80, 0xC0, 0x61, 0x00, 0x80, 0x42, 0x00, 0x80, 0x42, 0x3E, 0x80,
  0xC4, 0x63, 0x80, 0x8C, 0xC1, 0xC1, 0x88, 0x81, 0x41, 0x11, 0x01, 0x66,
  0x31, 0x01, 0x3C, 0x23, 0x01, 0x00, 0x42, 0x01, 0x00, 0xC2, 0x01, 0x00,
  0x82, 0x01, 0x01, 0x06, 0x01, 0x03, 0x06, 0x03, 0x02, 0x04, 0x02, 0x04,
  0x04, 0x02, 0x0C, 0x04, 0x06, 0x08, 0x04, 0x04, 0x10, 0x06, 0x0C, 0x30,
  0x02, 0x18, 0x20, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0x86, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x40, 0x30, 0x01, 0x00, 0x80, 0x04, 0x06, 0x00,
  0x10, 0x10, 0x00, 0x40, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x20, 0x00, 0x10, 0xC0, 0x01, 0x81, 0x00,
  0xCC, 0x06, 0x02, 0x20, 0x08, 0x19, 0x00, 0x30, 0x44, 0x00, 0x43, 0x30,
  0x00, 0x88, 0x80, 0x02, 0x42, 0x00, 0x07, 0x08, 0x00, 0x18, 0x20, 0x00,
  0x60, 0xC0, 0x02, 0xC1, 0x00, 0x31, 0x03, 0x01, 0x86, 0x07, 0xF8, 0x08,
  0x2D, 0x24, 0xA4, 0x92, 0x00, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x40, 0x80, 0xE0, 0x80, 0x10, 0x80, 0x0C,
  0x81, 0x03, 0xFE, 0x01, 0x00, 0x06, 0x80, 0x0C, 0x80, 0x10, 0x40, 0x20,
  0x40, 0x40, 0x20, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x30, 0x86, 0x10, 0x42,
  0x08, 0x41, 0x08, 0x00, 0x7F, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x31, 0xC0, 0x10, 0x18, 0x08, 0x02, 0x06, 0x00, 0xC1, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x58, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00,
  0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x8C, 0x00, 0x41, 0x00,
  0x20, 0x40, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0x7F, 0x00, 0x01, 0xC0,
  0xF0, 0x48, 0x62, 0x30, 0xB0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x00, 0x1F, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x40, 0x10, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x0E, 0x1C, 0x03, 0x80, 0x60, 0x20, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1F,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0xC0, 0x1C, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0A, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00,
  0x44, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x00,
  0x40, 0x80, 0x08, 0x08, 0x01, 0x00, 0x80, 0x30, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x30, 0x02, 0x06, 0x00, 0x20,
  0x40, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x09, 0xE0, 0x01, 0xF3, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x08, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0x04,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x43, 0xF0, 0x09, 0x81, 0x82, 0x40, 0x18, 0x50, 0x01, 0x0C,
  0x00, 0x21, 0x00, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x18, 0x00, 0x63, 0x00, 0x08, 0x20,
  0x03, 0x04, 0x00, 0x40, 0x40, 0x10, 0x0C, 0x0C, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1C, 0x70, 0x06, 0x01, 0x01, 0x80, 0x30, 0x20, 0x02, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x01,
  0x00, 0x60, 0x30, 0x18, 0x03, 0x0C, 0x00, 0x37, 0x00, 0x03, 0x80, 0x01,
  0x98, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x18, 0x01, 0x86, 0x00, 0x10, 0x80,
  0x02, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x32, 0x00,
  0x04, 0x60, 0x00, 0x84, 0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x03, 0x00, 0x7F,
  0x80, 0x00, 0x3E, 0x00, 0x18, 0x60, 0x04, 0x02, 0x01, 0x00, 0x20, 0x40,
  0x04, 0x18, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0xC4, 0x00,
  0x10, 0x80, 0x06, 0x18, 0x01, 0x41, 0x80, 0x48, 0x1C, 0x72, 0x00, 0xF8,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x07, 0xF8, 0x00, 0x06, 0x18, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x18,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x70, 0xC1, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x11, 0x00, 0x7F,
  0x81, 0x30, 0x0C, 0x08, 0x12, 0x01, 0x01, 0x81, 0x20, 0x20, 0x10, 0x16,
  0x06, 0x01, 0x01, 0x40, 0x40, 0x10, 0x14, 0x0C, 0x03, 0x01, 0xC0, 0x80,
  0x20, 0x1C, 0x08, 0x02, 0x03, 0x81, 0x80, 0x60, 0x28, 0x10, 0x06, 0x02,
  0x81, 0x00, 0x40, 0x68, 0x10, 0x0C, 0x04, 0x81, 0x80, 0xC0, 0x88, 0x08,
  0x14, 0x18, 0x80, 0xC2, 0x23, 0x08, 0x07, 0xC3, 0xE0, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x01, 0x30, 0x00, 0x08, 0x80,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x20,
  0x40, 0x01, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x08, 0x06, 0x00,
  0x40, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x03, 0xFF, 0xE0, 0x30, 0x01,
  0x01, 0x00, 0x08, 0x18, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x40,
  0x00, 0x86, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x00, 0x90, 0x00, 0x05,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x01, 0xFF, 0xC0, 0x08, 0x01, 0x80, 0xC0,
  0x04, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20,
  0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00,
  0x40, 0xC0, 0x06, 0x04, 0x01, 0xC0, 0x3F, 0xF0, 0x01, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0xC0, 0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x18, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00,
  0x02, 0x18, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x30, 0x20, 0x0E, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xC1, 0xC0, 0x30, 0x02, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x08,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x02, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x10, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x80, 0x01, 0x83,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00,
  0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00,
  0x61, 0x00, 0x00, 0x86, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18, 0x04,
  0x00, 0xE0, 0x08, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFE,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x78, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xF2, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x21, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00,
  0x03, 0x02, 0x00, 0x04, 0x06, 0x00, 0x08, 0x07, 0x00, 0x70, 0x03, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x40,
  0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x0C,
  0x00, 0x06, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x20, 0x3F, 0xFF, 0xF0,
  0x10, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02,
  0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x40, 0x40, 0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xFC, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0xFE,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x06, 0x02, 0x00, 0x10, 0x0C, 0x00, 0x40,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x10, 0x00, 0x80, 0x40, 0x03,
  0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x10, 0x00, 0x10, 0x40, 0x00, 0x21,
  0x00, 0x00, 0xC4, 0x00, 0x01, 0x18, 0x00, 0x02, 0x50, 0x00, 0x05, 0x10,
  0x00, 0x1C, 0x20, 0x00, 0x30, 0x60, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80,
  0x01, 0x00, 0x80, 0x06, 0x01, 0x00, 0x08, 0x03, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x01, 0x80, 0x08, 0x02, 0x00, 0x18, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0x60, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x14,
  0x0E, 0x00, 0x00, 0x30, 0x14, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x03, 0x40,
  0x58, 0x00, 0x04, 0x80, 0x90, 0x00, 0x1B, 0x03, 0x20, 0x00, 0x24, 0x04,
  0x40, 0x00, 0xC8, 0x08, 0x80, 0x01, 0x10, 0x11, 0x00, 0x04, 0x20, 0x22,
  0x00, 0x08, 0xC0, 0xC4, 0x00, 0x21, 0x01, 0x0C, 0x00, 0xC2, 0x02, 0x08,
  0x01, 0x04, 0x04, 0x10, 0x06, 0x18, 0x18, 0x20, 0x08, 0x20, 0x20, 0x40,
  0x30, 0x40, 0x40, 0x80, 0x40, 0x80, 0x81, 0x01, 0x01, 0x01, 0x03, 0x02,
  0x06, 0x06, 0x02, 0x08, 0x08, 0x08, 0x04, 0x30, 0x10, 0x10, 0x08, 0x40,
  0x20, 0x20, 0x11, 0x80, 0x40, 0x40, 0x22, 0x01, 0x81, 0x80, 0x48, 0x02,
  0x02, 0x00, 0x90, 0x04, 0x04, 0x01, 0xC0, 0x08, 0x08, 0x01, 0x80, 0x10,
  0x30, 0x02, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x40,
  0xE0, 0x00, 0x20, 0x50, 0x00, 0x30, 0x24, 0x00, 0x10, 0x12, 0x00, 0x08,
  0x09, 0x80, 0x04, 0x0C, 0x40, 0x06, 0x04, 0x20, 0x02, 0x02, 0x18, 0x01,
  0x01, 0x04, 0x00, 0x80, 0x82, 0x00, 0x40, 0xC1, 0x80, 0x60, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x18, 0x04, 0x04, 0x08, 0x02,
  0x06, 0x04, 0x01, 0x82, 0x02, 0x00, 0x41, 0x01, 0x00, 0x20, 0x81, 0x80,
  0x18, 0xC0, 0x80, 0x04, 0x40, 0x40, 0x02, 0x20, 0x20, 0x01, 0x90, 0x10,
  0x00, 0x48, 0x18, 0x00, 0x2C, 0x08, 0x00, 0x1C, 0x04, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xC1, 0xC0,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x82,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00,
  0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x06,
  0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x80, 0x00, 0x41, 0x00, 0x01, 0x82,
  0x00, 0x06, 0x06, 0x00, 0x08, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x10, 0x0E, 0x03, 0x00, 0x20, 0x20, 0x03,
  0x02, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x03, 0x0C, 0x00, 0x20, 0x80,
  0x06, 0x08, 0x00, 0xC0, 0x80, 0x38, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xC1, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80,
  0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x06, 0x40, 0x00,
  0x0C, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xD0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20,
  0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x80, 0x00, 0x41, 0x00,
  0x01, 0x82, 0x00, 0x06, 0x06, 0x00, 0x08, 0x06, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x10, 0x0E, 0x03, 0x00, 0x20, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x04,
  0x08, 0x01, 0x80, 0x80, 0x70, 0x0F, 0xF8, 0x01, 0x01, 0x80, 0x10, 0x08,
  0x01, 0x00, 0x80, 0x10, 0x08, 0x03, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x06, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0x0F,
  0x01, 0x80, 0x10, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x18,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00,
  0x30, 0x80, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02,
  0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42,
  0x00, 0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00,
  0xC1, 0x00, 0x01, 0x03, 0x00, 0x06, 0x02, 0x00, 0x08, 0x06, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00,
  0x40, 0x40, 0x08, 0x06, 0x00, 0x80, 0x60, 0x10, 0x02, 0x01, 0x00, 0x20,
  0x20, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x34, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x1C, 0x00,
  0x24, 0x00, 0x28, 0x00, 0x48, 0x00, 0x50, 0x01, 0x90, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x0C, 0x40, 0x08, 0x80, 0x10, 0x80, 0x11, 0x00, 0x21,
  0x00, 0x62, 0x00, 0x82, 0x00, 0x84, 0x01, 0x04, 0x03, 0x08, 0x04, 0x08,
  0x04, 0x10, 0x08, 0x10, 0x18, 0x20, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x81, 0x80, 0x81, 0x01, 0x02, 0x01, 0x02, 0x02, 0x04, 0x02, 0x08,
  0x04, 0x10, 0x04, 0x10, 0x08, 0x20, 0x08, 0x60, 0x18, 0xC0, 0x18, 0x80,
  0x31, 0x00, 0x33, 0x00, 0x66, 0x00, 0x64, 0x00, 0xC8, 0x00, 0xC8, 0x00,
  0x90, 0x01, 0xA0, 0x01, 0x40, 0x01, 0x40, 0x02, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x20, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x04,
  0x04, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x18, 0x03, 0x00, 0x04, 0x03, 0x00, 0x02, 0x03,
  0x00, 0x01, 0x80, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x11, 0x00, 0x0C,
  0x40, 0x02, 0x18, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x10, 0x08,
  0x0C, 0x03, 0x02, 0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x90,
  0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x07, 0xFC, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x02,
  0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x02, 0x80, 0x01, 0xA0, 0x00, 0x44, 0x00,
  0x21, 0x00, 0x18, 0x40, 0x04, 0x08, 0x02, 0x02, 0x01, 0x80, 0x80, 0x40,
  0x30, 0x30, 0x04, 0x08, 0x01, 0x04, 0x00, 0x63, 0x00, 0x08, 0x80, 0x02,
  0x40, 0x00, 0xF0, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xFC, 0xC2, 0x18, 0x43,
  0x08, 0x20, 0x00, 0x70, 0x00, 0x77, 0x10, 0x60, 0x24, 0x30, 0x09, 0x08,
  0x01, 0x84, 0x00, 0x63, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0xC2, 0x00, 0x30, 0xC0,
  0x14, 0x10, 0x09, 0x06, 0x04, 0x40, 0xFE, 0x20, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x81, 0x80, 0x11, 0xFC, 0x02, 0x40,
  0x40, 0x90, 0x04, 0x14, 0x00, 0x83, 0x80, 0x18, 0x60, 0x01, 0x18, 0x00,
  0x23, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x60, 0x00,
  0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x02,
  0x30, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x34, 0x01, 0x04, 0xC0, 0xC0,
  0x87, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x10, 0x1F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x01, 0x81, 0x00, 0x7F, 0x98, 0x0C, 0x04, 0x80, 0xC0,
  0x14, 0x0C, 0x00, 0xA0, 0x40, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x83,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x40, 0x00,
  0x82, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x10, 0x20,
  0x01, 0x81, 0x00, 0x1C, 0x08, 0x00, 0xA0, 0x60, 0x0D, 0x01, 0x00, 0xD0,
  0x0C, 0x0C, 0x80, 0x3F, 0x84, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x02, 0x02,
  0x04, 0x03, 0x08, 0x01, 0x10, 0x01, 0x30, 0x03, 0x20, 0x02, 0x20, 0x06,
  0x40, 0x0C, 0x40, 0x38, 0x41, 0xE0, 0xFE, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x10, 0x1F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xB0,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0xF8, 0x40, 0x60, 0x24, 0x06, 0x00, 0xA0, 0x60, 0x05, 0x02,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80,
  0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0xE0,
  0x40, 0x05, 0x03, 0x00, 0x78, 0x08, 0x06, 0x80, 0x60, 0x64, 0x01, 0xFC,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x30,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x03, 0x00, 0x47, 0xF8, 0x12, 0x02, 0x09, 0x00, 0x42,
  0x80, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x18, 0x00, 0x46, 0x00, 0x31, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x00, 0x01, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x01, 0xF0, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x10, 0x40, 0x08, 0x10, 0x04, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x20, 0x40, 0x18, 0x20, 0x04, 0x10, 0x01, 0x08, 0x00, 0x44, 0x00, 0x13,
  0x80, 0x0D, 0x20, 0x02, 0x88, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x18,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x02,
  0x00, 0x20, 0x80, 0x08, 0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x23, 0xF8, 0x7F, 0x81, 0x60, 0x46,
  0x04, 0x16, 0x03, 0x60, 0x10, 0xA0, 0x0A, 0x00, 0x86, 0x00, 0x60, 0x04,
  0x30, 0x03, 0x00, 0x23, 0x00, 0x10, 0x01, 0x18, 0x01, 0x80, 0x08, 0x80,
  0x08, 0x00, 0xC4, 0x00, 0x40, 0x04, 0x20, 0x02, 0x00, 0x23, 0x00, 0x10,
  0x01, 0x10, 0x01, 0x80, 0x18, 0x80, 0x08, 0x00, 0x84, 0x00, 0x40, 0x04,
  0x20, 0x02, 0x00, 0x23, 0x00, 0x30, 0x01, 0x10, 0x01, 0x00, 0x18, 0x80,
  0x08, 0x00, 0x84, 0x00, 0x40, 0x04, 0x60, 0x02, 0x00, 0x22, 0x00, 0x30,
  0x01, 0x10, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x1F, 0xE0, 0x48, 0x08,
  0x24, 0x03, 0x0A, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x60, 0x01, 0x18,
  0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00,
  0x62, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x31,
  0x00, 0x08, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x7F, 0x80, 0x60, 0x30, 0x30, 0x04, 0x08, 0x00, 0x84, 0x00,
  0x23, 0x00, 0x08, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x09,
  0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0xC8, 0x00, 0x23, 0x00, 0x18, 0x40, 0x0C, 0x18, 0x06,
  0x03, 0x03, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x08, 0xFE, 0x00, 0x4C,
  0x08, 0x04, 0x80, 0x20, 0x28, 0x01, 0x01, 0xC0, 0x0C, 0x0C, 0x00, 0x20,
  0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x30, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08,
  0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x08,
  0x0A, 0x00, 0x80, 0x98, 0x18, 0x04, 0x7F, 0x80, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0x84, 0x18, 0x09, 0x06, 0x00, 0xA0, 0x80, 0x14, 0x20,
  0x01, 0x8C, 0x00, 0x31, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x02, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00,
  0x18, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x38, 0x40, 0x05, 0x0C, 0x01,
  0xE0, 0x80, 0x68, 0x18, 0x19, 0x01, 0xFC, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x08, 0x11, 0xF0,
  0x48, 0x02, 0x40, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x0C, 0x02, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0xC0, 0x20,
  0x7F, 0xC0, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x07, 0xFC, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x7C, 0x00, 0x18, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0x40, 0x02,
  0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x46, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x50,
  0xC0, 0x24, 0x10, 0x32, 0x03, 0xF8, 0x80, 0xC0, 0x03, 0x40, 0x02, 0x40,
  0x06, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x20, 0x40, 0x20, 0x60, 0x40, 0x20, 0x40, 0x20, 0x80, 0x21, 0x80, 0x21,
  0x00, 0x23, 0x00, 0x22, 0x00, 0x26, 0x00, 0x24, 0x00, 0x2C, 0x00, 0x28,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x10, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x80,
  0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x08, 0x40, 0x84, 0x08, 0x40, 0x8C,
  0x08, 0xC0, 0x88, 0x08, 0x80, 0x98, 0x08, 0x80, 0x90, 0x09, 0x00, 0xB0,
  0x0D, 0x00, 0xA0, 0x06, 0x00, 0xA0, 0x06, 0x00, 0xC0, 0x04, 0x00, 0xC0,
  0x04, 0x00, 0x02, 0x00, 0x30, 0x30, 0x06, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0x82, 0x00, 0x04, 0x40, 0x00, 0x48,
  0x00, 0x05, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x50, 0x00, 0x09,
  0x00, 0x01, 0x10, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0x40, 0xC0, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x02, 0x02, 0x00, 0x20, 0xC0, 0x02, 0x00,
  0x00, 0x80, 0x02, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x30, 0x04, 0x00, 0x20, 0x10, 0x00,
  0x40, 0x20, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x31, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x48, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x98, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x7F, 0x00, 0x60, 0x30, 0x38, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 11, 13, 5, -31 },
  { 45, 23, 31, 23, 1, -31 },
  { 135, 19, 36, 21, 1, -33 },
  { 221, 24, 33, 30, 3, -32 },
  { 320, 22, 32, 24, 1, -32 },
  { 408, 3, 11, 7, 5, -31 },
  { 413, 12, 38, 11, 1, -31 },
  { 470, 12, 38, 11, -3, -31 },
  { 527, 16, 16, 20, 5, -33 },
  { 559, 18, 21, 22, 3, -26 },
  { 607, 6, 11, 8, -2, -5 },
  { 616, 10, 2, 13, 1, -13 },
  { 619, 2, 3, 8, 1, -3 },
  { 620, 19, 31, 13, -2, -31 },
  { 694, 18, 32, 21, 2, -32 },
  { 766, 10, 31, 21, 6, -31 },
  { 805, 20, 32, 21, 0, -32 },
  { 885, 20, 32, 21, 0, -32 },
  { 965, 20, 32, 21, 0, -32 },
  { 1045, 20, 31, 21, 1, -31 },
  { 1123, 19, 32, 21, 2, -32 },
  { 1199, 18, 31, 21, 4, -31 },
  { 1269, 19, 32, 21, 1, -32 },
  { 1345, 19, 32, 21, 1, -32 },
  { 1421, 7, 23, 8, 1, -23 },
  { 1442, 10, 29, 8, -2, -23 },
  { 1479, 18, 19, 22, 3, -25 },
  { 1522, 18, 11, 22, 3, -21 },
  { 1547, 18, 19, 22, 3, -25 },
  { 1590, 14, 32, 15, 2, -32 },
  { 1646, 28, 35, 31, 2, -31 },
  { 1769, 21, 32, 21, -3, -32 },
  { 1853, 21, 31, 23, 1, -31 },
  { 1935, 21, 32, 22, 3, -32 },
  { 2019, 23, 31, 25, 1, -31 },
  { 2109, 21, 31, 20, 1, -31 },
  { 2191, 21, 31, 19, 1, -31 },
  { 2273, 23, 32, 27, 3, -32 },
  { 2365, 25, 31, 26, 1, -31 },
  { 2462, 14, 31, 10, -1, -31 },
  { 2517, 16, 39, 9, -7, -31 },
  { 2595, 23, 31, 21, 1, -31 },
  { 2685, 14, 31, 19, 1, -31 },
  { 2740, 31, 31, 32, 1, -31 },
  { 2861, 25, 31, 26, 1, -31 },
  { 2958, 23, 32, 27, 3, -32 },
  { 3050, 20, 31, 21, 1, -31 },
  { 3128, 23, 39, 27, 3, -32 },
  { 3241, 20, 31, 21, 1, -31 },
  { 3319, 20, 32, 19, 0, -32 },
  { 3399, 18, 31, 18, 4, -31 },
  { 3469, 23, 31, 26, 3, -31 },
  { 3559, 20, 31, 20, 4, -31 },
  { 3637, 31, 31, 33, 5, -31 },
  { 3758, 25, 31, 19, -3, -31 },
  { 3855, 18, 31, 18, 4, -31 },
  { 3925, 23, 31, 20, -1, -31 },
  { 4015, 17, 38, 13, -1, -31 },
  { 4096, 7, 31, 14, 4, -31 },
  { 4124, 16, 38, 13, -3, -31 },
  { 4200, 18, 18, 22, 2, -32 },
  { 4241, 15, 2, 15, -4, 4 },
  { 4245, 5, 7, 10, 6, -34 },
  { 4250, 18, 24, 21, 2, -24 },
  { 4304, 19, 33, 22, 1, -33 },
  { 4383, 16, 24, 17, 2, -24 },
  { 4431, 21, 33, 22, 2, -33 },
  { 4518, 16, 24, 19, 2, -24 },
  { 4566, 22, 45, 10, -6, -34 },
  { 4690, 21, 35, 22, 0, -24 },
  { 4782, 18, 33, 21, 1, -33 },
  { 4857, 8, 32, 8, 1, -32 },
  { 4889, 15, 43, 8, -6, -32 },
  { 4970, 18, 33, 17, 1, -33 },
  { 5045, 8, 33, 8, 1, -33 },
  { 5078, 29, 24, 32, 1, -24 },
  { 5165, 18, 24, 21, 1, -24 },
  { 5219, 18, 24, 22, 2, -24 },
  { 5273, 21, 34, 22, -1, -24 },
  { 5363, 19, 34, 22, 2, -24 },
  { 5444, 14, 24, 14, 1, -24 },
  { 5486, 16, 24, 16, 0, -24 },
  { 5534, 10, 29, 12, 2, -29 },
  { 5571, 18, 23, 21, 2, -23 },
  { 5623, 16, 23, 16, 2, -23 },
  { 5669, 24, 23, 26, 3, -23 },
  { 5738, 20, 23, 17, -2, -23 },
  { 5796, 23, 34, 16, -5, -23 },
  { 5894, 17, 23, 16, -1, -23 },
  { 5943, 16, 38, 14, 1, -31 },
  { 6019, 1, 44, 20, 10, -33 },
  { 6025, 15, 38, 14, -2, -31 },
  { 6097, 18, 3, 22, 3, -17 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC44PT7B_H_
