#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x01,
  0x80, 0x20, 0x90, 0xD8, 0x48, 0x24, 0x12, 0x09, 0x0D, 0x04, 0x82, 0x41,
  0x20, 0x80, 0x00, 0x18, 0x08, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x01,
  0x80, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x20,
  0x10, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x7F, 0xFF, 0xF8, 0x04, 0x06,
  0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0x80,
  0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x10, 0x00,
  0x60, 0x20, 0x1F, 0xFF, 0xFE, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x01,
  0x80, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x18,
  0xC3, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x0C, 0x10, 0x00, 0x41, 0x00, 0x06, 0x30, 0x00,
  0x32, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x04, 0xC0,
  0x00, 0x46, 0x00, 0x04, 0x30, 0x00, 0x41, 0x00, 0x04, 0x18, 0x00, 0x81,
  0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x82, 0x08, 0x10,
  0x40, 0xF1, 0x38, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0x82, 0x08, 0x01, 0x83, 0x06, 0x00, 0x81, 0x01, 0x00, 0x81, 0x00,
  0x80, 0xC0, 0x80, 0x40, 0x40, 0xC0, 0x60, 0x40, 0x40, 0x30, 0x20, 0x20,
  0x10, 0x20, 0x10, 0x08, 0x30, 0x18, 0x04, 0x10, 0x0C, 0x02, 0x10, 0x04,
  0x03, 0x18, 0x62, 0x01, 0x08, 0xFD, 0x00, 0x88, 0xC3, 0x80, 0x8C, 0xC0,
  0xE0, 0xC4, 0x40, 0x50, 0x44, 0x60, 0x2F, 0xC6, 0x20, 0x10, 0x82, 0x10,
  0x08, 0x02, 0x18, 0x04, 0x03, 0x08, 0x02, 0x01, 0x04, 0x03, 0x01, 0x02,
  0x01, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0xC0, 0x40, 0x60, 0x40,
  0x20, 0x20, 0x40, 0x10, 0x30, 0x60, 0x08, 0x10, 0x20, 0x06, 0x10, 0x20,
  0x01, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00,
  0x04, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x10,
  0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x03, 0x00, 0x10, 0x18,
  0x00, 0x40, 0x40, 0x01, 0x86, 0x00, 0x02, 0x30, 0x00, 0x0F, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xA0, 0x00, 0x0C, 0x80, 0x00, 0xC1, 0x00, 0x06, 0x06,
  0x01, 0x30, 0x08, 0x0C, 0x80, 0x30, 0x24, 0x00, 0x41, 0x90, 0x01, 0x84,
  0xC0, 0x02, 0x22, 0x00, 0x05, 0x88, 0x00, 0x14, 0x20, 0x00, 0x20, 0xC0,
  0x01, 0xC3, 0x00, 0x09, 0x06, 0x00, 0x46, 0x0C, 0x06, 0x08, 0x1F, 0xE0,
  0x30, 0x25, 0xA4, 0x94, 0x92, 0x00, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x08, 0x10, 0x0C,
  0x20, 0x06, 0x40, 0x02, 0x9F, 0x03, 0xC0, 0x0A, 0x00, 0x22, 0x00, 0x84,
  0x02, 0x0C, 0x18, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFC, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x30, 0x86, 0x10, 0x42, 0x08, 0x41,
  0x08, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xE0, 0x06, 0x06, 0x01, 0x80, 0x60, 0x20, 0x04, 0x08, 0x00, 0x83,
  0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x98,
  0x00, 0x32, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x48, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x4C, 0x00, 0x09, 0x80,
  0x03, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x43, 0x00,
  0x08, 0x60, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x18, 0x04, 0x01, 0x83,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0x81, 0x43, 0x23, 0x36, 0x16, 0x0A, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xC0, 0x60,
  0x10, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x18, 0x06,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x18, 0x01, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x05, 0x00,
  0x00, 0xF0, 0x00, 0x0A, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x06, 0x20,
  0x00, 0xC6, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x40, 0x06, 0x04,
  0x00, 0xC0, 0x80, 0x08, 0x08, 0x01, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0xC0, 0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x06, 0x00,
  0x30, 0x40, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0x80, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x38, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xFC, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x41, 0xE0, 0x08, 0xF7, 0x01, 0x60, 0x10,
  0x58, 0x01, 0x0A, 0x00, 0x31, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09,
  0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x23,
  0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x08, 0x08, 0x02, 0x01,
  0x81, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0x80,
  0x40, 0x10, 0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0x20, 0x04, 0x02,
  0x00, 0xC0, 0x10, 0x18, 0x00, 0x86, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x38, 0x80, 0x0E, 0x06, 0x01, 0x80, 0x20, 0x30, 0x01, 0x06, 0x00, 0x18,
  0x40, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x08, 0xC0, 0x01, 0x04, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x06, 0x02, 0x01,
  0x80, 0x20, 0x60, 0x06, 0x08, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01, 0x18,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x44, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0xE1, 0x00, 0x28, 0x30,
  0x19, 0x03, 0xFE, 0x20, 0x04, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x00, 0x06,
  0x1C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x30, 0x60, 0x00, 0xC0, 0x30, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x82, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0xC0, 0x0F,
  0x80, 0x44, 0x01, 0x87, 0x02, 0x60, 0x10, 0x10, 0x12, 0x01, 0x00, 0x80,
  0x90, 0x10, 0x04, 0x05, 0x81, 0x80, 0x40, 0x28, 0x08, 0x02, 0x01, 0x40,
  0xC0, 0x10, 0x1E, 0x04, 0x01, 0x80, 0xB0, 0x20, 0x08, 0x05, 0x01, 0x00,
  0x40, 0x28, 0x18, 0x06, 0x02, 0x40, 0xC0, 0x30, 0x12, 0x06, 0x01, 0x81,
  0x90, 0x10, 0x14, 0x08, 0x80, 0x81, 0x20, 0x84, 0x06, 0x19, 0x18, 0x30,
  0x1F, 0x07, 0x81, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x02, 0x40, 0x00,
  0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20,
  0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x10,
  0x08, 0x00, 0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x30, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20,
  0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x01, 0xFF, 0xC0, 0x04, 0x01, 0xC0, 0x10, 0x01, 0x80, 0x40, 0x02, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x10, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x04, 0x04, 0x00, 0x20,
  0x30, 0x03, 0x00, 0x80, 0xF8, 0x03, 0xFF, 0xC0, 0x08, 0x01, 0x80, 0x20,
  0x01, 0x01, 0x80, 0x06, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00,
  0x83, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x82,
  0x00, 0x04, 0x18, 0x00, 0x30, 0x40, 0x01, 0x81, 0x00, 0x0C, 0x04, 0x01,
  0xC0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x06, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x40, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0x00, 0xE0, 0x01, 0x00, 0x30, 0x01, 0x00, 0x08, 0x03,
  0x00, 0x04, 0x02, 0x00, 0x06, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x06,
  0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20,
  0x00, 0x30, 0x20, 0x00, 0x20, 0x20, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40,
  0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x38, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x07, 0xF8, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x60,
  0x00, 0x20, 0x20, 0x00, 0x20, 0x10, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x07,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08,
  0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x20, 0x00,
  0x10, 0x08, 0x00, 0x04, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x30, 0x10, 0x00, 0x08, 0x04, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x60, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x04, 0x02, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x40, 0x40, 0x00, 0x30, 0x10, 0x00, 0x08, 0x04, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x08,
  0x00, 0x04, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0x40, 0x00, 0x30,
  0x10, 0x00, 0x08, 0x04, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0x01, 0xFC,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x02, 0x38, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x03, 0x01, 0x00,
  0x04, 0x01, 0x00, 0x08, 0x03, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x02, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04, 0x0C,
  0x00, 0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x09, 0xC0, 0x00, 0x09, 0x20, 0x00, 0x0A, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x10, 0x00, 0x10, 0x10, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01,
  0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x3F, 0xFF, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0A, 0x02, 0xC0, 0x00, 0x1A, 0x02,
  0x40, 0x00, 0x16, 0x02, 0x40, 0x00, 0x34, 0x02, 0x40, 0x00, 0x24, 0x06,
  0x40, 0x00, 0x44, 0x04, 0x40, 0x00, 0x4C, 0x04, 0x40, 0x00, 0x8C, 0x04,
  0x60, 0x01, 0x88, 0x04, 0x20, 0x01, 0x08, 0x0C, 0x20, 0x03, 0x08, 0x08,
  0x20, 0x02, 0x18, 0x08, 0x20, 0x06, 0x10, 0x08, 0x20, 0x04, 0x10, 0x08,
  0x20, 0x08, 0x10, 0x18, 0x20, 0x08, 0x10, 0x10, 0x30, 0x10, 0x30, 0x10,
  0x10, 0x30, 0x20, 0x10, 0x10, 0x20, 0x20, 0x30, 0x10, 0x60, 0x20, 0x20,
  0x10, 0x40, 0x20, 0x20, 0x10, 0xC0, 0x60, 0x20, 0x10, 0x80, 0x40, 0x20,
  0x11, 0x00, 0x40, 0x60, 0x19, 0x00, 0x40, 0x40, 0x0A, 0x00, 0xC0, 0x40,
  0x0E, 0x00, 0x80, 0x40, 0x0C, 0x00, 0x80, 0xC0, 0x0C, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0F, 0x00, 0x02,
  0x02, 0x40, 0x00, 0x80, 0x90, 0x00, 0x20, 0x26, 0x00, 0x18, 0x08, 0x80,
  0x04, 0x06, 0x20, 0x01, 0x01, 0x0C, 0x00, 0x40, 0x41, 0x00, 0x30, 0x10,
  0x40, 0x08, 0x04, 0x18, 0x02, 0x03, 0x02, 0x00, 0x80, 0x80, 0x80, 0x20,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x01, 0x80, 0x60,
  0x40, 0x40, 0x08, 0x10, 0x10, 0x02, 0x0C, 0x04, 0x00, 0xC2, 0x03, 0x00,
  0x10, 0x80, 0x80, 0x04, 0x20, 0x20, 0x01, 0x98, 0x08, 0x00, 0x26, 0x02,
  0x00, 0x09, 0x01, 0x80, 0x03, 0x40, 0x40, 0x00, 0x50, 0x10, 0x00, 0x1C,
  0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x80, 0x00,
  0x83, 0x00, 0x01, 0x84, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00,
  0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x23, 0x00, 0x00,
  0xC2, 0x00, 0x03, 0x04, 0x00, 0x04, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x08, 0x07, 0x00,
  0x40, 0x0C, 0x02, 0x00, 0x20, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x08, 0x00,
  0x20, 0x40, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08,
  0x00, 0x20, 0x40, 0x01, 0x06, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x18,
  0x08, 0x03, 0x00, 0x7F, 0xE0, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x80, 0x00, 0x83,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC2,
  0x00, 0x03, 0x04, 0x00, 0x04, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x0C,
  0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x08, 0x07, 0x00, 0x40, 0x0C,
  0x02, 0x00, 0x20, 0x30, 0x01, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40,
  0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x20,
  0x40, 0x03, 0x06, 0x00, 0x30, 0x20, 0x03, 0x01, 0x00, 0x30, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x06, 0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0xC0, 0x08,
  0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x06, 0x01, 0x00, 0x10,
  0x08, 0x00, 0x80, 0xC0, 0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x70, 0x06,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x03, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x18, 0x00, 0x04, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x60,
  0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x30, 0xC0, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x40, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x60, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0xC0,
  0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44,
  0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x30,
  0x40, 0x02, 0x04, 0x00, 0x60, 0x60, 0x04, 0x06, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x20, 0x10, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04,
  0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21,
  0x00, 0x03, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x50, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x20, 0x02, 0x60, 0x06, 0x40, 0x04,
  0xC0, 0x08, 0x80, 0x19, 0x80, 0x31, 0x00, 0x21, 0x00, 0x42, 0x00, 0xC2,
  0x00, 0x84, 0x01, 0x04, 0x02, 0x08, 0x02, 0x08, 0x04, 0x10, 0x08, 0x10,
  0x18, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x81,
  0x01, 0x83, 0x01, 0x02, 0x03, 0x04, 0x02, 0x08, 0x06, 0x18, 0x04, 0x10,
  0x0C, 0x20, 0x08, 0x40, 0x18, 0xC0, 0x10, 0x80, 0x11, 0x00, 0x23, 0x00,
  0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0x98, 0x00, 0x90, 0x01, 0x20, 0x01,
  0x60, 0x02, 0x40, 0x02, 0x80, 0x05, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x20, 0x00, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x02, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0x60, 0x60,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x20, 0x00, 0x06, 0x30, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x50, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x40, 0x00, 0x04, 0x30, 0x00, 0x04, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x00, 0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x01, 0x00, 0x04, 0x01, 0x80, 0x02, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x40, 0x80, 0x00, 0x78, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00,
  0x84, 0x00, 0x30, 0xC0, 0x04, 0x08, 0x01, 0x01, 0x00, 0x60, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x01, 0x04, 0x00, 0x21, 0x80,
  0x06, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0xFE, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x03, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xB0,
  0x00, 0x32, 0x00, 0x04, 0x40, 0x01, 0x0C, 0x00, 0x60, 0x80, 0x08, 0x10,
  0x02, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x04, 0x00, 0xC1, 0x80, 0x08,
  0x20, 0x01, 0x08, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x0C,
  0xFF, 0xFE, 0x8C, 0x46, 0x21, 0x10, 0x00, 0xFC, 0x20, 0x60, 0xC8, 0x18,
  0x0D, 0x06, 0x00, 0xA1, 0x80, 0x14, 0x20, 0x01, 0x8C, 0x00, 0x21, 0x00,
  0x04, 0x60, 0x00, 0x88, 0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00,
  0xC2, 0x00, 0x18, 0x40, 0x05, 0x0C, 0x01, 0x40, 0x80, 0x68, 0x18, 0x19,
  0x01, 0xFC, 0x20, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0xFC, 0x02, 0x30, 0xC0, 0x58, 0x04, 0x16, 0x00,
  0xC2, 0x80, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x23, 0x00, 0x04, 0x60, 0x00,
  0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x03,
  0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18,
  0xC0, 0x02, 0x1C, 0x00, 0x82, 0x80, 0x30, 0x88, 0x1C, 0x10, 0xFE, 0x00,
  0x00, 0xFF, 0x03, 0x81, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x10, 0x1F, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x3F, 0x08, 0x06, 0x0C, 0x40, 0x60, 0x12, 0x06, 0x00,
  0x70, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18,
  0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x43, 0x00, 0x06,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00,
  0x0E, 0x08, 0x00, 0x60, 0x40, 0x07, 0x03, 0x00, 0x68, 0x08, 0x06, 0x40,
  0x60, 0x64, 0x00, 0xFC, 0x20, 0x00, 0x00, 0xFC, 0x03, 0x86, 0x06, 0x03,
  0x0C, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x02, 0x60, 0x06,
  0x40, 0x0C, 0x40, 0x38, 0x7F, 0xC0, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x18, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x04, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x08, 0x06, 0x04, 0x40, 0x60, 0x12,
  0x06, 0x00, 0x50, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x43,
  0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00,
  0xC1, 0x00, 0x0E, 0x08, 0x00, 0x60, 0x40, 0x07, 0x03, 0x00, 0x68, 0x08,
  0x06, 0x40, 0x60, 0x66, 0x01, 0xFC, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x80, 0x18, 0x03, 0xC7, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x43,
  0xF0, 0x13, 0x82, 0x05, 0x80, 0x42, 0xC0, 0x10, 0xA0, 0x04, 0x30, 0x01,
  0x0C, 0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4,
  0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00,
  0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08,
  0xC0, 0x02, 0x20, 0x00, 0x80, 0x03, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x01, 0x30, 0x03, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x0C, 0x10,
  0x06, 0x04, 0x03, 0x03, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x08, 0x10,
  0x06, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0xA0, 0x03,
  0x48, 0x00, 0xA1, 0x00, 0x30, 0x40, 0x08, 0x18, 0x02, 0x02, 0x01, 0x80,
  0x80, 0x40, 0x30, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x03, 0x00, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x04, 0x3E, 0x03, 0xF0, 0x13, 0x0C, 0x30, 0x60, 0x50, 0x09, 0x80,
  0x82, 0x80, 0x2C, 0x03, 0x0A, 0x00, 0xA0, 0x04, 0x30, 0x03, 0x00, 0x10,
  0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x20, 0x03, 0x18, 0x00, 0x80, 0x08, 0x40,
  0x02, 0x00, 0x21, 0x00, 0x10, 0x00, 0x84, 0x00, 0x40, 0x06, 0x30, 0x01,
  0x00, 0x10, 0x80, 0x04, 0x00, 0x42, 0x00, 0x30, 0x01, 0x08, 0x00, 0x80,
  0x04, 0x20, 0x02, 0x00, 0x31, 0x80, 0x08, 0x00, 0x84, 0x00, 0x20, 0x02,
  0x10, 0x01, 0x80, 0x08, 0x40, 0x04, 0x00, 0x21, 0x00, 0x10, 0x01, 0x88,
  0x00, 0x40, 0x04, 0x20, 0x03, 0x00, 0x10, 0x04, 0x3F, 0x01, 0x38, 0x60,
  0x58, 0x04, 0x2C, 0x01, 0x0A, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x60,
  0x01, 0x18, 0x00, 0x44, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x30, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0xE0, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x18, 0x00,
  0xC4, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x33, 0x00, 0x18, 0x40, 0x04,
  0x18, 0x02, 0x03, 0x03, 0x00, 0x7F, 0x80, 0x01, 0x0F, 0xC0, 0x09, 0xC3,
  0x00, 0x58, 0x04, 0x04, 0x80, 0x30, 0x28, 0x00, 0x81, 0xC0, 0x04, 0x0C,
  0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00,
  0x02, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81,
  0xC0, 0x08, 0x0A, 0x00, 0xC0, 0xC8, 0x18, 0x04, 0x3F, 0x80, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x20, 0x60, 0xC4, 0x18, 0x04, 0x86, 0x00, 0xD1, 0x80,
  0x0C, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0xE2, 0x00, 0x18, 0x40, 0x07,
  0x0C, 0x01, 0xA0, 0x80, 0x64, 0x18, 0x19, 0x81, 0xFC, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x04, 0x3E,
  0x09, 0x80, 0x16, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x06, 0x03, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0xC0, 0x30, 0x7F, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x1F, 0xF8, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xF8,
  0x00, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00,
  0xC4, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42,
  0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00,
  0x08, 0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0xE2, 0x00, 0x30, 0x80, 0x14,
  0x30, 0x09, 0x06, 0x04, 0x40, 0xFE, 0x30, 0xC0, 0x01, 0x40, 0x03, 0x40,
  0x02, 0x40, 0x06, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40,
  0x10, 0x40, 0x30, 0x60, 0x20, 0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x20,
  0x80, 0x21, 0x00, 0x21, 0x00, 0x22, 0x00, 0x26, 0x00, 0x24, 0x00, 0x2C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x0C,
  0x00, 0xA0, 0x06, 0x00, 0x50, 0x05, 0x00, 0x48, 0x02, 0x80, 0x24, 0x02,
  0x40, 0x22, 0x01, 0x20, 0x11, 0x01, 0x10, 0x18, 0x80, 0x88, 0x08, 0x40,
  0xC4, 0x0C, 0x20, 0x42, 0x04, 0x10, 0x61, 0x02, 0x08, 0x20, 0xC2, 0x04,
  0x30, 0x61, 0x02, 0x10, 0x11, 0x01, 0x18, 0x08, 0x80, 0x88, 0x04, 0xC0,
  0x4C, 0x02, 0x40, 0x24, 0x01, 0x60, 0x12, 0x00, 0xA0, 0x0A, 0x00, 0x50,
  0x05, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x02, 0x00,
  0x18, 0x10, 0x01, 0x80, 0x40, 0x18, 0x02, 0x00, 0x80, 0x18, 0x08, 0x00,
  0x40, 0x80, 0x02, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x02,
  0x40, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x30, 0x60, 0x01, 0x01, 0x00,
  0x10, 0x08, 0x01, 0x00, 0x60, 0x18, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0x80, 0x06, 0x00, 0x80,
  0x04, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x18, 0x00, 0x40,
  0x10, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x40, 0x00, 0x40,
  0x40, 0x00, 0x40, 0x80, 0x00, 0x40, 0x80, 0x00, 0x41, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x22, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x28, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x18, 0xE0, 0x18, 0x06, 0x0E, 0x00, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 32, 9, 1, -32 },
  { 37, 9, 11, 13, 5, -32 },
  { 50, 23, 32, 24, 1, -32 },
  { 142, 20, 37, 21, 1, -34 },
  { 235, 25, 34, 30, 3, -33 },
  { 342, 22, 33, 25, 1, -33 },
  { 433, 3, 11, 7, 5, -32 },
  { 438, 13, 39, 11, 1, -32 },
  { 502, 13, 39, 11, -3, -32 },
  { 566, 15, 16, 20, 6, -34 },
  { 596, 18, 20, 23, 3, -26 },
  { 641, 6, 11, 8, -2, -5 },
  { 650, 11, 1, 13, 1, -13 },
  { 652, 2, 3, 9, 1, -3 },
  { 653, 19, 32, 14, -2, -32 },
  { 729, 19, 33, 21, 2, -33 },
  { 808, 9, 32, 21, 7, -32 },
  { 844, 20, 33, 21, 0, -33 },
  { 927, 21, 33, 21, 0, -33 },
  { 1014, 20, 32, 21, 0, -32 },
  { 1094, 20, 32, 21, 1, -32 },
  { 1174, 19, 33, 21, 2, -33 },
  { 1253, 18, 32, 21, 4, -32 },
  { 1325, 20, 33, 21, 1, -33 },
  { 1408, 19, 33, 21, 1, -33 },
  { 1487, 7, 24, 9, 1, -24 },
  { 1508, 10, 30, 9, -2, -24 },
  { 1546, 18, 20, 23, 3, -26 },
  { 1591, 18, 10, 23, 3, -21 },
  { 1614, 18, 20, 23, 3, -26 },
  { 1659, 14, 33, 15, 3, -33 },
  { 1717, 29, 36, 32, 2, -32 },
  { 1848, 21, 32, 21, -3, -32 },
  { 1932, 22, 32, 23, 1, -32 },
  { 2020, 22, 33, 23, 3, -33 },
  { 2111, 24, 32, 26, 1, -32 },
  { 2207, 21, 32, 21, 1, -32 },
  { 2291, 21, 32, 19, 1, -32 },
  { 2375, 24, 33, 27, 3, -33 },
  { 2474, 26, 32, 27, 1, -32 },
  { 2578, 14, 32, 11, -1, -32 },
  { 2634, 17, 40, 9, -7, -32 },
  { 2719, 24, 32, 21, 1, -32 },
  { 2815, 14, 32, 19, 1, -32 },
  { 2871, 32, 32, 33, 1, -32 },
  { 2999, 26, 32, 27, 1, -32 },
  { 3103, 23, 33, 28, 3, -33 },
  { 3198, 21, 32, 22, 1, -32 },
  { 3282, 23, 41, 28, 3, -33 },
  { 3400, 21, 32, 22, 1, -32 },
  { 3484, 21, 33, 20, 0, -33 },
  { 3571, 19, 32, 19, 4, -32 },
  { 3647, 24, 32, 27, 3, -32 },
  { 3743, 20, 32, 21, 4, -32 },
  { 3823, 31, 32, 33, 5, -32 },
  { 3947, 25, 32, 19, -3, -32 },
  { 4047, 19, 32, 19, 4, -32 },
  { 4123, 23, 32, 20, -1, -32 },
  { 4215, 17, 39, 13, -1, -32 },
  { 4298, 7, 32, 14, 4, -32 },
  { 4326, 17, 39, 13, -3, -32 },
  { 4409, 19, 18, 22, 2, -32 },
  { 4452, 15, 1, 15, -4, 5 },
  { 4454, 4, 7, 10, 7, -34 },
  { 4458, 19, 24, 22, 2, -24 },
  { 4515, 19, 34, 22, 1, -34 },
  { 4596, 16, 24, 17, 2, -24 },
  { 4644, 21, 34, 22, 2, -34 },
  { 4734, 16, 24, 19, 2, -24 },
  { 4782, 23, 45, 11, -6, -34 },
  { 4912, 21, 35, 22, 0, -24 },
  { 5004, 18, 34, 22, 1, -34 },
  { 5081, 8, 32, 8, 1, -32 },
  { 5113, 15, 43, 9, -6, -32 },
  { 5194, 18, 34, 17, 1, -34 },
  { 5271, 8, 34, 8, 1, -34 },
  { 5305, 30, 24, 33, 1, -24 },
  { 5395, 18, 24, 22, 1, -24 },
  { 5449, 18, 24, 22, 2, -24 },
  { 5503, 21, 34, 22, -1, -24 },
  { 5593, 19, 34, 22, 2, -24 },
  { 5674, 15, 24, 14, 1, -24 },
  { 5719, 16, 24, 17, 0, -24 },
  { 5767, 11, 30, 12, 2, -30 },
  { 5809, 18, 24, 22, 2, -24 },
  { 5863, 16, 24, 16, 2, -24 },
  { 5911, 25, 24, 26, 3, -24 },
  { 5986, 21, 24, 18, -2, -24 },
  { 6049, 24, 35, 17, -5, -24 },
  { 6154, 18, 24, 16, -1, -24 },
  { 6208, 16, 39, 14, 1, -32 },
  { 6286, 1, 45, 21, 11, -34 },
  { 6292, 16, 39, 14, -3, -32 },
  { 6370, 18, 4, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC45PT7B_H_
