#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0xB6, 0xE0, 0x09, 0x0A, 0x12, 0x7B,
  0x14, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x08, 0x7C, 0xA2, 0x43, 0x02,
  0x07, 0x0A, 0x15, 0x51, 0xC1, 0x00, 0x31, 0x52, 0x92, 0x94, 0x9B, 0xAD,
  0xD5, 0x19, 0x29, 0x49, 0x4E, 0x0C, 0x12, 0x22, 0x24, 0x18, 0x30, 0x49,
  0x8A, 0x86, 0x84, 0x7A, 0xF0, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21,
  0x04, 0x00, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0xC0, 0x27, 0x0E, 0xC9,
  0x00, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x56, 0xF0, 0x80, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00, 0x39, 0x14, 0x61, 0x86,
  0x18, 0x62, 0x8A, 0x2F, 0x00, 0x2E, 0x92, 0x52, 0x49, 0x00, 0x1C, 0x44,
  0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83, 0xE0, 0x3C, 0x04, 0x08, 0x10,
  0x47, 0x01, 0x02, 0x04, 0x0B, 0xE0, 0x02, 0x08, 0x28, 0xA1, 0x44, 0x91,
  0x44, 0x7E, 0x10, 0x20, 0x1E, 0x40, 0x81, 0x07, 0x80, 0x81, 0x02, 0x04,
  0x0B, 0xE0, 0x1C, 0x84, 0x20, 0xB3, 0x28, 0x61, 0x8A, 0x2F, 0x00, 0x7C,
  0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x08, 0x00, 0x1C, 0x44, 0x89, 0x12,
  0x47, 0x11, 0x42, 0x85, 0x09, 0xE0, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0xCE,
  0x82, 0x04, 0x13, 0xC0, 0x20, 0x00, 0x04, 0x10, 0x00, 0x00, 0x24, 0x48,
  0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x81,
  0x19, 0x88, 0x00, 0x70, 0x42, 0x11, 0x11, 0x10, 0x00, 0x20, 0x0F, 0x18,
  0x50, 0x31, 0x99, 0x2D, 0x16, 0x93, 0x49, 0xAD, 0x49, 0x20, 0x0F, 0x80,
  0x04, 0x08, 0x28, 0x51, 0x22, 0x4F, 0x91, 0x42, 0x86, 0x08, 0x1E, 0x21,
  0x21, 0x21, 0x22, 0x3C, 0x42, 0x42, 0x42, 0x44, 0xF8, 0x1E, 0x41, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0xF0, 0x1E, 0x21, 0x21, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x42, 0x84, 0xF8, 0x1E, 0x40, 0x81, 0x02, 0x07, 0x90,
  0x20, 0x41, 0x03, 0xE0, 0x1E, 0x40, 0x81, 0x02, 0x0F, 0x90, 0x20, 0x41,
  0x02, 0x00, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x8C, 0x82, 0x82, 0x82, 0x82,
  0x7C, 0x20, 0x90, 0x48, 0x24, 0x12, 0x11, 0xF9, 0x04, 0x82, 0x42, 0x41,
  0x20, 0x80, 0x32, 0x22, 0x22, 0x44, 0x44, 0xC0, 0x08, 0x42, 0x10, 0x88,
  0x42, 0x10, 0x88, 0x42, 0x60, 0x21, 0x22, 0x24, 0x28, 0x30, 0x70, 0x48,
  0x48, 0x48, 0x84, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x3E, 0x10,
  0x24, 0x04, 0xC1, 0x18, 0x53, 0x0C, 0xA2, 0x94, 0x52, 0x52, 0x4C, 0x91,
  0x92, 0x22, 0x00, 0x20, 0x88, 0x4C, 0x25, 0x12, 0x92, 0x49, 0x14, 0x8A,
  0x45, 0x41, 0x20, 0x80, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x78, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x9E, 0x20, 0x40, 0x82,
  0x00, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x68,
  0x10, 0x08, 0x08, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x9E, 0x24, 0x44, 0x8A,
  0x10, 0x1E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x0B, 0xE0, 0xFE,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x00, 0x41, 0x41, 0x41,
  0x41, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x83, 0x06, 0x14, 0x28,
  0x89, 0x14, 0x28, 0x60, 0x81, 0x00, 0x88, 0x62, 0x19, 0x8A, 0x52, 0x94,
  0xA9, 0x4A, 0x53, 0x18, 0x86, 0x21, 0x08, 0x40, 0x21, 0x11, 0x12, 0x14,
  0x08, 0x08, 0x18, 0x24, 0x24, 0x44, 0x84, 0x83, 0x09, 0x22, 0x45, 0x0C,
  0x08, 0x20, 0x40, 0x81, 0x00, 0x3E, 0x04, 0x10, 0x20, 0x82, 0x08, 0x10,
  0x41, 0x03, 0xE0, 0x19, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x0E, 0x00,
  0x91, 0x24, 0x92, 0x24, 0x80, 0x1C, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x08, 0xE0, 0x10, 0xA2, 0x92, 0x46, 0x10, 0xF8, 0x90, 0x3D, 0x18,
  0x62, 0x8A, 0x29, 0xBA, 0x20, 0x40, 0x81, 0xE2, 0x28, 0x50, 0xA1, 0x45,
  0x0B, 0xE0, 0x3A, 0x21, 0x08, 0x42, 0x1E, 0x02, 0x04, 0x11, 0xE4, 0x50,
  0xA1, 0x44, 0x89, 0x13, 0xE0, 0x3A, 0x63, 0xE8, 0x42, 0x1E, 0x07, 0x08,
  0x08, 0x1C, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0xC0, 0x1E, 0x45, 0x0A, 0x18, 0x50, 0xA1, 0x3E, 0x04, 0x10, 0x27, 0x80,
  0x20, 0x40, 0x81, 0xE2, 0x28, 0x51, 0x22, 0x45, 0x0A, 0x10, 0x20, 0x14,
  0x92, 0x52, 0x00, 0x08, 0x00, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x22,
  0x00, 0x20, 0x82, 0x09, 0x49, 0x46, 0x14, 0x52, 0x28, 0x80, 0x24, 0x94,
  0x92, 0x52, 0x00, 0x3D, 0xC8, 0x94, 0x45, 0x11, 0x44, 0x51, 0x18, 0x86,
  0x22, 0x3C, 0x94, 0x51, 0x45, 0x18, 0x61, 0x39, 0x18, 0x61, 0x86, 0x28,
  0xBC, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0xA1, 0x7C, 0x81, 0x02, 0x00, 0x3D,
  0x18, 0x61, 0x8A, 0x28, 0xBE, 0x08, 0x41, 0x04, 0x39, 0x10, 0x84, 0x22,
  0x10, 0x3A, 0x10, 0x41, 0x04, 0x3E, 0x4B, 0xC9, 0x24, 0x98, 0x46, 0x18,
  0x62, 0x8A, 0x29, 0x3A, 0x8C, 0x65, 0x2A, 0x53, 0x10, 0x91, 0x91, 0xAA,
  0xAA, 0xCA, 0xCC, 0x88, 0x88, 0x22, 0x48, 0x50, 0xC1, 0x05, 0x12, 0x62,
  0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18, 0x08, 0x10, 0x10, 0x20, 0xC0,
  0x3C, 0x21, 0x04, 0x21, 0x08, 0x3C, 0x0C, 0x41, 0x08, 0x20, 0x8C, 0x10,
  0x41, 0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x42, 0x10, 0x88, 0x22, 0x10,
  0x88, 0x4E, 0x00, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 4, 2, -11 },
  { 8, 8, 11, 8, 0, -11 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 8, 11, 10, 1, -11 },
  { 41, 8, 11, 8, 0, -11 },
  { 52, 1, 4, 2, 2, -11 },
  { 53, 5, 13, 4, 0, -11 },
  { 62, 4, 13, 4, -1, -11 },
  { 69, 5, 5, 7, 2, -11 },
  { 73, 6, 7, 8, 1, -9 },
  { 79, 2, 4, 3, -1, -2 },
  { 80, 4, 1, 4, 0, -5 },
  { 81, 1, 1, 3, 0, -1 },
  { 82, 7, 11, 5, -1, -11 },
  { 92, 6, 11, 7, 1, -11 },
  { 101, 3, 11, 7, 2, -11 },
  { 106, 7, 11, 7, 0, -11 },
  { 116, 7, 11, 7, 0, -11 },
  { 126, 7, 11, 7, 0, -11 },
  { 136, 7, 11, 7, 0, -11 },
  { 146, 6, 11, 7, 1, -11 },
  { 155, 6, 11, 7, 1, -11 },
  { 164, 7, 11, 7, 0, -11 },
  { 174, 7, 11, 7, 0, -11 },
  { 184, 3, 8, 3, 0, -8 },
  { 187, 4, 10, 3, -1, -8 },
  { 192, 6, 7, 8, 1, -9 },
  { 198, 6, 3, 8, 1, -7 },
  { 201, 6, 7, 8, 1, -9 },
  { 207, 5, 11, 5, 1, -11 },
  { 214, 9, 12, 11, 1, -11 },
  { 228, 7, 11, 7, -1, -11 },
  { 238, 8, 11, 8, 0, -11 },
  { 249, 7, 11, 8, 1, -11 },
  { 259, 8, 11, 9, 0, -11 },
  { 270, 7, 11, 7, 0, -11 },
  { 280, 7, 11, 6, 0, -11 },
  { 290, 8, 11, 9, 1, -11 },
  { 301, 9, 11, 9, 0, -11 },
  { 314, 4, 11, 4, 0, -11 },
  { 320, 5, 14, 3, -2, -11 },
  { 329, 8, 11, 7, 0, -11 },
  { 340, 5, 11, 6, 0, -11 },
  { 347, 11, 11, 11, 0, -11 },
  { 363, 9, 11, 9, 0, -11 },
  { 376, 8, 11, 9, 1, -11 },
  { 387, 7, 11, 7, 0, -11 },
  { 397, 8, 14, 9, 1, -11 },
  { 411, 7, 11, 7, 0, -11 },
  { 421, 7, 11, 7, 0, -11 },
  { 431, 7, 11, 6, 1, -11 },
  { 441, 8, 11, 9, 1, -11 },
  { 452, 7, 11, 7, 1, -11 },
  { 462, 10, 11, 11, 2, -11 },
  { 476, 8, 11, 6, -1, -11 },
  { 487, 7, 11, 6, 1, -11 },
  { 497, 7, 11, 7, 0, -11 },
  { 507, 5, 13, 4, 0, -11 },
  { 516, 3, 11, 5, 1, -11 },
  { 521, 6, 13, 4, -1, -11 },
  { 531, 6, 6, 7, 1, -11 },
  { 536, 5, 1, 5, -1, 1 },
  { 537, 2, 2, 3, 2, -11 },
  { 538, 6, 8, 7, 1, -8 },
  { 544, 7, 11, 7, 0, -11 },
  { 554, 5, 8, 6, 1, -8 },
  { 559, 7, 11, 7, 1, -11 },
  { 569, 5, 8, 6, 1, -8 },
  { 574, 8, 15, 4, -2, -11 },
  { 589, 7, 12, 7, 0, -8 },
  { 600, 7, 11, 7, 0, -11 },
  { 610, 3, 11, 3, 0, -11 },
  { 615, 5, 15, 3, -2, -11 },
  { 625, 6, 11, 6, 0, -11 },
  { 634, 3, 11, 3, 0, -11 },
  { 639, 10, 8, 11, 0, -8 },
  { 649, 6, 8, 7, 0, -8 },
  { 655, 6, 8, 7, 1, -8 },
  { 661, 7, 11, 7, 0, -8 },
  { 671, 6, 12, 7, 1, -8 },
  { 680, 5, 8, 5, 0, -8 },
  { 685, 5, 8, 6, 0, -8 },
  { 690, 3, 10, 4, 1, -10 },
  { 694, 6, 8, 7, 1, -8 },
  { 700, 5, 8, 5, 1, -8 },
  { 705, 8, 8, 9, 1, -8 },
  { 713, 7, 8, 6, -1, -8 },
  { 720, 8, 12, 6, -2, -8 },
  { 732, 6, 8, 5, 0, -8 },
  { 738, 6, 13, 5, 0, -11 },
  { 748, 1, 15, 7, 3, -11 },
  { 750, 5, 13, 5, -1, -11 },
  { 759, 6, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC15PT7B_H_
