#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x52, 0x01, 0x00, 0x55, 0x99, 0xA0, 0x04, 0x40,
  0x90, 0x12, 0x04, 0x43, 0xFE, 0x12, 0x04, 0x40, 0x88, 0x12, 0x1D, 0xF0,
  0x88, 0x11, 0x02, 0x40, 0x88, 0x00, 0x04, 0x0E, 0x35, 0x48, 0x48, 0x48,
  0x28, 0x10, 0x1C, 0x12, 0x12, 0x12, 0x14, 0xF8, 0x20, 0x20, 0x3C, 0x28,
  0x89, 0x12, 0x22, 0x48, 0x91, 0x14, 0xE2, 0xAC, 0xA9, 0x69, 0x21, 0x44,
  0x48, 0x91, 0x12, 0x22, 0x83, 0x80, 0x06, 0x02, 0x41, 0x08, 0x42, 0x11,
  0x04, 0x40, 0xE0, 0x20, 0x34, 0x10, 0x94, 0x26, 0x06, 0x81, 0x20, 0xA7,
  0xC8, 0x5A, 0x80, 0x08, 0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x80, 0x18, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88,
  0x80, 0x09, 0x11, 0xA0, 0xF2, 0x89, 0x01, 0x00, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x29, 0x48, 0xF0, 0x80, 0x01, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x00, 0x0E, 0x11, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x84, 0x84, 0x78, 0x35, 0x91, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x1F, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x07, 0xF0, 0x1F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x78,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x27, 0xE0, 0x00, 0x80, 0xC0, 0xA0,
  0xA0, 0x90, 0x88, 0x44, 0x42, 0x42, 0x41, 0x1F, 0xE0, 0x40, 0x40, 0x20,
  0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0xE0, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x27, 0xE0, 0x07, 0x84, 0x04, 0x04, 0x04, 0x02, 0x01, 0x71,
  0xC4, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x21, 0xE0, 0xFF, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x0F,
  0x88, 0x48, 0x24, 0x11, 0x08, 0x98, 0x30, 0x64, 0x41, 0x20, 0xA0, 0x50,
  0x24, 0x11, 0xF0, 0x3E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x41, 0x47, 0x3A,
  0x02, 0x02, 0x04, 0x08, 0xF0, 0x24, 0x00, 0x00, 0x02, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x02, 0x44, 0x88, 0x01, 0x02, 0x0C, 0x30, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x02,
  0x0C, 0x30, 0xC0, 0x7C, 0x10, 0x41, 0x04, 0x21, 0x08, 0x41, 0x04, 0x00,
  0x02, 0x00, 0x07, 0xE0, 0xC0, 0x88, 0x02, 0x80, 0x14, 0x7C, 0xC4, 0x46,
  0x22, 0x32, 0x11, 0x90, 0x94, 0x88, 0xA4, 0x49, 0x1D, 0x88, 0x00, 0x20,
  0x01, 0x80, 0x03, 0xE0, 0x01, 0x01, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x22,
  0x21, 0x1F, 0x90, 0x50, 0x28, 0x18, 0x0C, 0x04, 0x3F, 0x10, 0x48, 0x24,
  0x14, 0x0A, 0x09, 0xF8, 0x86, 0x41, 0x40, 0xA0, 0x50, 0x28, 0x27, 0xE0,
  0x0F, 0xC4, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x40, 0x0F, 0x80, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x04, 0x86, 0x3E, 0x00,
  0x3F, 0x90, 0x08, 0x04, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x07, 0xE0, 0x3F, 0x90, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0xFC, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0xE2, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x1E, 0x80, 0x50, 0x0A, 0x02, 0x40,
  0x44, 0x08, 0x7E, 0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x24, 0x04, 0x80,
  0x9F, 0xE2, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x00,
  0x1C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x43, 0x80, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0xE0, 0x20, 0xC8, 0x42, 0x20, 0x90, 0x48, 0x14, 0x07, 0x01, 0x20,
  0x48, 0x21, 0x08, 0x42, 0x10, 0x82, 0x20, 0x80, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0xF0, 0x10, 0x0C, 0xC0, 0x23, 0x01,
  0x8C, 0x0A, 0x50, 0x29, 0x41, 0x24, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24,
  0x48, 0x92, 0x22, 0x88, 0x8C, 0x22, 0x10, 0x80, 0x20, 0x26, 0x04, 0xC0,
  0x94, 0x24, 0x84, 0x90, 0x91, 0x12, 0x22, 0x44, 0x90, 0x52, 0x0A, 0x41,
  0x48, 0x11, 0x02, 0x00, 0x07, 0x01, 0x10, 0x41, 0x10, 0x14, 0x02, 0x80,
  0x50, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x08, 0x82, 0x0F,
  0x80, 0x3F, 0x10, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x0C, 0xF8, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0x01, 0x10, 0x41, 0x10, 0x14, 0x02,
  0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x08, 0x82,
  0x0E, 0x80, 0x20, 0x04, 0x00, 0x40, 0x3F, 0x10, 0x48, 0x24, 0x14, 0x0A,
  0x09, 0x08, 0xF8, 0x44, 0x42, 0x21, 0x10, 0x88, 0x24, 0x10, 0x1F, 0x90,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x27, 0xE0, 0xFF, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0x24, 0x04, 0x80, 0x90, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0x84, 0x10, 0x7C, 0x00,
  0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x10, 0x88, 0x48, 0x14,
  0x0C, 0x04, 0x02, 0x00, 0x81, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85,
  0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x22, 0x85, 0x0A, 0x14, 0x30,
  0x60, 0x41, 0x82, 0x04, 0x00, 0x10, 0x21, 0x08, 0x22, 0x04, 0x80, 0x90,
  0x0C, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x88, 0x20, 0x84, 0x11, 0x02,
  0x00, 0x81, 0x82, 0x84, 0x84, 0x48, 0x48, 0x50, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x1F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x3F, 0x80, 0x1E, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xF0,
  0x92, 0x44, 0x92, 0x48, 0x92, 0x40, 0x1E, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0xF0, 0x04, 0x0C, 0x12,
  0x22, 0x22, 0x41, 0x81, 0x81, 0xFE, 0x94, 0x1D, 0x23, 0x41, 0x41, 0x81,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x7C, 0x10, 0x08, 0x04, 0x02, 0x02, 0x71,
  0x44, 0xC2, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x16, 0x12, 0xF0, 0x1E,
  0x41, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0xE0, 0x00, 0x80, 0x40,
  0x20, 0x11, 0xC9, 0x19, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x24,
  0x31, 0xE8, 0x1C, 0x45, 0x0A, 0x18, 0x5F, 0x20, 0x40, 0x81, 0x01, 0xF0,
  0x01, 0xC0, 0x80, 0x20, 0x08, 0x0F, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x03,
  0x00, 0x0E, 0x88, 0xC8, 0x24, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x21,
  0x8F, 0x40, 0x40, 0x20, 0x10, 0x11, 0xF0, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x71, 0xC4, 0x82, 0x41, 0x20, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x08,
  0x10, 0x02, 0x22, 0x22, 0x44, 0x44, 0x48, 0x02, 0x00, 0x00, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x43, 0x00,
  0x10, 0x10, 0x10, 0x10, 0x21, 0x21, 0x22, 0x24, 0x28, 0x58, 0x68, 0x48,
  0x44, 0x44, 0x82, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44, 0x80, 0x2E,
  0x38, 0xC5, 0x12, 0x08, 0x48, 0x41, 0x21, 0x05, 0x04, 0x24, 0x10, 0x90,
  0x82, 0x42, 0x09, 0x08, 0x28, 0x21, 0x00, 0x27, 0x1C, 0x48, 0x24, 0x12,
  0x0A, 0x09, 0x04, 0x82, 0x41, 0x20, 0xA0, 0x80, 0x1C, 0x22, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x13, 0x85, 0x11, 0x84, 0x41,
  0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x45, 0xE1, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x86, 0x7A, 0x04, 0x04, 0x04, 0x04, 0x08, 0x26, 0x70, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x00, 0x1E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x0B, 0xE0, 0x21, 0x3E, 0x84, 0x22, 0x10, 0x84, 0x21, 0x0E, 0x00,
  0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0xFC, 0x83,
  0x06, 0x14, 0x28, 0x91, 0x24, 0x28, 0x60, 0x81, 0x00, 0x84, 0x30, 0x86,
  0x30, 0xC6, 0x29, 0x25, 0x25, 0x28, 0xA5, 0x18, 0xC3, 0x18, 0x42, 0x08,
  0x00, 0x20, 0x88, 0x44, 0x41, 0x40, 0xC0, 0x40, 0x30, 0x28, 0x24, 0x21,
  0x20, 0x80, 0x10, 0x44, 0x11, 0x08, 0x42, 0x11, 0x02, 0x40, 0xA0, 0x28,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x00, 0x3E, 0x04,
  0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x03, 0xE0, 0x0E, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x20, 0x80, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x60, 0xFF,
  0xFF, 0xF0, 0x1C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x06, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x10, 0xC0, 0x71, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 4, 1, -14 },
  { 7, 4, 5, 6, 2, -14 },
  { 10, 11, 14, 10, 0, -14 },
  { 30, 8, 16, 9, 1, -15 },
  { 46, 11, 14, 13, 1, -14 },
  { 66, 10, 15, 11, 0, -15 },
  { 85, 2, 5, 3, 2, -14 },
  { 87, 5, 17, 5, 1, -14 },
  { 98, 5, 17, 5, -1, -14 },
  { 109, 7, 7, 9, 2, -15 },
  { 116, 8, 10, 10, 1, -12 },
  { 126, 3, 5, 3, -1, -2 },
  { 128, 4, 1, 6, 1, -6 },
  { 129, 1, 1, 4, 1, -1 },
  { 130, 9, 14, 6, -1, -14 },
  { 146, 8, 15, 9, 1, -15 },
  { 161, 4, 14, 9, 3, -14 },
  { 168, 9, 14, 9, 0, -14 },
  { 184, 9, 14, 9, 0, -14 },
  { 200, 9, 14, 9, 0, -14 },
  { 216, 9, 14, 9, 0, -14 },
  { 232, 9, 15, 9, 1, -15 },
  { 249, 8, 14, 9, 2, -14 },
  { 263, 9, 14, 9, 0, -14 },
  { 279, 8, 14, 9, 1, -14 },
  { 293, 3, 11, 4, 0, -11 },
  { 298, 4, 14, 4, -1, -11 },
  { 305, 8, 9, 10, 1, -12 },
  { 314, 8, 4, 10, 1, -9 },
  { 318, 8, 9, 10, 1, -12 },
  { 327, 6, 14, 7, 1, -14 },
  { 338, 13, 16, 14, 1, -14 },
  { 364, 9, 14, 9, -1, -14 },
  { 380, 9, 14, 10, 1, -14 },
  { 396, 10, 14, 10, 1, -14 },
  { 414, 10, 14, 12, 1, -14 },
  { 432, 9, 14, 9, 1, -14 },
  { 448, 9, 14, 8, 1, -14 },
  { 464, 11, 14, 12, 1, -14 },
  { 484, 11, 14, 12, 1, -14 },
  { 504, 6, 14, 5, 0, -14 },
  { 515, 7, 17, 4, -3, -14 },
  { 530, 10, 14, 9, 1, -14 },
  { 548, 6, 14, 8, 1, -14 },
  { 559, 14, 14, 15, 1, -14 },
  { 584, 11, 14, 12, 1, -14 },
  { 604, 11, 15, 12, 1, -15 },
  { 625, 9, 14, 10, 1, -14 },
  { 641, 11, 18, 12, 1, -15 },
  { 666, 9, 14, 10, 1, -14 },
  { 682, 9, 14, 9, 0, -14 },
  { 698, 8, 14, 8, 2, -14 },
  { 712, 11, 14, 12, 1, -14 },
  { 732, 9, 14, 9, 2, -14 },
  { 748, 14, 14, 15, 2, -14 },
  { 773, 11, 14, 8, -1, -14 },
  { 793, 8, 14, 8, 2, -14 },
  { 807, 10, 14, 9, 0, -14 },
  { 825, 7, 17, 6, 0, -14 },
  { 840, 3, 14, 6, 2, -14 },
  { 846, 7, 17, 6, -1, -14 },
  { 861, 8, 8, 10, 1, -14 },
  { 869, 7, 1, 7, -2, 2 },
  { 870, 2, 3, 4, 3, -15 },
  { 871, 8, 11, 10, 1, -11 },
  { 882, 9, 15, 10, 0, -15 },
  { 899, 7, 11, 8, 1, -11 },
  { 909, 9, 15, 10, 1, -15 },
  { 926, 7, 11, 9, 1, -11 },
  { 936, 10, 20, 5, -3, -15 },
  { 961, 9, 16, 10, 0, -11 },
  { 979, 9, 15, 10, 0, -15 },
  { 996, 4, 14, 4, 0, -14 },
  { 1003, 7, 19, 4, -3, -14 },
  { 1020, 8, 15, 8, 0, -15 },
  { 1035, 4, 15, 4, 0, -15 },
  { 1043, 14, 11, 15, 0, -11 },
  { 1063, 9, 11, 10, 0, -11 },
  { 1076, 8, 11, 10, 1, -11 },
  { 1087, 10, 16, 10, -1, -11 },
  { 1107, 8, 16, 10, 1, -11 },
  { 1123, 7, 11, 6, 0, -11 },
  { 1133, 7, 11, 7, 0, -11 },
  { 1143, 5, 13, 5, 1, -13 },
  { 1152, 8, 11, 10, 1, -11 },
  { 1163, 7, 11, 7, 1, -11 },
  { 1173, 11, 11, 12, 1, -11 },
  { 1189, 9, 11, 8, -1, -11 },
  { 1202, 10, 16, 7, -2, -11 },
  { 1222, 7, 11, 7, 0, -11 },
  { 1232, 7, 17, 6, 1, -14 },
  { 1247, 1, 20, 9, 4, -15 },
  { 1250, 7, 17, 6, -1, -14 },
  { 1265, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC20PT7B_H_
