#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x26, 0x0C, 0xC1, 0x90,
  0x22, 0x04, 0xC0, 0x98, 0x32, 0x04, 0x40, 0x88, 0x13, 0x02, 0x40, 0xC8,
  0x11, 0x02, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x08, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x02, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x40, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x02, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFE, 0x00, 0x1C, 0x4F, 0x80, 0xE1, 0x81, 0x03, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x18, 0x08, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80,
  0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x13, 0x80, 0x00, 0x21, 0x80, 0x00,
  0xC1, 0x80, 0x01, 0x03, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x01,
  0x00, 0x06, 0x06, 0x08, 0x0C, 0x18, 0x1C, 0x11, 0xC0, 0x1F, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x0F, 0xE0,
  0x00, 0x40, 0x60, 0x80, 0x03, 0x03, 0x03, 0x00, 0x18, 0x18, 0x0C, 0x00,
  0x40, 0x40, 0x10, 0x03, 0x03, 0x00, 0x40, 0x18, 0x08, 0x01, 0x00, 0x40,
  0x20, 0x04, 0x03, 0x01, 0x80, 0x30, 0x18, 0x04, 0x00, 0xC0, 0x40, 0x10,
  0x03, 0x03, 0x00, 0xC0, 0x08, 0x18, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x00,
  0x83, 0x00, 0x30, 0x06, 0x08, 0x00, 0x80, 0x10, 0x61, 0xF2, 0x00, 0x43,
  0x0E, 0xE8, 0x03, 0x08, 0x60, 0xE0, 0x08, 0x63, 0x03, 0xC0, 0x63, 0x18,
  0x07, 0x03, 0x08, 0x40, 0x16, 0x18, 0x63, 0x00, 0x5F, 0xC3, 0x0C, 0x01,
  0x1E, 0x08, 0x20, 0x04, 0x00, 0x61, 0x80, 0x10, 0x03, 0x06, 0x00, 0x40,
  0x08, 0x10, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x08,
  0x0C, 0x00, 0x80, 0x60, 0x30, 0x06, 0x01, 0x00, 0xC0, 0x18, 0x08, 0x03,
  0x00, 0x40, 0x60, 0x0C, 0x03, 0x01, 0x00, 0x30, 0x08, 0x0C, 0x00, 0xC0,
  0x60, 0x60, 0x01, 0x01, 0x01, 0x00, 0x06, 0x18, 0x0C, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x18,
  0x01, 0x18, 0x01, 0x00, 0x66, 0x00, 0x30, 0x08, 0xC0, 0x02, 0x03, 0x30,
  0x00, 0x60, 0x46, 0x00, 0x04, 0x18, 0x80, 0x00, 0xC6, 0x10, 0x00, 0x08,
  0x86, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x01, 0x00,
  0x00, 0xF0, 0x20, 0x00, 0x32, 0x06, 0x00, 0x0C, 0x60, 0x60, 0x03, 0x04,
  0x06, 0x01, 0xC0, 0xC0, 0x7F, 0xE0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x33,
  0x32, 0x26, 0x64, 0x44, 0xC8, 0x88, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x01,
  0x00, 0xC0, 0x38, 0x10, 0x01, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x68, 0x7C,
  0x03, 0xF8, 0x00, 0xE0, 0x00, 0x34, 0x00, 0x0C, 0x40, 0x03, 0x08, 0x00,
  0x80, 0x80, 0x60, 0x10, 0x08, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x06, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x06, 0x03, 0x00, 0x30, 0x06, 0x01, 0x80, 0x08,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20,
  0x00, 0x11, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0, 0x00,
  0x13, 0x00, 0x00, 0x48, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x34,
  0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x03,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20,
  0x00, 0x30, 0x80, 0x00, 0x82, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x10, 0x00,
  0xC0, 0x60, 0x06, 0x00, 0x80, 0x30, 0x03, 0x83, 0x80, 0x03, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x03, 0xA0, 0x62, 0x0C, 0x63, 0x86,
  0x60, 0x4C, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03, 0x80,
  0x18, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x41, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x1C, 0x01, 0x80, 0x38, 0x00, 0x60, 0x10, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x0E, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x98, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60, 0x20,
  0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x08, 0x00, 0x30, 0x04,
  0x00, 0x30, 0x06, 0x00, 0x10, 0x03, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x18, 0x00, 0x40, 0x08, 0x00, 0x60, 0x08, 0x00, 0x30, 0x0C, 0x00,
  0x10, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x38, 0x07, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x7F, 0x00, 0x47, 0x87, 0x01, 0x98, 0x03, 0x03, 0x60, 0x03, 0x05,
  0x80, 0x02, 0x0E, 0x00, 0x06, 0x38, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x83, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x60,
  0x00, 0x60, 0x10, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x08, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x10, 0x00,
  0x04, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x0E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xC0, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x40, 0x00, 0x81, 0x80, 0x01, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10,
  0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00,
  0x18, 0x40, 0x00, 0x30, 0xC0, 0x00, 0xA1, 0x80, 0x03, 0xC1, 0x80, 0x0D,
  0x01, 0x80, 0x72, 0x01, 0xFF, 0x84, 0x00, 0xFC, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x18,
  0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0,
  0x00, 0x60, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x40, 0x01, 0xF8, 0x03, 0x0C, 0x00, 0x79,
  0xE0, 0x30, 0x80, 0x1C, 0x06, 0x01, 0x18, 0x03, 0x00, 0x40, 0x11, 0x00,
  0x60, 0x04, 0x01, 0x30, 0x04, 0x00, 0xC0, 0x33, 0x00, 0xC0, 0x0C, 0x03,
  0x20, 0x18, 0x00, 0x80, 0x36, 0x01, 0x80, 0x18, 0x03, 0x60, 0x10, 0x01,
  0x80, 0x26, 0x03, 0x00, 0x10, 0x02, 0x40, 0x30, 0x01, 0x00, 0x64, 0x02,
  0x00, 0x30, 0x06, 0x40, 0x20, 0x03, 0x00, 0x4C, 0x02, 0x00, 0x20, 0x0C,
  0xC0, 0x60, 0x06, 0x00, 0x8C, 0x02, 0x00, 0x60, 0x18, 0xC0, 0x20, 0x0A,
  0x01, 0x0C, 0x02, 0x01, 0xA0, 0x30, 0x40, 0x30, 0x33, 0x06, 0x04, 0x01,
  0xCE, 0x1F, 0xC0, 0x40, 0x0F, 0x80, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x20, 0x00,
  0x00, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x08,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x40, 0x20, 0x00, 0x30,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0x40, 0x30, 0x00,
  0x10, 0x08, 0x00, 0x04, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x20, 0x00, 0x06, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x00, 0x20, 0x03, 0x80, 0x08,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x30,
  0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x30, 0x10, 0x00, 0x18, 0x04, 0x00, 0x1C, 0x03,
  0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x20, 0x03, 0xC0, 0x08, 0x00, 0x18,
  0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x10, 0x00,
  0x06, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x08, 0x10, 0x00, 0x06, 0x04, 0x00, 0x03, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x01, 0xC0, 0x30, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x08, 0x03, 0xC0, 0x00, 0x80, 0x07, 0x00,
  0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x04, 0x00, 0x03, 0x80,
  0x40, 0x00, 0x70, 0x04, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x80, 0x0C, 0x0F,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xE2, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x08,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x02, 0x06,
  0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x08,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x03,
  0x00, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x20, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x04, 0x1C, 0x00, 0x00,
  0x43, 0x80, 0x00, 0x04, 0x70, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0D, 0xD0,
  0x00, 0x00, 0x91, 0x80, 0x00, 0x0A, 0x08, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x20, 0x01, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x60,
  0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x00, 0x0A, 0x01, 0xE0, 0x00, 0x00, 0x68, 0x04,
  0x80, 0x00, 0x01, 0x60, 0x12, 0x00, 0x00, 0x0D, 0x80, 0xC8, 0x00, 0x00,
  0x64, 0x03, 0x20, 0x00, 0x01, 0x10, 0x0C, 0x80, 0x00, 0x0C, 0xC0, 0x23,
  0x00, 0x00, 0x23, 0x00, 0x8C, 0x00, 0x01, 0x8C, 0x06, 0x30, 0x00, 0x04,
  0x20, 0x18, 0x40, 0x00, 0x30, 0x80, 0x41, 0x00, 0x00, 0x86, 0x01, 0x04,
  0x00, 0x06, 0x18, 0x04, 0x10, 0x00, 0x30, 0x40, 0x30, 0x60, 0x00, 0x81,
  0x00, 0xC1, 0x80, 0x06, 0x04, 0x02, 0x06, 0x00, 0x10, 0x30, 0x08, 0x08,
  0x00, 0xC0, 0xC0, 0x60, 0x20, 0x02, 0x02, 0x01, 0x80, 0x80, 0x18, 0x08,
  0x06, 0x02, 0x00, 0x40, 0x20, 0x10, 0x08, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x10, 0x0C, 0x03, 0x03, 0x00, 0x40,
  0x20, 0x04, 0x08, 0x03, 0x00, 0x80, 0x10, 0x60, 0x0C, 0x02, 0x00, 0x41,
  0x00, 0x30, 0x18, 0x01, 0x0C, 0x00, 0x80, 0x60, 0x04, 0x20, 0x02, 0x01,
  0x00, 0x19, 0x80, 0x18, 0x04, 0x00, 0x6C, 0x00, 0x60, 0x30, 0x01, 0xA0,
  0x01, 0x00, 0xC0, 0x03, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x20, 0x1A, 0x00, 0x00,
  0xC0, 0x24, 0x00, 0x01, 0x80, 0x4C, 0x00, 0x02, 0x01, 0x88, 0x00, 0x04,
  0x03, 0x10, 0x00, 0x08, 0x06, 0x30, 0x00, 0x30, 0x08, 0x20, 0x00, 0x60,
  0x10, 0x40, 0x00, 0x80, 0x60, 0xC0, 0x01, 0x00, 0xC0, 0x80, 0x06, 0x01,
  0x01, 0x00, 0x0C, 0x02, 0x03, 0x00, 0x18, 0x04, 0x02, 0x00, 0x20, 0x18,
  0x04, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x80, 0x40, 0x08, 0x03, 0x00, 0x80,
  0x18, 0x06, 0x03, 0x00, 0x30, 0x08, 0x06, 0x00, 0x20, 0x10, 0x0C, 0x00,
  0x60, 0x60, 0x10, 0x00, 0xC0, 0xC0, 0x20, 0x00, 0x81, 0x00, 0xC0, 0x01,
  0x82, 0x01, 0x80, 0x03, 0x04, 0x03, 0x00, 0x02, 0x18, 0x04, 0x00, 0x06,
  0x30, 0x08, 0x00, 0x0C, 0x40, 0x30, 0x00, 0x08, 0x80, 0x60, 0x00, 0x19,
  0x00, 0x80, 0x00, 0x36, 0x01, 0x00, 0x00, 0x2C, 0x06, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x40, 0x1E, 0x00, 0x20, 0x03, 0x80, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00, 0x08, 0x04, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30, 0x00, 0x08, 0x10, 0x00, 0x0C,
  0x08, 0x00, 0x04, 0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x01, 0x00, 0x06, 0x00, 0x80, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x30,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x40,
  0x1E, 0x00, 0x20, 0x03, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08,
  0x00, 0x08, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x10,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x04,
  0x06, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x01, 0x00, 0x1C, 0x00, 0xFF, 0xF8,
  0x00, 0x40, 0x30, 0x00, 0x60, 0x08, 0x00, 0x30, 0x04, 0x00, 0x10, 0x03,
  0x00, 0x08, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x00,
  0x18, 0x01, 0x00, 0x04, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x20, 0x00, 0x20, 0x10, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C,
  0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x88, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x10, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x04, 0x03, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x40,
  0x03, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00,
  0x02, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1A,
  0x00, 0x01, 0xC0, 0x00, 0x26, 0x00, 0x02, 0x80, 0x00, 0xCC, 0x00, 0x05,
  0x00, 0x01, 0x18, 0x00, 0x1A, 0x00, 0x06, 0x30, 0x00, 0x24, 0x00, 0x0C,
  0x60, 0x00, 0xC8, 0x00, 0x10, 0xC0, 0x01, 0x10, 0x00, 0x61, 0x80, 0x06,
  0x20, 0x00, 0x83, 0x00, 0x08, 0x40, 0x03, 0x06, 0x00, 0x30, 0x80, 0x04,
  0x0C, 0x00, 0x61, 0x00, 0x18, 0x18, 0x01, 0x82, 0x00, 0x30, 0x30, 0x03,
  0x06, 0x00, 0x40, 0x60, 0x04, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x02,
  0x01, 0x80, 0x20, 0x30, 0x0C, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x02, 0x01,
  0x00, 0xC0, 0x60, 0x04, 0x06, 0x01, 0x80, 0x80, 0x08, 0x08, 0x03, 0x01,
  0x00, 0x10, 0x30, 0x06, 0x06, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x00, 0x40,
  0x80, 0x18, 0x30, 0x00, 0x83, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x61,
  0x80, 0x02, 0x18, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x08,
  0xC0, 0x01, 0x18, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x04,
  0xC0, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x16, 0x00, 0x01,
  0x60, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x02, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80,
  0x0C, 0x00, 0x02, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x19, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x48, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xC0, 0x40, 0x40, 0x40,
  0x60, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10,
  0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x64, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x40, 0x02, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x11,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xC0,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0x84, 0x03, 0x81, 0x88, 0x0C, 0x01, 0x30, 0x30, 0x01, 0x60, 0xC0, 0x02,
  0x83, 0x00, 0x07, 0x04, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x10,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0x20, 0x00, 0x60, 0x40, 0x01, 0x40, 0xC0, 0x06, 0x81, 0x80, 0x19,
  0x01, 0x80, 0x66, 0x01, 0x83, 0x88, 0x01, 0xFC, 0x10, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x03, 0x0F, 0xF0, 0x02, 0x18, 0x18, 0x02, 0x60,
  0x0C, 0x02, 0xC0, 0x06, 0x06, 0x80, 0x02, 0x07, 0x80, 0x02, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x10, 0x70, 0x00, 0x30, 0x58, 0x00, 0x60, 0x48, 0x00, 0xC0, 0x4C, 0x01,
  0x80, 0x46, 0x03, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x0F, 0xFC, 0x07, 0x00, 0x81, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x1F, 0xF8, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x7F, 0x86, 0x00,
  0x38, 0x18, 0xC0, 0x0C, 0x01, 0x90, 0x03, 0x00, 0x1A, 0x00, 0xC0, 0x01,
  0x40, 0x30, 0x00, 0x38, 0x04, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x20, 0x00,
  0x70, 0x04, 0x00, 0x1A, 0x00, 0xC0, 0x06, 0xC0, 0x18, 0x01, 0x98, 0x01,
  0x80, 0x72, 0x00, 0x18, 0x18, 0x40, 0x01, 0xFE, 0x08, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xF0, 0x07, 0x03, 0x01, 0x80, 0x30,
  0x60, 0x06, 0x18, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01, 0x30, 0x00, 0x64,
  0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x31, 0x80, 0x3C, 0x30,
  0xFE, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x60, 0x1F,
  0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC4, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xF0, 0x40, 0x1C, 0x0C, 0x60, 0x18, 0x03, 0x20, 0x18,
  0x00, 0xD0, 0x18, 0x00, 0x28, 0x18, 0x00, 0x14, 0x08, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0, 0x40, 0x00,
  0xE0, 0x20, 0x00, 0xD0, 0x10, 0x00, 0xD8, 0x0C, 0x00, 0xCC, 0x03, 0x00,
  0xC4, 0x00, 0xC0, 0xC2, 0x00, 0x3F, 0xC3, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x61, 0xFE, 0x00, 0x86, 0x07, 0x01, 0x30, 0x06, 0x02,
  0xC0, 0x06, 0x0D, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x00,
  0x82, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x10,
  0x60, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x02, 0x0C,
  0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x86, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x10,
  0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80,
  0x01, 0x8A, 0x00, 0x06, 0x4C, 0x00, 0x12, 0x30, 0x00, 0x50, 0x40, 0x01,
  0x81, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0x80, 0x30, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00, 0x30,
  0x10, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x18, 0xFF, 0x01, 0xFE, 0x00, 0x8C, 0x0C, 0x18, 0x18, 0x04, 0xC0, 0x31,
  0x80, 0x60, 0x2C, 0x00, 0x98, 0x01, 0x03, 0xC0, 0x05, 0x80, 0x0C, 0x14,
  0x00, 0x28, 0x00, 0x60, 0xE0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x30, 0x00, 0x60, 0x00, 0x83, 0x00, 0x02, 0x00, 0x04, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x80, 0x01, 0x80, 0x03, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x60, 0x00, 0x40, 0x00, 0x83, 0x00, 0x02, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x80, 0x01, 0x80, 0x03, 0x04, 0x00, 0x08, 0x00, 0x10, 0x60,
  0x00, 0x40, 0x00, 0x83, 0x00, 0x06, 0x00, 0x04, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x80, 0x01, 0x00, 0x03, 0x04, 0x00, 0x08, 0x00, 0x10, 0x60, 0x00,
  0x40, 0x00, 0x83, 0x00, 0x06, 0x00, 0x04, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x80, 0x01, 0x00, 0x03, 0x04, 0x00, 0x08, 0x00, 0x10, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x06, 0x1F, 0xE0, 0x08, 0xE0, 0x70, 0x13,
  0x00, 0x60, 0x2C, 0x00, 0x60, 0xD0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x20, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0x83,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60,
  0x00, 0x20, 0xC0, 0x00, 0x41, 0x00, 0x01, 0x82, 0x00, 0x03, 0x04, 0x00,
  0x04, 0x18, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x0E,
  0x07, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00,
  0xC2, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x4C,
  0x00, 0x01, 0x20, 0x00, 0x05, 0x80, 0x00, 0x16, 0x00, 0x00, 0x50, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x02, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x1C, 0x0E,
  0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x30,
  0xFF, 0x00, 0x08, 0x60, 0x60, 0x02, 0x70, 0x0C, 0x00, 0x90, 0x01, 0x80,
  0x6C, 0x00, 0x20, 0x1E, 0x00, 0x08, 0x05, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x30, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x01, 0x20, 0x03, 0x00, 0x4C,
  0x01, 0xC0, 0x11, 0x80, 0xC0, 0x0C, 0x3F, 0xE0, 0x03, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0xE0, 0x63,
  0x01, 0x80, 0x32, 0x03, 0x00, 0x1A, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x0A,
  0x08, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0,
  0x40, 0x00, 0xE0, 0x40, 0x01, 0xA0, 0x40, 0x03, 0x60, 0x60, 0x07, 0x60,
  0x30, 0x0E, 0x40, 0x18, 0x18, 0x40, 0x0F, 0xF0, 0xC0, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x03, 0x0F, 0xC0, 0x8E, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x06, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x03,
  0x80, 0x70, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x08, 0x00, 0x60, 0xE0, 0x1C, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x1F, 0xFF, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x1F, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x10,
  0x00, 0x10, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00, 0x01, 0x82, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x60, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x82,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xA0, 0xC0, 0x03, 0x40, 0x80, 0x0D, 0x81, 0x80, 0x32, 0x01, 0x81,
  0xC4, 0x01, 0xFE, 0x08, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x10, 0x00,
  0xC2, 0x00, 0x18, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04,
  0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x60,
  0x04, 0x08, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x42, 0x00,
  0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x06, 0x00,
  0x0B, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x38, 0x00, 0x4C, 0x00, 0x58, 0x01,
  0x98, 0x01, 0xB0, 0x02, 0x30, 0x02, 0x60, 0x04, 0x60, 0x0C, 0xC0, 0x18,
  0xC0, 0x11, 0x80, 0x20, 0x80, 0x61, 0x00, 0xC1, 0x00, 0x82, 0x01, 0x02,
  0x01, 0x04, 0x06, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x30, 0x10,
  0x30, 0x20, 0x40, 0x20, 0x40, 0x40, 0x80, 0x41, 0x80, 0x83, 0x00, 0x82,
  0x01, 0x04, 0x01, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x04, 0x20, 0x04, 0x60,
  0x0C, 0xC0, 0x08, 0x80, 0x19, 0x00, 0x13, 0x00, 0x36, 0x00, 0x24, 0x00,
  0x68, 0x00, 0x58, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x20, 0x01, 0x80, 0x10, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x33, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x10, 0x30, 0x00, 0x18, 0x08, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30,
  0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x0C,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x05, 0x80, 0xE0, 0x1C, 0x00,
  0x7D, 0xE8, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 39, 11, 1, -39 },
  { 55, 11, 14, 16, 6, -39 },
  { 75, 28, 39, 29, 1, -39 },
  { 212, 23, 45, 26, 2, -42 },
  { 342, 30, 41, 37, 4, -40 },
  { 496, 27, 41, 30, 1, -40 },
  { 635, 4, 14, 9, 6, -39 },
  { 642, 15, 48, 13, 2, -39 },
  { 732, 16, 48, 13, -4, -39 },
  { 828, 19, 20, 25, 7, -42 },
  { 876, 23, 25, 28, 3, -32 },
  { 948, 7, 13, 10, -2, -6 },
  { 960, 12, 2, 16, 2, -16 },
  { 963, 3, 3, 10, 1, -3 },
  { 965, 23, 39, 17, -2, -39 },
  { 1078, 22, 41, 26, 3, -40 },
  { 1191, 12, 39, 26, 8, -39 },
  { 1250, 25, 40, 26, 0, -40 },
  { 1375, 25, 41, 26, 0, -40 },
  { 1504, 25, 40, 26, 0, -40 },
  { 1629, 25, 40, 26, 1, -39 },
  { 1754, 23, 41, 26, 3, -40 },
  { 1872, 22, 39, 26, 5, -39 },
  { 1980, 25, 41, 26, 1, -40 },
  { 2109, 23, 41, 26, 2, -40 },
  { 2227, 8, 29, 10, 1, -29 },
  { 2256, 12, 36, 10, -2, -29 },
  { 2310, 23, 24, 28, 3, -32 },
  { 2379, 23, 13, 28, 3, -26 },
  { 2417, 23, 24, 28, 3, -32 },
  { 2486, 17, 40, 19, 3, -40 },
  { 2571, 36, 44, 39, 2, -39 },
  { 2769, 26, 39, 26, -3, -39 },
  { 2896, 26, 39, 28, 2, -39 },
  { 3023, 26, 41, 28, 4, -40 },
  { 3157, 28, 39, 32, 2, -39 },
  { 3294, 25, 39, 25, 2, -39 },
  { 3416, 25, 39, 23, 2, -39 },
  { 3538, 29, 41, 33, 4, -40 },
  { 3687, 31, 39, 33, 2, -39 },
  { 3839, 17, 39, 13, -1, -39 },
  { 3922, 21, 49, 11, -9, -39 },
  { 4051, 28, 39, 26, 2, -39 },
  { 4188, 17, 39, 23, 2, -39 },
  { 4271, 38, 39, 40, 2, -39 },
  { 4457, 31, 39, 33, 2, -39 },
  { 4609, 28, 41, 34, 4, -40 },
  { 4753, 25, 39, 27, 2, -39 },
  { 4875, 28, 49, 34, 4, -40 },
  { 5047, 25, 39, 27, 2, -39 },
  { 5169, 25, 41, 24, 0, -40 },
  { 5298, 23, 39, 23, 5, -39 },
  { 5411, 29, 40, 33, 4, -39 },
  { 5556, 25, 39, 26, 5, -39 },
  { 5678, 39, 39, 41, 6, -39 },
  { 5869, 30, 39, 23, -3, -39 },
  { 6016, 23, 39, 23, 5, -39 },
  { 6129, 28, 39, 25, -1, -39 },
  { 6266, 21, 48, 16, -1, -39 },
  { 6392, 8, 39, 17, 5, -39 },
  { 6431, 21, 48, 16, -4, -39 },
  { 6557, 23, 22, 27, 2, -39 },
  { 6621, 18, 1, 18, -4, 6 },
  { 6624, 6, 9, 12, 8, -42 },
  { 6631, 23, 31, 27, 2, -30 },
  { 6721, 24, 43, 27, 1, -42 },
  { 6850, 19, 31, 21, 3, -30 },
  { 6924, 27, 43, 27, 2, -42 },
  { 7070, 19, 31, 24, 3, -30 },
  { 7144, 27, 55, 13, -7, -42 },
  { 7330, 25, 43, 27, 1, -30 },
  { 7465, 23, 42, 27, 1, -42 },
  { 7586, 10, 39, 10, 1, -39 },
  { 7635, 20, 52, 10, -8, -39 },
  { 7765, 22, 42, 21, 1, -42 },
  { 7881, 11, 42, 10, 1, -42 },
  { 7939, 37, 30, 40, 1, -30 },
  { 8078, 23, 30, 26, 1, -30 },
  { 8165, 22, 31, 27, 2, -30 },
  { 8251, 26, 43, 27, -1, -30 },
  { 8391, 24, 43, 27, 2, -30 },
  { 8520, 18, 29, 18, 1, -29 },
  { 8586, 20, 31, 20, 0, -30 },
  { 8664, 14, 37, 14, 2, -36 },
  { 8729, 23, 30, 27, 2, -29 },
  { 8816, 19, 29, 20, 3, -29 },
  { 8885, 31, 29, 32, 3, -29 },
  { 8998, 25, 29, 22, -2, -29 },
  { 9089, 29, 42, 20, -6, -29 },
  { 9242, 21, 29, 20, -1, -29 },
  { 9319, 19, 48, 18, 2, -39 },
  { 9433, 1, 55, 26, 13, -42 },
  { 9440, 19, 48, 18, -3, -39 },
  { 9554, 23, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC55PT7B_H_
