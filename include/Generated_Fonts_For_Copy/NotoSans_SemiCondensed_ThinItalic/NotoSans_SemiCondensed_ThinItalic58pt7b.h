#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x31, 0x03, 0x30, 0x23, 0x02, 0x30,
  0x22, 0x06, 0x20, 0x66, 0x04, 0x60, 0x44, 0x04, 0x40, 0xC4, 0x08, 0xC0,
  0x88, 0x08, 0x80, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x02, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xE6, 0x7E,
  0x01, 0x83, 0x02, 0x01, 0x81, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x40,
  0x00, 0xC0, 0x60, 0x00, 0x40, 0x30, 0x00, 0x20, 0x10, 0x00, 0x10, 0x08,
  0x00, 0x08, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x70, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x06, 0x38, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x80, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08,
  0x00, 0x08, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x06, 0x00, 0x02, 0x06,
  0x02, 0x01, 0x06, 0x01, 0xE1, 0x9E, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x03, 0xFC, 0x00,
  0x0C, 0x06, 0x0C, 0x00, 0x08, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x06, 0x00,
  0x30, 0x18, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x60, 0x30, 0x02, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x80, 0x20, 0x06, 0x01, 0x80, 0x60, 0x06, 0x03,
  0x00, 0x60, 0x06, 0x02, 0x00, 0x40, 0x06, 0x06, 0x00, 0x40, 0x04, 0x0C,
  0x00, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x0C, 0x30,
  0x00, 0xC0, 0x08, 0x30, 0xFC, 0xC0, 0x18, 0x61, 0x86, 0xC0, 0x18, 0x43,
  0x03, 0xC0, 0x30, 0xC6, 0x03, 0xC0, 0x31, 0x84, 0x01, 0x40, 0x61, 0x0C,
  0x01, 0x60, 0xC3, 0x08, 0x01, 0x3B, 0x86, 0x18, 0x01, 0x1F, 0x04, 0x18,
  0x01, 0x00, 0x0C, 0x10, 0x03, 0x00, 0x18, 0x30, 0x03, 0x00, 0x10, 0x30,
  0x03, 0x00, 0x30, 0x20, 0x03, 0x00, 0x60, 0x20, 0x02, 0x00, 0x40, 0x20,
  0x02, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60,
  0x04, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x60,
  0x18, 0x0C, 0x00, 0x20, 0x10, 0x08, 0x00, 0x30, 0x30, 0x18, 0x00, 0x30,
  0x60, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x01, 0x00, 0x18, 0x60, 0x0C, 0x00, 0x86, 0x00, 0x30, 0x0C, 0x60,
  0x01, 0x80, 0x42, 0x00, 0x06, 0x06, 0x30, 0x00, 0x10, 0x21, 0x00, 0x00,
  0xC3, 0x08, 0x00, 0x02, 0x30, 0x40, 0x00, 0x19, 0x06, 0x00, 0x00, 0x58,
  0x30, 0x00, 0x03, 0x80, 0x80, 0x00, 0x18, 0x04, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x19, 0x81, 0x80, 0x01, 0x8C, 0x06, 0x00, 0x38, 0x30, 0x1C, 0x07,
  0x00, 0x80, 0x7F, 0xF0, 0x06, 0x00, 0x70, 0x00, 0x00, 0x18, 0x8C, 0x63,
  0x10, 0x8C, 0x62, 0x10, 0x8C, 0x42, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x04, 0x03, 0x00, 0xE0, 0x20, 0x01, 0x82, 0x00, 0x0E,
  0x20, 0x00, 0x32, 0x0F, 0x00, 0xFF, 0xC0, 0x06, 0x00, 0x01, 0xA0, 0x00,
  0x33, 0x00, 0x06, 0x10, 0x00, 0xC1, 0x80, 0x18, 0x08, 0x06, 0x00, 0xC0,
  0x20, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x70, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x00, 0x06,
  0x03, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06,
  0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x40, 0x01, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x03, 0xA0, 0x62, 0x1C, 0x63, 0x06,
  0x60, 0x4C, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x03, 0x80, 0x30, 0x03, 0x80, 0x06, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0xC0,
  0x08, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x00, 0xF0, 0x03, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40,
  0x20, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x02,
  0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0x80, 0x08, 0x00, 0x20, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x18, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x18, 0x03,
  0xC0, 0x3C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xE3, 0x80, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x7F, 0xC0, 0x08, 0x70, 0x38, 0x04, 0xE0, 0x0E,
  0x06, 0xC0, 0x03, 0x03, 0xC0, 0x00, 0xC1, 0x40, 0x00, 0x60, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x08, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x04, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0x80, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xEF, 0x00, 0x03,
  0x80, 0x70, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x30, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x04,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x03,
  0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x07, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x0E, 0x0C, 0x00, 0x1A, 0x0C, 0x00, 0x36, 0x07, 0x00, 0xE6,
  0x03, 0xEF, 0x84, 0x00, 0xFE, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x70, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x01, 0xC0,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xF7, 0x81,
  0x80, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x00, 0x30, 0x80, 0x03, 0xFF, 0x01, 0x8C, 0x00, 0x70, 0x30, 0x0C, 0x40,
  0x06, 0x01, 0x80, 0x26, 0x00, 0x60, 0x0C, 0x01, 0x30, 0x06, 0x00, 0x40,
  0x0B, 0x00, 0x60, 0x02, 0x00, 0xD8, 0x02, 0x00, 0x30, 0x06, 0xC0, 0x30,
  0x01, 0x80, 0x34, 0x01, 0x00, 0x08, 0x01, 0xE0, 0x18, 0x00, 0x40, 0x0B,
  0x00, 0xC0, 0x06, 0x00, 0x58, 0x04, 0x00, 0x30, 0x06, 0xC0, 0x60, 0x01,
  0x00, 0x34, 0x03, 0x00, 0x18, 0x01, 0x20, 0x18, 0x00, 0xC0, 0x19, 0x00,
  0xC0, 0x06, 0x00, 0x88, 0x06, 0x00, 0x70, 0x0C, 0x40, 0x30, 0x07, 0x80,
  0x42, 0x01, 0x80, 0x2C, 0x06, 0x10, 0x06, 0x03, 0x60, 0x60, 0x80, 0x30,
  0x71, 0x06, 0x06, 0x00, 0xFF, 0x0F, 0xE0, 0x30, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x10, 0x00,
  0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x08, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x80, 0x1F, 0xFF, 0xF0, 0x02, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x40, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x20, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x07, 0x00,
  0x40, 0x00, 0x60, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x08, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x04, 0x04, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x00, 0x80,
  0x01, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xC0, 0x07, 0x80,
  0x18, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x06, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x7C, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x20, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x0F, 0xFE, 0x30, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x81, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x0C, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x07, 0x3C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x00, 0x01, 0x00, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x47, 0x80, 0x00, 0x03, 0x32, 0x00,
  0x00, 0x0D, 0x8C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0xE0, 0x40, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x40, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0xA0, 0x00, 0x00, 0x0F, 0x00, 0xA0, 0x00, 0x00,
  0x0A, 0x00, 0xB0, 0x00, 0x00, 0x1A, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x01,
  0xB0, 0x00, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x01, 0x10, 0x00,
  0x00, 0x64, 0x01, 0x10, 0x00, 0x00, 0xC4, 0x03, 0x10, 0x00, 0x00, 0x8C,
  0x03, 0x10, 0x00, 0x01, 0x8C, 0x02, 0x18, 0x00, 0x01, 0x08, 0x02, 0x18,
  0x00, 0x03, 0x08, 0x06, 0x18, 0x00, 0x06, 0x18, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x04, 0x08, 0x00, 0x0C, 0x10, 0x04,
  0x08, 0x00, 0x18, 0x10, 0x0C, 0x08, 0x00, 0x10, 0x30, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x08, 0x0C, 0x00, 0x60, 0x20,
  0x08, 0x04, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x00, 0xC0, 0x60, 0x18, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80, 0x60, 0x10, 0x06, 0x03, 0x00,
  0x40, 0x10, 0x06, 0x02, 0x00, 0x40, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x04, 0x00, 0xC0, 0x20, 0x02, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x08,
  0x00, 0x80, 0x60, 0x02, 0x18, 0x01, 0x80, 0x60, 0x02, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x30, 0x01, 0x80, 0x40, 0x03, 0x60, 0x01, 0x00, 0x40, 0x03,
  0x40, 0x01, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x80, 0x38, 0x00, 0x00, 0x40, 0x14, 0x00, 0x00, 0x60, 0x0B,
  0x00, 0x00, 0x30, 0x0C, 0x80, 0x00, 0x10, 0x06, 0x40, 0x00, 0x08, 0x03,
  0x30, 0x00, 0x0C, 0x01, 0x08, 0x00, 0x06, 0x00, 0x84, 0x00, 0x03, 0x00,
  0xC3, 0x00, 0x01, 0x00, 0x60, 0x80, 0x00, 0x80, 0x20, 0x40, 0x00, 0xC0,
  0x10, 0x30, 0x00, 0x60, 0x18, 0x08, 0x00, 0x30, 0x0C, 0x04, 0x00, 0x10,
  0x06, 0x03, 0x00, 0x08, 0x02, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x20, 0x03, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60, 0x18, 0x00, 0x60,
  0x20, 0x0C, 0x00, 0x30, 0x10, 0x06, 0x00, 0x08, 0x18, 0x02, 0x00, 0x06,
  0x0C, 0x01, 0x00, 0x03, 0x06, 0x01, 0x80, 0x00, 0x82, 0x00, 0xC0, 0x00,
  0x61, 0x00, 0x40, 0x00, 0x31, 0x80, 0x20, 0x00, 0x08, 0xC0, 0x30, 0x00,
  0x06, 0x60, 0x18, 0x00, 0x03, 0x20, 0x0C, 0x00, 0x00, 0x90, 0x04, 0x00,
  0x00, 0x78, 0x02, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x30, 0x07, 0x80, 0x0C, 0x00, 0x30,
  0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x30,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x30,
  0x07, 0x80, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0xE0, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x70, 0x03, 0xFF, 0xF0, 0x00, 0x80, 0x30, 0x00, 0x20, 0x0C,
  0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0x80, 0x01, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00,
  0xF0, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x23, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x04, 0x00,
  0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0x40,
  0x01, 0x80, 0x30, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x20, 0x00, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00,
  0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00,
  0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x07,
  0x80, 0x00, 0x4C, 0x00, 0x02, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x60, 0x00,
  0x21, 0x00, 0x01, 0xB0, 0x00, 0x30, 0x80, 0x01, 0x98, 0x00, 0x18, 0x40,
  0x00, 0xCC, 0x00, 0x18, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x10, 0x00, 0x63,
  0x00, 0x04, 0x08, 0x00, 0x21, 0x80, 0x06, 0x04, 0x00, 0x30, 0xC0, 0x02,
  0x02, 0x00, 0x10, 0x60, 0x03, 0x01, 0x00, 0x18, 0x10, 0x01, 0x00, 0x80,
  0x0C, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x20, 0x10, 0x01, 0x00,
  0x80, 0x10, 0x18, 0x00, 0x80, 0xC0, 0x08, 0x0C, 0x00, 0x40, 0x40, 0x04,
  0x04, 0x00, 0x20, 0x60, 0x02, 0x06, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00,
  0x0C, 0x30, 0x00, 0x83, 0x00, 0x06, 0x18, 0x00, 0x41, 0x00, 0x03, 0x08,
  0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x10, 0x80, 0x00, 0xC4, 0x00, 0x08,
  0xC0, 0x00, 0x66, 0x00, 0x04, 0x60, 0x00, 0x32, 0x00, 0x02, 0x20, 0x00,
  0x1B, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x90, 0x00, 0x06, 0x80,
  0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x14,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0x40,
  0x10, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60,
  0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10, 0x18,
  0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x40, 0x00, 0x30,
  0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x04, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x05, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x00, 0x1F,
  0xC1, 0x80, 0x3C, 0x70, 0x80, 0x30, 0x0C, 0x40, 0x30, 0x03, 0x20, 0x30,
  0x00, 0xB0, 0x30, 0x00, 0x78, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10,
  0x40, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0xE0, 0x40, 0x00, 0xF0, 0x30, 0x00, 0x50, 0x18, 0x00, 0x48, 0x04, 0x00,
  0x64, 0x03, 0x00, 0x66, 0x00, 0xC0, 0xE2, 0x00, 0x3F, 0xC1, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x1F, 0xC0, 0x04, 0x3C,
  0x70, 0x06, 0x30, 0x0C, 0x03, 0x30, 0x03, 0x01, 0x30, 0x00, 0x80, 0xB0,
  0x00, 0x60, 0xF0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x38, 0x00, 0x04, 0x18,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08,
  0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x41, 0xE0, 0x00, 0x60, 0xF0, 0x00, 0x60, 0x4C, 0x00, 0x60, 0x26, 0x00,
  0x60, 0x11, 0xC0, 0xE0, 0x18, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0x8F, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x60, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFC, 0x08, 0x00, 0x78, 0x70, 0x80,
  0x0C, 0x01, 0x98, 0x01, 0x80, 0x0D, 0x80, 0x30, 0x00, 0x58, 0x06, 0x00,
  0x05, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04,
  0x04, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x04, 0x00, 0x03,
  0x80, 0x40, 0x00, 0x70, 0x04, 0x00, 0x05, 0x00, 0x60, 0x00, 0xD0, 0x06,
  0x00, 0x1B, 0x00, 0x20, 0x03, 0x30, 0x03, 0x00, 0x62, 0x00, 0x18, 0x1C,
  0x20, 0x00, 0xFF, 0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0x9E, 0x01, 0xC0, 0x70, 0x30, 0x03, 0x06, 0x00, 0x10, 0xC0, 0x01,
  0x0C, 0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00,
  0x66, 0x00, 0x0C, 0x60, 0x01, 0x84, 0x00, 0x70, 0xC0, 0xFC, 0x0F, 0xFE,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0x01, 0xC0, 0x70,
  0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x40, 0x0F,
  0x0E, 0x10, 0x06, 0x00, 0xC4, 0x03, 0x00, 0x1B, 0x01, 0x80, 0x02, 0xC0,
  0xC0, 0x00, 0xA0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00,
  0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x20,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x02, 0x00, 0x01, 0xC0, 0x80, 0x00,
  0xE0, 0x20, 0x00, 0x78, 0x0C, 0x00, 0x1A, 0x03, 0x00, 0x0D, 0x80, 0x40,
  0x06, 0x60, 0x18, 0x03, 0x10, 0x03, 0x03, 0x84, 0x00, 0x7F, 0x83, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x03, 0xF8, 0x01, 0x0F, 0x1C, 0x03, 0x18, 0x06, 0x03, 0x60,
  0x03, 0x02, 0x40, 0x03, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x07, 0x00,
  0x01, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x10, 0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x08, 0x20, 0x00,
  0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00,
  0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x00, 0x40,
  0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x03, 0x01, 0x00,
  0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x04, 0x06,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x08, 0xF0, 0x00, 0x09, 0x90, 0x00, 0x1B, 0x18, 0x00, 0x1E, 0x18,
  0x00, 0x1C, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04,
  0x00, 0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x01, 0x00, 0x60, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x00, 0x01, 0x07, 0xF0, 0x07, 0xE0, 0x02, 0x3C,
  0xF0, 0x38, 0xF0, 0x0C, 0xC0, 0x30, 0xC0, 0x30, 0x13, 0x00, 0x63, 0x00,
  0x60, 0x2C, 0x00, 0x4C, 0x00, 0x40, 0x50, 0x00, 0xB0, 0x00, 0xC1, 0xC0,
  0x01, 0x40, 0x01, 0x83, 0x80, 0x03, 0x80, 0x03, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x10, 0x00, 0x10, 0x60,
  0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80,
  0x01, 0x82, 0x00, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x00, 0x04, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x30, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x80, 0x00, 0x80, 0x00, 0x83, 0x00, 0x01, 0x00, 0x01, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x20, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00, 0x03, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x00, 0x08, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x01, 0x03, 0xF8, 0x01, 0x0F, 0x1C, 0x03, 0x38, 0x06, 0x02, 0x60,
  0x03, 0x02, 0x40, 0x03, 0x02, 0x80, 0x03, 0x07, 0x80, 0x01, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x10, 0x60, 0x00,
  0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x00, 0x3F,
  0xC0, 0x01, 0xE1, 0xC0, 0x07, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x68,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x48, 0x00, 0x01, 0x90, 0x00,
  0x03, 0x20, 0x00, 0x04, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC1, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x03, 0x01, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x02, 0x1E,
  0x38, 0x00, 0x63, 0x00, 0xC0, 0x04, 0x60, 0x06, 0x00, 0x4C, 0x00, 0x20,
  0x05, 0x80, 0x03, 0x00, 0xF0, 0x00, 0x30, 0x0F, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x10, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x1C, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x10, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0xF0, 0x00,
  0x30, 0x0D, 0x00, 0x06, 0x00, 0xD0, 0x00, 0xC0, 0x09, 0x80, 0x18, 0x00,
  0x8E, 0x07, 0x00, 0x18, 0x7F, 0xE0, 0x01, 0x80, 0x40, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x3C, 0x38, 0x40, 0x30,
  0x06, 0x20, 0x30, 0x01, 0xB0, 0x30, 0x00, 0x58, 0x30, 0x00, 0x28, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06,
  0x10, 0x00, 0x03, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0xE0, 0x80, 0x00, 0xE0, 0x40, 0x00, 0x70, 0x30, 0x00,
  0x68, 0x18, 0x00, 0x6C, 0x04, 0x00, 0x66, 0x03, 0x00, 0x62, 0x00, 0xC0,
  0xE1, 0x00, 0x3F, 0xC1, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x07, 0xE0, 0x21, 0xE4, 0x0C, 0xE0, 0x01, 0x30, 0x00, 0x24,
  0x00, 0x05, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x87, 0xC0, 0xC0, 0x04, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x08, 0x00, 0x60, 0x78, 0x06, 0x00, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x07, 0xFF, 0x7F, 0xFC, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFE, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x40, 0x00, 0x30,
  0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10,
  0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06,
  0x10, 0x00, 0x0C, 0x20, 0x00, 0x38, 0x40, 0x00, 0x60, 0x80, 0x01, 0xC1,
  0x00, 0x02, 0x82, 0x00, 0x0B, 0x06, 0x00, 0x36, 0x0C, 0x00, 0xC8, 0x0E,
  0x06, 0x10, 0x0F, 0xF8, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x20, 0x00, 0x61,
  0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x18, 0x18, 0x00,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x30, 0x06, 0x01, 0x80, 0x20, 0x04,
  0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x40, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33,
  0x00, 0x00, 0x90, 0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00,
  0x40, 0x00, 0xB0, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x30, 0x00, 0x4C, 0x00,
  0x3C, 0x00, 0x62, 0x00, 0x16, 0x00, 0x21, 0x00, 0x1B, 0x00, 0x10, 0x80,
  0x09, 0x80, 0x18, 0x40, 0x0C, 0xC0, 0x08, 0x20, 0x04, 0x60, 0x0C, 0x10,
  0x06, 0x10, 0x04, 0x08, 0x02, 0x08, 0x06, 0x04, 0x03, 0x04, 0x02, 0x02,
  0x01, 0x02, 0x03, 0x01, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x40, 0xC0, 0x40, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x10, 0x60, 0x10, 0x60,
  0x08, 0x20, 0x08, 0x20, 0x04, 0x30, 0x06, 0x30, 0x02, 0x10, 0x03, 0x10,
  0x01, 0x98, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x64,
  0x00, 0x36, 0x00, 0x36, 0x00, 0x1A, 0x00, 0x1A, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x10,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x40, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x02, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x01,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x10, 0x00, 0x80, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x01, 0x60, 0x1C, 0x03, 0xC0,
  0x07, 0xDE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 41, 12, 2, -41 },
  { 53, 12, 15, 17, 6, -41 },
  { 76, 30, 41, 30, 1, -41 },
  { 230, 25, 47, 27, 2, -44 },
  { 377, 32, 43, 39, 4, -42 },
  { 549, 29, 43, 32, 1, -42 },
  { 705, 5, 15, 9, 6, -41 },
  { 715, 16, 50, 14, 2, -41 },
  { 815, 16, 50, 14, -4, -41 },
  { 915, 20, 21, 26, 7, -44 },
  { 968, 24, 27, 29, 3, -34 },
  { 1049, 8, 13, 10, -3, -6 },
  { 1062, 13, 1, 17, 2, -16 },
  { 1064, 2, 3, 11, 2, -3 },
  { 1065, 25, 41, 17, -3, -41 },
  { 1194, 24, 43, 27, 3, -42 },
  { 1323, 12, 41, 27, 9, -41 },
  { 1385, 26, 42, 27, 0, -42 },
  { 1522, 27, 43, 27, 0, -42 },
  { 1668, 26, 42, 27, 0, -42 },
  { 1805, 26, 42, 27, 1, -41 },
  { 1942, 25, 43, 27, 3, -42 },
  { 2077, 24, 41, 27, 5, -41 },
  { 2200, 26, 43, 27, 1, -42 },
  { 2340, 24, 43, 27, 2, -42 },
  { 2469, 9, 31, 11, 1, -31 },
  { 2504, 13, 38, 11, -3, -31 },
  { 2566, 24, 25, 29, 3, -33 },
  { 2641, 24, 13, 29, 3, -27 },
  { 2680, 24, 25, 29, 3, -33 },
  { 2755, 18, 42, 20, 3, -42 },
  { 2850, 37, 46, 41, 3, -41 },
  { 3063, 27, 42, 27, -3, -42 },
  { 3205, 27, 41, 30, 2, -41 },
  { 3344, 28, 43, 29, 4, -42 },
  { 3495, 30, 41, 34, 2, -41 },
  { 3649, 27, 41, 27, 2, -41 },
  { 3788, 27, 41, 25, 2, -41 },
  { 3927, 30, 43, 35, 4, -42 },
  { 4089, 33, 41, 34, 2, -41 },
  { 4259, 18, 41, 14, -1, -41 },
  { 4352, 21, 51, 12, -9, -41 },
  { 4486, 30, 41, 27, 2, -41 },
  { 4640, 18, 41, 24, 2, -41 },
  { 4733, 40, 41, 42, 2, -41 },
  { 4938, 33, 41, 35, 2, -41 },
  { 5108, 30, 43, 36, 4, -42 },
  { 5270, 26, 41, 28, 2, -41 },
  { 5404, 30, 52, 36, 4, -42 },
  { 5599, 26, 41, 28, 2, -41 },
  { 5733, 27, 43, 26, 0, -42 },
  { 5879, 24, 41, 24, 5, -41 },
  { 6002, 31, 42, 34, 4, -41 },
  { 6165, 25, 41, 27, 6, -41 },
  { 6294, 41, 41, 43, 6, -41 },
  { 6505, 32, 41, 24, -3, -41 },
  { 6669, 24, 41, 24, 5, -41 },
  { 6792, 30, 41, 26, -1, -41 },
  { 6946, 22, 50, 17, -1, -41 },
  { 7084, 8, 41, 18, 6, -41 },
  { 7125, 21, 50, 17, -4, -41 },
  { 7257, 25, 24, 29, 2, -42 },
  { 7332, 20, 1, 19, -5, 6 },
  { 7335, 6, 9, 13, 9, -44 },
  { 7342, 25, 32, 28, 2, -31 },
  { 7442, 25, 45, 29, 1, -44 },
  { 7583, 20, 32, 22, 3, -31 },
  { 7663, 28, 45, 29, 2, -44 },
  { 7821, 20, 32, 25, 3, -31 },
  { 7901, 30, 58, 14, -8, -44 },
  { 8119, 26, 45, 29, 1, -31 },
  { 8266, 24, 44, 28, 1, -44 },
  { 8398, 11, 42, 11, 1, -42 },
  { 8456, 20, 56, 11, -8, -42 },
  { 8596, 24, 44, 22, 1, -44 },
  { 8728, 11, 44, 11, 1, -44 },
  { 8789, 39, 31, 43, 1, -31 },
  { 8941, 24, 31, 28, 1, -31 },
  { 9034, 23, 32, 28, 3, -31 },
  { 9126, 28, 44, 29, -2, -31 },
  { 9280, 25, 45, 29, 2, -31 },
  { 9421, 19, 31, 19, 1, -31 },
  { 9495, 21, 32, 21, 0, -31 },
  { 9579, 14, 39, 15, 2, -38 },
  { 9648, 23, 32, 28, 3, -31 },
  { 9740, 21, 31, 21, 3, -31 },
  { 9822, 33, 31, 34, 3, -31 },
  { 9950, 26, 31, 23, -2, -31 },
  { 10051, 31, 45, 21, -7, -31 },
  { 10226, 23, 31, 21, -1, -31 },
  { 10316, 20, 50, 19, 2, -41 },
  { 10441, 1, 58, 27, 14, -44 },
  { 10449, 20, 50, 19, -3, -41 },
  { 10574, 24, 5, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC58PT7B_H_
