#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x20, 0x00, 0x04,
  0x20, 0x4A, 0x63, 0x18, 0xCA, 0x40, 0x02, 0x10, 0x10, 0x80, 0x88, 0x08,
  0x40, 0x42, 0x02, 0x11, 0xEF, 0x61, 0x08, 0x08, 0x40, 0x84, 0x04, 0x20,
  0x21, 0x0F, 0xFF, 0x10, 0x80, 0x84, 0x04, 0x20, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x00, 0x80, 0x20, 0x04, 0x07, 0xF1, 0x10, 0x42, 0x08, 0x81, 0x10,
  0x22, 0x02, 0x40, 0x30, 0x03, 0x00, 0x50, 0x09, 0x01, 0x10, 0x42, 0x08,
  0x81, 0x12, 0x2C, 0x3E, 0x01, 0x00, 0x20, 0x04, 0x00, 0x08, 0x00, 0x68,
  0x09, 0x08, 0x22, 0x10, 0x84, 0x21, 0x10, 0x44, 0x20, 0x90, 0x42, 0x20,
  0x84, 0x9D, 0x0A, 0x46, 0x25, 0x0C, 0x92, 0x16, 0x28, 0x20, 0x90, 0x42,
  0x20, 0x84, 0x42, 0x10, 0x84, 0x41, 0x08, 0x82, 0x22, 0x03, 0x80, 0x03,
  0x80, 0x22, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x21, 0x01, 0x10,
  0x0B, 0x00, 0x20, 0x07, 0x00, 0x44, 0x14, 0x10, 0xC0, 0x8A, 0x02, 0x50,
  0x14, 0x80, 0x44, 0x06, 0x20, 0x48, 0xFC, 0x60, 0x5A, 0xA8, 0x02, 0x08,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x02, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x04, 0x01, 0x0C, 0x40, 0xD0, 0x0F,
  0xC5, 0x02, 0x41, 0x08, 0x02, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x24, 0xA5, 0x00, 0xFC, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x03, 0x80, 0x88, 0x20,
  0x88, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x21, 0x04, 0x1F, 0x00,
  0x0C, 0xD4, 0xA2, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x00, 0x01, 0xC0, 0x62, 0x08, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFC, 0x01, 0xC0, 0xE2,
  0x10, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x60, 0xF8,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x87, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x50, 0x0A, 0x01, 0x20, 0x22,
  0x02, 0x20, 0x42, 0x08, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40, 0x4F, 0xFF,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x07, 0xF8, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0xC0, 0x19, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x3F, 0xC0, 0x00, 0xE0, 0x31, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x4F, 0x05, 0x08, 0x60, 0x44, 0x04, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x44, 0x08, 0x41, 0x03, 0xE0, 0x7F, 0xE0, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x00,
  0x03, 0x80, 0xC4, 0x10, 0x21, 0x01, 0x10, 0x12, 0x01, 0x10, 0x21, 0x04,
  0x08, 0x80, 0x70, 0x1A, 0x02, 0x18, 0x40, 0x88, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x80, 0x87, 0xF0, 0x03, 0x01, 0x98, 0x40, 0x90, 0x12,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x81, 0x98, 0xD0, 0x64,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x18, 0x7C, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x88, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x20, 0x84, 0x10, 0x80, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x40, 0x00, 0x1C, 0x62, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x00, 0x00, 0x00, 0x80, 0x80, 0x01, 0xFE,
  0x00, 0x80, 0x40, 0xC0, 0x08, 0x20, 0x02, 0x10, 0x00, 0x48, 0x1C, 0x12,
  0x18, 0x85, 0x08, 0x21, 0x42, 0x08, 0x51, 0x04, 0x18, 0x41, 0x0A, 0x10,
  0x42, 0x84, 0x20, 0xA1, 0x08, 0x48, 0x45, 0x22, 0x0E, 0x70, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x20,
  0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02,
  0x10, 0x20, 0x81, 0x04, 0x1F, 0xE0, 0x80, 0x88, 0x04, 0x40, 0x24, 0x01,
  0x20, 0x0A, 0x00, 0x70, 0x02, 0x0F, 0xE0, 0x80, 0x84, 0x02, 0x20, 0x11,
  0x00, 0x88, 0x08, 0x80, 0x44, 0x04, 0x3F, 0xC1, 0x06, 0x08, 0x08, 0x80,
  0x44, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44, 0x04, 0x3F, 0xC0,
  0x00, 0xE0, 0x38, 0xC2, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x40,
  0x41, 0x00, 0x84, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x20,
  0x08, 0x80, 0x42, 0x06, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0xC2, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0x00,
  0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0xFC, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x70, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x1F,
  0x20, 0x02, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x11, 0x00,
  0x84, 0x02, 0x0F, 0xF0, 0x08, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21,
  0x00, 0x42, 0x00, 0x88, 0x01, 0x10, 0x02, 0x3F, 0xF8, 0x40, 0x10, 0x80,
  0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x42, 0x00, 0x80, 0x0F, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0xF0, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x03, 0x00, 0x08, 0x0C, 0x40, 0x41, 0x02, 0x04, 0x10,
  0x10, 0x80, 0x44, 0x02, 0x20, 0x09, 0x00, 0x2C, 0x00, 0xD0, 0x02, 0x20,
  0x10, 0x80, 0x41, 0x01, 0x04, 0x04, 0x10, 0x20, 0x20, 0x80, 0x82, 0x01,
  0x08, 0x04, 0x00, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFF, 0x08, 0x00,
  0x63, 0x00, 0x18, 0x50, 0x03, 0x0A, 0x00, 0xA1, 0x40, 0x14, 0x28, 0x04,
  0x89, 0x00, 0xA1, 0x20, 0x24, 0x24, 0x04, 0x84, 0x81, 0x10, 0x88, 0x44,
  0x21, 0x08, 0x84, 0x22, 0x10, 0x84, 0x42, 0x10, 0x90, 0x44, 0x12, 0x10,
  0x82, 0x82, 0x10, 0x50, 0x42, 0x04, 0x08, 0x00, 0x08, 0x02, 0x30, 0x04,
  0x50, 0x08, 0xA0, 0x21, 0x40, 0x42, 0x40, 0x88, 0x81, 0x11, 0x02, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x22, 0x04, 0x44, 0x08, 0x88, 0x12, 0x10, 0x14,
  0x40, 0x28, 0x80, 0x51, 0x00, 0x42, 0x00, 0x80, 0x01, 0xC0, 0x18, 0xC0,
  0x80, 0x84, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x80, 0x22, 0x00, 0x84, 0x04, 0x0F, 0xE0, 0x0F, 0xC1, 0x02, 0x10, 0x11,
  0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x0C, 0x3E, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x18, 0xC0, 0x80, 0x84, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00,
  0x50, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x84, 0x04, 0x0F, 0xE0, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xC1, 0x03, 0x10,
  0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12, 0x02, 0x20, 0x62, 0x18, 0x3E,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x88, 0x08, 0x80, 0x88, 0x08, 0x80,
  0x40, 0x01, 0xC0, 0x63, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x8F, 0xF0, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00,
  0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x09, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x88, 0x02, 0x20, 0x08, 0x80, 0x41, 0x02, 0x03, 0xF0, 0x00, 0x80, 0x38,
  0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x82, 0x08,
  0x20, 0x84, 0x08, 0x40, 0x88, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A, 0x03, 0x01, 0x40, 0xA0,
  0x48, 0x14, 0x09, 0x04, 0x82, 0x20, 0x90, 0x44, 0x22, 0x08, 0x84, 0x42,
  0x10, 0x88, 0x42, 0x21, 0x10, 0x44, 0x22, 0x09, 0x04, 0x81, 0x20, 0x90,
  0x28, 0x12, 0x05, 0x02, 0x80, 0xC0, 0x50, 0x18, 0x04, 0x02, 0x00, 0x80,
  0x00, 0x04, 0x02, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x24,
  0x00, 0x48, 0x00, 0xA0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x12, 0x00,
  0x44, 0x01, 0x08, 0x02, 0x10, 0x08, 0x10, 0x20, 0x20, 0x80, 0x43, 0x00,
  0x40, 0x80, 0x34, 0x02, 0x40, 0x44, 0x08, 0x40, 0x82, 0x10, 0x22, 0x02,
  0x20, 0x24, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x0F, 0x80, 0x88, 0x88, 0x88,
  0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x10, 0x07, 0xC0, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0x80,
  0x01, 0x00, 0x50, 0x12, 0x02, 0x40, 0x84, 0x20, 0x84, 0x11, 0x01, 0x40,
  0x28, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x91, 0x22, 0x03, 0x01, 0x94, 0x41,
  0x90, 0x34, 0x02, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40,
  0x48, 0x18, 0x85, 0x1F, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0xE1, 0x22, 0x28, 0x26, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80,
  0x50, 0x0A, 0x01, 0x80, 0x50, 0x0B, 0x02, 0x60, 0x8B, 0xE0, 0x03, 0x83,
  0x11, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x0C, 0x41, 0x92, 0x10, 0x51, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x60,
  0x85, 0x07, 0xC8, 0x00, 0x03, 0x03, 0x21, 0x04, 0x81, 0x40, 0x50, 0x24,
  0x11, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0xF0, 0x00,
  0x1C, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0x32, 0x42, 0x0A, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x04,
  0x40, 0x22, 0x01, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x10, 0xA0, 0xF9, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x0F, 0xE0, 0x00, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xE1, 0x22, 0x28, 0x26, 0x04,
  0x80, 0x90, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x12, 0x02,
  0x40, 0x48, 0x08, 0x18, 0x00, 0x00, 0x10, 0x84, 0x22, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xF0, 0x00, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x81, 0x20, 0x88, 0x42,
  0x21, 0x10, 0x48, 0x16, 0x06, 0x41, 0x10, 0x84, 0x20, 0x88, 0x22, 0x08,
  0x81, 0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x00, 0x03, 0x06, 0x16, 0x44, 0xCC, 0x14, 0x24, 0x0C,
  0x12, 0x04, 0x09, 0x02, 0x05, 0x01, 0x02, 0x80, 0x81, 0x40, 0x80, 0xA0,
  0x40, 0x60, 0x20, 0x50, 0x10, 0x28, 0x10, 0x14, 0x08, 0x0A, 0x04, 0x08,
  0x03, 0x84, 0x88, 0xE0, 0x98, 0x12, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40,
  0x48, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x03, 0x01, 0x98,
  0x41, 0x10, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x28, 0x08, 0x82, 0x0F, 0x80, 0x00, 0xE0, 0x48, 0x82, 0x82, 0x18,
  0x10, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x04,
  0x40, 0x23, 0x02, 0x18, 0x20, 0xBE, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x00, 0x03, 0x00, 0xC9, 0x10, 0x52, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x81,
  0x84, 0x28, 0x7C, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x27, 0x94, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0x06, 0x32, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x8F, 0xE0,
  0x10, 0x20, 0x41, 0x07, 0xE4, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0xE0, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0xC8, 0x28, 0xF9, 0x00,
  0x80, 0x60, 0x24, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21, 0x10, 0x44, 0x12,
  0x05, 0x01, 0x40, 0x20, 0x08, 0x00, 0x83, 0x07, 0x06, 0x0A, 0x14, 0x14,
  0x28, 0x48, 0x90, 0x91, 0x22, 0x24, 0x44, 0x48, 0x90, 0x91, 0x21, 0x42,
  0x82, 0x85, 0x06, 0x0A, 0x08, 0x08, 0x10, 0x10, 0x00, 0x10, 0x10, 0x82,
  0x08, 0x40, 0x48, 0x05, 0x00, 0x50, 0x02, 0x00, 0x60, 0x0A, 0x01, 0x10,
  0x11, 0x02, 0x08, 0x40, 0x88, 0x08, 0x04, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00,
  0x28, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x01, 0xFE, 0x00, 0x03, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x03,
  0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x0F, 0x00, 0x30, 0x11, 0x8C, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 5, 7, 8, 3, -19 },
  { 18, 13, 19, 14, 1, -19 },
  { 49, 11, 23, 13, 1, -21 },
  { 81, 15, 20, 18, 2, -20 },
  { 119, 13, 20, 15, 1, -20 },
  { 152, 2, 7, 4, 3, -19 },
  { 154, 7, 23, 7, 1, -19 },
  { 175, 8, 23, 7, -2, -19 },
  { 198, 10, 9, 12, 3, -20 },
  { 210, 11, 13, 14, 2, -16 },
  { 228, 3, 6, 5, -1, -3 },
  { 231, 6, 1, 8, 1, -8 },
  { 232, 1, 2, 5, 1, -2 },
  { 233, 11, 19, 8, -1, -19 },
  { 260, 11, 20, 13, 1, -20 },
  { 288, 6, 19, 13, 4, -19 },
  { 303, 12, 20, 13, 0, -20 },
  { 333, 12, 20, 13, 0, -20 },
  { 363, 12, 19, 13, 0, -19 },
  { 392, 13, 19, 13, 0, -19 },
  { 423, 12, 20, 13, 1, -20 },
  { 453, 11, 19, 13, 2, -19 },
  { 480, 12, 20, 13, 1, -20 },
  { 510, 11, 20, 13, 1, -20 },
  { 538, 4, 14, 5, 1, -14 },
  { 545, 6, 17, 5, -1, -14 },
  { 558, 11, 12, 14, 2, -16 },
  { 575, 11, 7, 14, 2, -13 },
  { 585, 11, 12, 14, 2, -16 },
  { 602, 8, 20, 9, 2, -20 },
  { 622, 18, 21, 19, 1, -19 },
  { 670, 13, 19, 13, -2, -19 },
  { 701, 13, 19, 14, 1, -19 },
  { 732, 13, 20, 14, 2, -20 },
  { 765, 14, 19, 16, 1, -19 },
  { 799, 12, 19, 13, 1, -19 },
  { 828, 12, 19, 11, 1, -19 },
  { 857, 14, 20, 16, 2, -20 },
  { 892, 15, 19, 16, 1, -19 },
  { 928, 8, 19, 6, 0, -19 },
  { 947, 10, 24, 5, -4, -19 },
  { 977, 14, 19, 13, 1, -19 },
  { 1011, 8, 19, 11, 1, -19 },
  { 1030, 19, 19, 20, 1, -19 },
  { 1076, 15, 19, 16, 1, -19 },
  { 1112, 14, 20, 17, 2, -20 },
  { 1147, 12, 19, 13, 1, -19 },
  { 1176, 14, 25, 17, 2, -20 },
  { 1220, 12, 19, 13, 1, -19 },
  { 1249, 12, 20, 12, 0, -20 },
  { 1279, 12, 19, 11, 2, -19 },
  { 1308, 14, 19, 16, 2, -19 },
  { 1342, 12, 19, 13, 3, -19 },
  { 1371, 19, 19, 20, 3, -19 },
  { 1417, 15, 19, 11, -2, -19 },
  { 1453, 12, 19, 11, 2, -19 },
  { 1482, 14, 19, 12, -1, -19 },
  { 1516, 10, 23, 8, 0, -19 },
  { 1545, 4, 19, 8, 3, -19 },
  { 1555, 10, 23, 8, -2, -19 },
  { 1584, 11, 11, 13, 1, -19 },
  { 1600, 9, 1, 9, -2, 3 },
  { 1602, 3, 5, 6, 4, -21 },
  { 1604, 11, 15, 13, 1, -15 },
  { 1625, 11, 21, 13, 1, -21 },
  { 1654, 10, 15, 10, 1, -15 },
  { 1673, 13, 21, 13, 1, -21 },
  { 1708, 10, 15, 12, 1, -15 },
  { 1727, 14, 27, 6, -4, -21 },
  { 1775, 13, 21, 13, 0, -15 },
  { 1810, 11, 21, 13, 1, -21 },
  { 1839, 5, 19, 5, 1, -19 },
  { 1851, 10, 25, 5, -4, -19 },
  { 1883, 10, 21, 10, 1, -21 },
  { 1910, 5, 21, 5, 1, -21 },
  { 1924, 17, 15, 20, 1, -15 },
  { 1956, 11, 15, 13, 1, -15 },
  { 1977, 11, 15, 13, 1, -15 },
  { 1998, 13, 21, 13, -1, -15 },
  { 2033, 12, 21, 13, 1, -15 },
  { 2065, 9, 14, 9, 1, -14 },
  { 2081, 10, 15, 10, 0, -15 },
  { 2100, 7, 18, 7, 1, -18 },
  { 2116, 11, 14, 13, 1, -14 },
  { 2136, 10, 14, 10, 1, -14 },
  { 2154, 15, 14, 16, 2, -14 },
  { 2181, 12, 14, 11, -1, -14 },
  { 2202, 14, 21, 10, -3, -14 },
  { 2239, 11, 14, 10, -1, -14 },
  { 2259, 9, 23, 9, 1, -19 },
  { 2285, 1, 28, 13, 6, -21 },
  { 2289, 10, 23, 9, -2, -19 },
  { 2318, 11, 3, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC27PT7B_H_
