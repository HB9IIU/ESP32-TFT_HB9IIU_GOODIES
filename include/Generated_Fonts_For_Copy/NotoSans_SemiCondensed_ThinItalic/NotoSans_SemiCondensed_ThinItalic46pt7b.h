#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
  0xC0, 0xC0, 0x00, 0x20, 0x90, 0x48, 0x2C, 0x34, 0x12, 0x09, 0x04, 0x82,
  0x42, 0x41, 0x20, 0x90, 0x40, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20, 0x10, 0x00,
  0x20, 0x30, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x1F,
  0xFF, 0xFF, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x00,
  0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x00, 0x03,
  0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x02, 0x00, 0xFF, 0xFF, 0xF8, 0x04,
  0x02, 0x00, 0x04, 0x06, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x08,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10,
  0x18, 0x00, 0x10, 0x10, 0x00, 0x20, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0C, 0x47, 0x03,
  0x04, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x00,
  0xC1, 0x80, 0x0C, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00,
  0x01, 0xB0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x26,
  0x00, 0x04, 0x30, 0x00, 0x41, 0x00, 0x04, 0x18, 0x00, 0x40, 0x80, 0x04,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x20, 0x81,
  0x86, 0x0F, 0x93, 0x80, 0x1F, 0xE0, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x01, 0x03, 0x08,
  0x00, 0xC0, 0x81, 0x00, 0x60, 0x40, 0x40, 0x10, 0x30, 0x10, 0x0C, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x80, 0x40, 0xC0, 0x40, 0x10, 0x20,
  0x10, 0x0C, 0x10, 0x04, 0x03, 0x0C, 0x03, 0x00, 0x82, 0x00, 0xC0, 0x21,
  0x00, 0x30, 0x18, 0xC7, 0xCC, 0x04, 0x23, 0x1B, 0x01, 0x11, 0x82, 0xC0,
  0x8C, 0x40, 0xD0, 0x62, 0x20, 0x36, 0x31, 0x88, 0x0C, 0xF8, 0xC6, 0x03,
  0x00, 0x21, 0x00, 0xC0, 0x18, 0x40, 0x20, 0x04, 0x30, 0x08, 0x02, 0x0C,
  0x02, 0x01, 0x82, 0x00, 0x80, 0x40, 0x80, 0x60, 0x20, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x04, 0x02, 0x03, 0x02, 0x00, 0x80, 0x81, 0x80, 0x20, 0x60,
  0x40, 0x0C, 0x30, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x00, 0x04, 0x03, 0x00, 0x18, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x18, 0x00, 0x80, 0x30, 0x01, 0x00, 0x40,
  0x02, 0x01, 0x80, 0x04, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x0C,
  0x20, 0x00, 0x30, 0x40, 0x18, 0xC0, 0x40, 0x23, 0x00, 0xC0, 0x44, 0x00,
  0x81, 0x10, 0x01, 0x82, 0x20, 0x01, 0x08, 0xC0, 0x03, 0x31, 0x00, 0x02,
  0x42, 0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x08, 0x00, 0x6C,
  0x18, 0x01, 0x88, 0x18, 0x0C, 0x18, 0x1F, 0xF0, 0x10, 0x24, 0xB4, 0x92,
  0x52, 0x40, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x80, 0x60, 0x80,
  0x31, 0x00, 0x0D, 0x07, 0x03, 0xFC, 0x03, 0x00, 0x04, 0x80, 0x08, 0x80,
  0x30, 0x40, 0x60, 0x40, 0xC0, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0xFF,
  0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x0C, 0x30, 0x86, 0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0xFF, 0xC0, 0x5F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18,
  0x30, 0x04, 0x03, 0x01, 0x00, 0x20, 0x60, 0x06, 0x08, 0x00, 0x42, 0x00,
  0x08, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x01,
  0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x63, 0x00, 0x08,
  0x60, 0x03, 0x04, 0x00, 0x40, 0x80, 0x10, 0x08, 0x06, 0x01, 0x81, 0x80,
  0x1F, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x68, 0x32, 0x31, 0x98, 0x48, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0x03, 0x00, 0xC0, 0x04, 0x04, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x18, 0x01, 0x80,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00,
  0x01, 0xA0, 0x00, 0x1B, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x00, 0x84,
  0x00, 0x0C, 0x20, 0x00, 0xC3, 0x00, 0x04, 0x10, 0x00, 0x40, 0x80, 0x04,
  0x04, 0x00, 0x60, 0x20, 0x06, 0x03, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80,
  0x30, 0x04, 0x03, 0x00, 0x20, 0x10, 0x03, 0x01, 0x00, 0x10, 0x10, 0x00,
  0x81, 0x80, 0x04, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x20, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x02, 0x00, 0x30, 0x18, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x1F, 0xC0, 0x27, 0x06, 0x02, 0xC0,
  0x10, 0x58, 0x01, 0x87, 0x00, 0x08, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40,
  0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x04, 0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x60,
  0x20, 0x0C, 0x01, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0C, 0x0C, 0x01, 0x80, 0x20, 0x30,
  0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x20, 0x20, 0x04, 0x01, 0x00, 0x80,
  0x18, 0x30, 0x00, 0xCE, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x30, 0xC0,
  0x0C, 0x02, 0x01, 0x80, 0x10, 0x20, 0x01, 0x86, 0x00, 0x08, 0x40, 0x00,
  0x8C, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00,
  0x08, 0x40, 0x01, 0x84, 0x00, 0x10, 0x20, 0x02, 0x03, 0x80, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x02,
  0x06, 0x00, 0x20, 0x40, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00,
  0x03, 0x10, 0x00, 0x61, 0x00, 0x06, 0x18, 0x00, 0xA0, 0xC0, 0x16, 0x06,
  0x06, 0x40, 0x3F, 0xC4, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xFF, 0x80,
  0x00, 0x06, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x30, 0x60, 0x00, 0xC0,
  0x30, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x31, 0x80, 0x3F, 0xC0, 0xC4, 0x01, 0x81, 0x01, 0x30, 0x08,
  0x0C, 0x04, 0x80, 0x40, 0x20, 0x12, 0x02, 0x00, 0x80, 0xD8, 0x18, 0x02,
  0x03, 0x40, 0x40, 0x18, 0x09, 0x01, 0x00, 0x40, 0x2C, 0x08, 0x01, 0x00,
  0xB0, 0x20, 0x04, 0x06, 0x80, 0x80, 0x30, 0x12, 0x02, 0x00, 0x80, 0x48,
  0x08, 0x06, 0x03, 0x20, 0x20, 0x18, 0x08, 0x80, 0x80, 0xA0, 0x42, 0x02,
  0x06, 0x83, 0x0C, 0x06, 0x31, 0x18, 0x30, 0x0F, 0x07, 0x80, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x04, 0x30, 0x00, 0x10, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x02,
  0x01, 0x00, 0x18, 0x04, 0x00, 0x40, 0x10, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x7F, 0xFE, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x81,
  0x80, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00,
  0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xC0, 0x00, 0x04, 0x03, 0xFF, 0x80, 0x10, 0x0F, 0x00, 0x80, 0x0C, 0x04,
  0x00, 0x30, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x60, 0x00, 0x43, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80,
  0x02, 0x04, 0x00, 0x30, 0x60, 0x06, 0x03, 0xFF, 0xC0, 0x10, 0x0F, 0x00,
  0x80, 0x0C, 0x04, 0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00,
  0x30, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x62, 0x00, 0x02, 0x10,
  0x00, 0x10, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x18,
  0x10, 0x07, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x40, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x04, 0x07, 0x80, 0x08, 0x01, 0xC0, 0x10, 0x00,
  0xC0, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x02, 0x00, 0x03,
  0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10,
  0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x30, 0x80, 0x00, 0x41, 0x00, 0x01, 0x82, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x10, 0x00, 0x60, 0x20, 0x03, 0x00, 0x40, 0x3C, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x01, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFC, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x20, 0x18, 0x00, 0x20, 0x0C,
  0x00, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x40, 0x40, 0x00, 0x10,
  0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x01,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x02,
  0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x40, 0x60, 0x00, 0x10, 0x10, 0x00,
  0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30,
  0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x01, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x03, 0x01, 0x00,
  0x06, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x02, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x04, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x04, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x09, 0xA0, 0x00, 0x0B, 0x20, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01,
  0x00, 0x40, 0x01, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFF, 0xFE,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0x40, 0x00, 0x05, 0x01, 0x40, 0x00, 0x0B, 0x03, 0x40, 0x00, 0x0A,
  0x02, 0x40, 0x00, 0x12, 0x02, 0x40, 0x00, 0x32, 0x02, 0x40, 0x00, 0x26,
  0x06, 0x40, 0x00, 0x66, 0x04, 0x60, 0x00, 0x44, 0x04, 0x20, 0x00, 0xC4,
  0x04, 0x20, 0x00, 0x84, 0x04, 0x20, 0x01, 0x0C, 0x0C, 0x20, 0x01, 0x08,
  0x08, 0x20, 0x02, 0x08, 0x08, 0x20, 0x06, 0x08, 0x08, 0x20, 0x04, 0x08,
  0x08, 0x30, 0x0C, 0x18, 0x18, 0x10, 0x08, 0x10, 0x10, 0x10, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x10, 0x30, 0x10, 0x20, 0x30,
  0x30, 0x10, 0x40, 0x20, 0x20, 0x18, 0xC0, 0x20, 0x20, 0x18, 0x80, 0x20,
  0x20, 0x09, 0x80, 0x60, 0x60, 0x09, 0x00, 0x40, 0x40, 0x0B, 0x00, 0x40,
  0x40, 0x0A, 0x00, 0x40, 0x40, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x06, 0x00, 0x01, 0x00, 0xE0,
  0x00, 0x20, 0x14, 0x00, 0x0C, 0x06, 0x80, 0x01, 0x00, 0x98, 0x00, 0x20,
  0x11, 0x00, 0x04, 0x02, 0x20, 0x00, 0x80, 0xC2, 0x00, 0x30, 0x18, 0x40,
  0x04, 0x02, 0x08, 0x00, 0x80, 0x40, 0x80, 0x10, 0x08, 0x10, 0x06, 0x03,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x18, 0x0C, 0x01, 0x02, 0x01, 0x00, 0x30, 0x40, 0x20,
  0x02, 0x08, 0x04, 0x00, 0x41, 0x01, 0x80, 0x0C, 0x60, 0x30, 0x00, 0x88,
  0x04, 0x00, 0x11, 0x00, 0x80, 0x03, 0x20, 0x10, 0x00, 0x24, 0x06, 0x00,
  0x05, 0x80, 0x80, 0x00, 0xE0, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x08, 0x03, 0x00, 0x04, 0x06, 0x00, 0x06, 0x04, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x01, 0x20, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x20, 0x7C,
  0x02, 0x00, 0x60, 0x20, 0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x18, 0x00, 0x61, 0x00, 0x0C, 0x10,
  0x01, 0x81, 0x00, 0xE0, 0x1F, 0xF8, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x30,
  0x01, 0x80, 0x08, 0x03, 0x00, 0x04, 0x06, 0x00, 0x06, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x02, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60, 0x20, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFE, 0x00,
  0x20, 0x7C, 0x02, 0x00, 0x60, 0x20, 0x03, 0x02, 0x00, 0x10, 0x60, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00,
  0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x41, 0x00,
  0x18, 0x10, 0x07, 0x01, 0xFF, 0xC0, 0x10, 0x10, 0x03, 0x01, 0x00, 0x20,
  0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x60, 0x04, 0x04,
  0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x20,
  0x80, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0x01, 0xC0, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x18, 0x03, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x18, 0x00, 0x02, 0x08, 0x00,
  0x03, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x30,
  0x00, 0x04, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C,
  0x02, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x03,
  0x08, 0x00, 0x20, 0x80, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x04, 0x00,
  0x80, 0x40, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x40,
  0x60, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x41, 0x80, 0x04,
  0x10, 0x00, 0x63, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00,
  0x2C, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0xC0, 0x10, 0x80,
  0x20, 0xC0, 0x20, 0x80, 0x20, 0xC0, 0x20, 0x80, 0x40, 0xC0, 0x60, 0x80,
  0x40, 0xC0, 0x40, 0x80, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0x80, 0x81,
  0x80, 0x41, 0x80, 0x81, 0x00, 0x41, 0x00, 0x81, 0x00, 0x43, 0x00, 0x82,
  0x00, 0x42, 0x00, 0x82, 0x00, 0x42, 0x00, 0xC6, 0x00, 0x44, 0x00, 0xC4,
  0x00, 0x44, 0x00, 0xCC, 0x00, 0x4C, 0x00, 0xC8, 0x00, 0x48, 0x00, 0xC8,
  0x00, 0x58, 0x00, 0xD0, 0x00, 0x50, 0x00, 0xD0, 0x00, 0x50, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x04, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x20, 0x06, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x08, 0x10, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80,
  0x20, 0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x10, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00,
  0x10, 0xC0, 0x06, 0x08, 0x00, 0x81, 0x00, 0x20, 0x20, 0x0C, 0x06, 0x01,
  0x00, 0x40, 0x40, 0x08, 0x18, 0x01, 0x02, 0x00, 0x20, 0x80, 0x06, 0x30,
  0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x00,
  0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x41, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41,
  0x04, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x01,
  0xFE, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00,
  0x04, 0x60, 0x01, 0x84, 0x00, 0x20, 0x80, 0x08, 0x10, 0x03, 0x01, 0x00,
  0x40, 0x20, 0x18, 0x04, 0x06, 0x00, 0x40, 0x80, 0x08, 0x30, 0x01, 0x04,
  0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x06, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0x86, 0x10, 0xC2, 0x08, 0x60, 0x00, 0x38, 0x00, 0x3D, 0xC4,
  0x0C, 0x0C, 0x82, 0x00, 0xB0, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x31,
  0x00, 0x06, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x4C,
  0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x10,
  0x00, 0x62, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00, 0xA0, 0x80, 0x34, 0x10,
  0x0D, 0x81, 0x03, 0x20, 0x1F, 0x84, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x0E, 0x00, 0x47,
  0xB8, 0x04, 0xC0, 0xC0, 0x58, 0x06, 0x0F, 0x00, 0x20, 0xA0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x01, 0x18, 0x00, 0x11, 0x80, 0x03, 0x10, 0x00, 0x31,
  0x00, 0x03, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06,
  0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x01,
  0x05, 0x00, 0x30, 0x50, 0x06, 0x08, 0x80, 0xC0, 0x87, 0xF0, 0x00, 0x00,
  0x3C, 0x01, 0xEF, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x10, 0x0F,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x03, 0x81, 0x00, 0x7B, 0x8C, 0x03, 0x01,
  0x20, 0x10, 0x02, 0x80, 0x80, 0x0A, 0x06, 0x00, 0x28, 0x10, 0x00, 0x60,
  0x80, 0x01, 0x02, 0x00, 0x04, 0x18, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x00,
  0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x14, 0x0C,
  0x00, 0xF0, 0x10, 0x06, 0x80, 0x40, 0x32, 0x00, 0x81, 0x88, 0x01, 0xFC,
  0x20, 0x00, 0x00, 0x38, 0x00, 0xF7, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0xC0,
  0x10, 0xC0, 0x0C, 0x40, 0x04, 0x60, 0x02, 0x20, 0x03, 0x30, 0x03, 0x10,
  0x03, 0x08, 0x0E, 0x07, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x10, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0x84, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xEE, 0x10, 0x0C, 0x04, 0x80, 0x40, 0x0A, 0x02, 0x00, 0x28, 0x18,
  0x00, 0xA0, 0x40, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x60, 0x00,
  0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x82,
  0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x03, 0x02, 0x00,
  0x0C, 0x08, 0x00, 0x50, 0x30, 0x03, 0xC0, 0x40, 0x1A, 0x01, 0x00, 0xC8,
  0x02, 0x06, 0x20, 0x07, 0xF1, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x02, 0x00, 0x60, 0x0E, 0x07, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x38, 0x02, 0x3D, 0xC0, 0x4C, 0x04, 0x0A, 0x00, 0xC3, 0xC0, 0x08,
  0x50, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20, 0x01, 0x8C, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x31, 0x80, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC6, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x18, 0x00, 0x42, 0x00, 0x08, 0x00,
  0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x98, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x82, 0x00, 0x60, 0x40,
  0x18, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x60, 0x08, 0x08, 0x01, 0x02,
  0x00, 0x60, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x23, 0x00, 0x04, 0xA0,
  0x01, 0xA6, 0x00, 0x28, 0x40, 0x06, 0x0C, 0x00, 0x80, 0x80, 0x10, 0x10,
  0x06, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0xC0, 0x40, 0x08,
  0x18, 0x01, 0x82, 0x00, 0x10, 0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x00, 0x00, 0x1E,
  0x00, 0xE0, 0x11, 0xDC, 0x1F, 0xE0, 0x48, 0x18, 0xC0, 0xC1, 0x40, 0x26,
  0x01, 0x0A, 0x00, 0xF0, 0x04, 0x38, 0x01, 0x80, 0x10, 0xC0, 0x04, 0x00,
  0x42, 0x00, 0x30, 0x01, 0x08, 0x00, 0xC0, 0x04, 0x60, 0x02, 0x00, 0x11,
  0x00, 0x08, 0x00, 0xC4, 0x00, 0x20, 0x02, 0x10, 0x01, 0x80, 0x08, 0xC0,
  0x04, 0x00, 0x22, 0x00, 0x10, 0x00, 0x88, 0x00, 0x40, 0x06, 0x20, 0x01,
  0x00, 0x10, 0x80, 0x0C, 0x00, 0x46, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80,
  0x04, 0x40, 0x02, 0x00, 0x31, 0x00, 0x18, 0x00, 0x84, 0x00, 0x40, 0x02,
  0x30, 0x01, 0x00, 0x08, 0x80, 0x04, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x8F,
  0x70, 0x13, 0x01, 0x02, 0x80, 0x30, 0xA0, 0x02, 0x14, 0x00, 0x43, 0x00,
  0x08, 0x60, 0x03, 0x08, 0x00, 0x63, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x0C, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x31, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0xC6, 0x00, 0x10, 0x80, 0x02, 0x00, 0x00, 0x38, 0x00, 0x7B,
  0xC0, 0x30, 0x18, 0x10, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x11, 0x00, 0x04,
  0xC0, 0x01, 0x20, 0x00, 0x58, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x68, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x02, 0x10, 0x01, 0x86, 0x00, 0xC0,
  0xC0, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x04, 0x7B, 0x80, 0x13,
  0x03, 0x00, 0x58, 0x06, 0x02, 0xC0, 0x08, 0x0A, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x00, 0x03, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x06, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x08,
  0x18, 0x00, 0x40, 0x50, 0x03, 0x01, 0x40, 0x18, 0x0C, 0x80, 0xC0, 0x21,
  0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1E,
  0xE1, 0x03, 0x01, 0x20, 0x40, 0x0A, 0x08, 0x00, 0xA1, 0x80, 0x0A, 0x10,
  0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0xC4,
  0x00, 0x08, 0x40, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x18,
  0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x50, 0xC0, 0x0F,
  0x04, 0x01, 0xA0, 0x40, 0x32, 0x02, 0x06, 0x20, 0x1F, 0xC6, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x1E, 0x08, 0xFC, 0x13, 0x00, 0x2C, 0x00, 0xB0, 0x01,
  0x40, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x00, 0x70, 0x03, 0xDF, 0x06, 0x01, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0xC0,
  0x30, 0x7F, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x1F,
  0xF8, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x21,
  0x00, 0x0C, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x8C,
  0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x30,
  0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x18, 0xC0,
  0x02, 0x10, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x05, 0x08, 0x01, 0xC1, 0x80,
  0x68, 0x18, 0x19, 0x01, 0xFC, 0x20, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00,
  0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x00, 0x20, 0x80, 0x30, 0x40,
  0x10, 0x30, 0x18, 0x08, 0x08, 0x04, 0x0C, 0x02, 0x04, 0x01, 0x06, 0x00,
  0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80, 0x06, 0x80,
  0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x50, 0x05, 0x00, 0x68, 0x02, 0x80,
  0x24, 0x03, 0x40, 0x12, 0x01, 0x30, 0x11, 0x01, 0x98, 0x08, 0x80, 0x84,
  0x08, 0x40, 0xC2, 0x04, 0x20, 0x41, 0x06, 0x10, 0x60, 0x82, 0x08, 0x20,
  0x43, 0x04, 0x30, 0x21, 0x02, 0x10, 0x10, 0x81, 0x08, 0x08, 0x80, 0x88,
  0x04, 0x40, 0x44, 0x02, 0x40, 0x24, 0x01, 0x20, 0x12, 0x00, 0xB0, 0x0A,
  0x00, 0x50, 0x05, 0x00, 0x28, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x02, 0x00, 0x18, 0x18, 0x01, 0x80, 0x40, 0x18, 0x03, 0x00, 0x80, 0x08,
  0x08, 0x00, 0x40, 0x80, 0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00,
  0x03, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x68,
  0x00, 0x02, 0x60, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x30, 0x20, 0x01,
  0x01, 0x00, 0x10, 0x0C, 0x01, 0x00, 0x20, 0x18, 0x01, 0x01, 0x80, 0x0C,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0x80, 0x06,
  0x00, 0x80, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x18,
  0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60,
  0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x22, 0x00, 0x00, 0x22, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x28, 0x00, 0x00, 0x28, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x38, 0x18, 0x0E, 0x00, 0xE7, 0x00,
  0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 9, 12, 13, 5, -33 },
  { 53, 24, 33, 24, 1, -33 },
  { 152, 20, 38, 22, 1, -35 },
  { 247, 26, 34, 31, 3, -33 },
  { 358, 23, 33, 25, 1, -33 },
  { 453, 3, 12, 7, 5, -33 },
  { 458, 13, 40, 11, 1, -33 },
  { 523, 13, 40, 11, -3, -33 },
  { 588, 16, 17, 21, 6, -35 },
  { 622, 19, 21, 23, 3, -27 },
  { 672, 6, 11, 8, -2, -5 },
  { 681, 10, 1, 14, 2, -13 },
  { 683, 3, 3, 9, 1, -3 },
  { 685, 19, 33, 14, -2, -33 },
  { 764, 19, 33, 22, 2, -33 },
  { 843, 10, 33, 22, 7, -33 },
  { 885, 21, 33, 22, 0, -33 },
  { 972, 21, 33, 22, 0, -33 },
  { 1059, 21, 33, 22, 0, -33 },
  { 1146, 21, 33, 22, 1, -33 },
  { 1233, 20, 33, 22, 2, -33 },
  { 1316, 19, 33, 22, 4, -33 },
  { 1395, 20, 33, 22, 1, -33 },
  { 1478, 20, 33, 22, 1, -33 },
  { 1561, 7, 24, 9, 1, -24 },
  { 1582, 10, 30, 9, -2, -24 },
  { 1620, 19, 20, 23, 3, -27 },
  { 1668, 19, 11, 23, 3, -22 },
  { 1695, 19, 20, 23, 3, -27 },
  { 1743, 14, 33, 16, 3, -33 },
  { 1801, 30, 37, 33, 2, -33 },
  { 1940, 22, 33, 21, -3, -33 },
  { 2031, 21, 33, 24, 2, -33 },
  { 2118, 22, 33, 23, 3, -33 },
  { 2209, 23, 33, 27, 2, -33 },
  { 2304, 22, 33, 21, 1, -33 },
  { 2395, 22, 33, 19, 1, -33 },
  { 2486, 24, 33, 28, 3, -33 },
  { 2585, 26, 33, 27, 1, -33 },
  { 2693, 14, 33, 11, -1, -33 },
  { 2751, 17, 41, 9, -7, -33 },
  { 2839, 24, 33, 22, 1, -33 },
  { 2938, 15, 33, 19, 1, -33 },
  { 3000, 32, 33, 33, 1, -33 },
  { 3132, 27, 33, 27, 1, -33 },
  { 3244, 24, 33, 28, 3, -33 },
  { 3343, 20, 33, 22, 2, -33 },
  { 3426, 24, 41, 28, 3, -33 },
  { 3549, 20, 33, 22, 2, -33 },
  { 3632, 21, 33, 20, 0, -33 },
  { 3719, 19, 33, 19, 4, -33 },
  { 3798, 25, 33, 27, 3, -33 },
  { 3902, 20, 33, 21, 5, -33 },
  { 3985, 32, 33, 34, 5, -33 },
  { 4117, 26, 33, 19, -3, -33 },
  { 4225, 19, 33, 19, 4, -33 },
  { 4304, 24, 33, 21, -1, -33 },
  { 4403, 17, 40, 13, -1, -33 },
  { 4488, 6, 33, 14, 5, -33 },
  { 4513, 17, 40, 13, -3, -33 },
  { 4598, 19, 19, 23, 2, -33 },
  { 4644, 16, 1, 15, -4, 5 },
  { 4646, 5, 7, 10, 7, -35 },
  { 4651, 19, 25, 22, 2, -25 },
  { 4711, 20, 35, 23, 1, -35 },
  { 4799, 16, 25, 18, 2, -25 },
  { 4849, 22, 35, 23, 2, -35 },
  { 4946, 17, 25, 20, 2, -25 },
  { 5000, 23, 46, 11, -6, -35 },
  { 5133, 22, 36, 23, 0, -25 },
  { 5232, 19, 35, 22, 1, -35 },
  { 5316, 9, 33, 9, 1, -33 },
  { 5354, 16, 44, 9, -6, -33 },
  { 5442, 19, 35, 18, 1, -35 },
  { 5526, 9, 35, 9, 1, -35 },
  { 5566, 30, 25, 34, 1, -25 },
  { 5660, 19, 25, 22, 1, -25 },
  { 5720, 18, 25, 23, 2, -25 },
  { 5777, 22, 36, 23, -1, -25 },
  { 5876, 20, 36, 23, 2, -25 },
  { 5966, 15, 25, 15, 1, -25 },
  { 6013, 16, 25, 17, 0, -25 },
  { 6063, 11, 30, 12, 2, -30 },
  { 6105, 19, 24, 22, 2, -24 },
  { 6162, 17, 24, 17, 2, -24 },
  { 6213, 25, 24, 27, 3, -24 },
  { 6288, 21, 24, 18, -2, -24 },
  { 6351, 24, 35, 17, -5, -24 },
  { 6456, 18, 24, 17, -1, -24 },
  { 6510, 16, 40, 15, 1, -33 },
  { 6590, 1, 46, 21, 11, -35 },
  { 6596, 16, 40, 15, -3, -33 },
  { 6676, 19, 4, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC46PT7B_H_
