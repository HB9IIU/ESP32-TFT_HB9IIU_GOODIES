#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x30, 0x90, 0x48, 0x64, 0x22,
  0x12, 0x09, 0x04, 0x84, 0x42, 0x21, 0x20, 0x80, 0x00, 0x10, 0x30, 0x01,
  0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x20, 0x20,
  0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x20,
  0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80, 0x0C, 0x08, 0x00,
  0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x20, 0x01, 0x01, 0x01, 0xFF, 0xFF,
  0xC0, 0x40, 0xC0, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x18,
  0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0xFF, 0x80, 0xC6, 0x10, 0x61, 0x00, 0x10, 0x40, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00, 0x62,
  0x00, 0x0D, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x01, 0x10,
  0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x40, 0x04, 0x30, 0xC1, 0x30, 0x0F, 0xF0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x0C, 0x30,
  0x80, 0x10, 0x41, 0x80, 0x41, 0x01, 0x01, 0x82, 0x02, 0x02, 0x0C, 0x04,
  0x08, 0x10, 0x08, 0x10, 0x20, 0x30, 0x40, 0x40, 0x41, 0x81, 0x00, 0x82,
  0x02, 0x01, 0x08, 0x04, 0x02, 0x30, 0x08, 0x08, 0x47, 0xD0, 0x11, 0x10,
  0xE0, 0x66, 0x60, 0xC0, 0x88, 0x81, 0x42, 0x22, 0x02, 0xF8, 0xC4, 0x04,
  0x01, 0x18, 0x08, 0x04, 0x20, 0x10, 0x18, 0x40, 0x20, 0x20, 0x80, 0x40,
  0x81, 0x01, 0x01, 0x06, 0x02, 0x04, 0x0C, 0x04, 0x10, 0x18, 0x18, 0x20,
  0x30, 0x20, 0x80, 0x20, 0xC3, 0x00, 0x43, 0x0C, 0x00, 0x7C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x08, 0x00, 0x60, 0x20, 0x02, 0x01,
  0x00, 0x30, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0x02,
  0x01, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x02, 0x10, 0x00, 0x0B, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x20, 0x08, 0x81,
  0x80, 0x88, 0x04, 0x04, 0xC0, 0x10, 0x44, 0x00, 0x82, 0x60, 0x02, 0x22,
  0x00, 0x11, 0x10, 0x00, 0x50, 0x80, 0x03, 0x04, 0x00, 0x18, 0x30, 0x01,
  0xE0, 0x80, 0x11, 0x06, 0x03, 0x04, 0x0F, 0xF0, 0x30, 0x32, 0x22, 0x24,
  0x44, 0x44, 0x80, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x0C, 0x10, 0x06, 0x20, 0x02, 0x40, 0x03, 0xFF, 0x03, 0x00,
  0x0A, 0x00, 0x22, 0x00, 0x84, 0x06, 0x04, 0x08, 0x08, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x0C, 0x20, 0x86, 0x10, 0x42,
  0x08, 0x43, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x81, 0x80, 0x80, 0x40, 0x80, 0x10, 0xC0,
  0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x30, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02,
  0xC0, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x60, 0x04, 0x10, 0x04, 0x08,
  0x04, 0x02, 0x06, 0x00, 0xFC, 0x00, 0x01, 0x81, 0xC1, 0x23, 0x22, 0x16,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x10, 0x08, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x30, 0x18, 0x18, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x0C, 0x01,
  0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x05, 0x00,
  0x01, 0xA0, 0x00, 0x24, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0xC4, 0x00,
  0x30, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x18, 0x10, 0x02,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x08, 0x02, 0x03, 0x00, 0x40, 0x40,
  0x08, 0x10, 0x01, 0x04, 0x00, 0x41, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0xBE, 0x00, 0x38,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x08, 0x03,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x23, 0xF8, 0x13, 0x01, 0x05,
  0x00, 0x21, 0x80, 0x08, 0x60, 0x03, 0x10, 0x00, 0x4C, 0x00, 0x13, 0x00,
  0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04,
  0x10, 0x01, 0x04, 0x00, 0x81, 0x80, 0x60, 0x30, 0x30, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x30, 0x08, 0x03, 0x03,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x04,
  0x00, 0x40, 0x80, 0x10, 0x18, 0x06, 0x01, 0x01, 0x80, 0x10, 0xC0, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x18, 0x80, 0x0C, 0x0C, 0x02, 0x00, 0x80, 0x80,
  0x08, 0x20, 0x01, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x41, 0x00, 0x08, 0x30, 0x02, 0x03, 0x01,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x40, 0x40, 0x20, 0x08, 0x10,
  0x02, 0x0C, 0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x31,
  0x00, 0x18, 0x60, 0x0A, 0x0C, 0x0C, 0x81, 0xFE, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x3F, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x40,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x03, 0x18, 0x00, 0x00, 0x22, 0x00, 0xFE, 0x04,
  0x80, 0x60, 0x40, 0x90, 0x18, 0x18, 0x16, 0x06, 0x02, 0x02, 0x80, 0x80,
  0x40, 0x50, 0x20, 0x08, 0x0A, 0x04, 0x03, 0x03, 0xC1, 0x80, 0x40, 0x50,
  0x20, 0x08, 0x0A, 0x04, 0x03, 0x01, 0x40, 0x80, 0x40, 0x48, 0x10, 0x08,
  0x09, 0x02, 0x03, 0x02, 0x20, 0x40, 0xE0, 0xC4, 0x0C, 0x32, 0x30, 0x80,
  0xFC, 0x7C, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x50, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00,
  0x20, 0x40, 0x04, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x7F, 0xF8, 0x08, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x18, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x05, 0x80,
  0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x80,
  0x30, 0x0C, 0x02, 0x00, 0x20, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00,
  0x20, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x70, 0x0F, 0xFC, 0x01, 0x80,
  0x30, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30,
  0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0x84,
  0x00, 0x18, 0x40, 0x03, 0x04, 0x00, 0x60, 0x40, 0x1C, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x0E, 0x01, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x02,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0C, 0x07, 0x00, 0x20, 0x06, 0x00,
  0x80, 0x0C, 0x02, 0x00, 0x18, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00,
  0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x04, 0x30, 0x00,
  0x10, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x20, 0x00, 0x81,
  0x00, 0x06, 0x04, 0x00, 0x30, 0x10, 0x03, 0x00, 0x40, 0x70, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x03, 0xFC, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x06, 0x00, 0x08, 0x0C, 0x00,
  0x20, 0x18, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00,
  0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00,
  0x04, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00,
  0x08, 0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x08, 0x10, 0x00, 0x10, 0x10, 0x00,
  0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00,
  0x20, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00,
  0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0x03, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0xFC, 0x00, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x20, 0x03,
  0x00, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x30, 0x01,
  0x01, 0x80, 0x04, 0x0C, 0x00, 0x10, 0x60, 0x00, 0xC3, 0x00, 0x02, 0x18,
  0x00, 0x08, 0xC0, 0x00, 0x27, 0x00, 0x00, 0xB4, 0x00, 0x07, 0x90, 0x00,
  0x1C, 0x20, 0x00, 0x40, 0x80, 0x01, 0x03, 0x00, 0x04, 0x04, 0x00, 0x30,
  0x10, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x03, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x03, 0x03,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60,
  0x28, 0x00, 0x03, 0x80, 0xA0, 0x00, 0x0A, 0x02, 0x80, 0x00, 0x78, 0x0A,
  0x00, 0x01, 0x40, 0x48, 0x00, 0x09, 0x01, 0x20, 0x00, 0x24, 0x04, 0x80,
  0x01, 0x10, 0x11, 0x00, 0x04, 0xC0, 0xC4, 0x00, 0x22, 0x02, 0x10, 0x01,
  0x88, 0x08, 0x40, 0x04, 0x20, 0x21, 0x00, 0x30, 0x80, 0x84, 0x00, 0x86,
  0x06, 0x10, 0x04, 0x10, 0x10, 0x40, 0x10, 0x40, 0x40, 0x80, 0x81, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x30, 0x20, 0xC0, 0x80, 0x80,
  0x82, 0x02, 0x02, 0x02, 0x18, 0x08, 0x08, 0x08, 0x40, 0x60, 0x20, 0x22,
  0x01, 0x01, 0x00, 0x48, 0x04, 0x04, 0x01, 0x40, 0x10, 0x10, 0x05, 0x00,
  0x40, 0x40, 0x18, 0x03, 0x03, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x01,
  0x03, 0x00, 0x01, 0x03, 0x80, 0x03, 0x02, 0x80, 0x02, 0x02, 0x80, 0x02,
  0x02, 0xC0, 0x02, 0x04, 0x40, 0x02, 0x04, 0x40, 0x06, 0x04, 0x60, 0x04,
  0x04, 0x20, 0x04, 0x0C, 0x20, 0x04, 0x08, 0x30, 0x04, 0x08, 0x10, 0x08,
  0x08, 0x10, 0x08, 0x08, 0x08, 0x08, 0x18, 0x08, 0x08, 0x10, 0x08, 0x18,
  0x10, 0x04, 0x10, 0x10, 0x04, 0x10, 0x10, 0x04, 0x10, 0x30, 0x02, 0x10,
  0x20, 0x02, 0x30, 0x20, 0x02, 0x20, 0x20, 0x01, 0x20, 0x20, 0x01, 0x20,
  0x40, 0x01, 0x20, 0x40, 0x00, 0xE0, 0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0,
  0xC0, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x06, 0x01, 0x80, 0x30, 0x03, 0x01,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00,
  0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02,
  0x40, 0x00, 0x0B, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC1,
  0x00, 0x02, 0x04, 0x00, 0x10, 0x08, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x30, 0x18, 0x02, 0x00, 0x40, 0x20, 0x06,
  0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x40, 0x80,
  0x08, 0x08, 0x01, 0x81, 0x80, 0x60, 0x1F, 0xF8, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x01, 0x80, 0x30,
  0x03, 0x01, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00,
  0x8C, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0,
  0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0xC0,
  0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x10, 0x08, 0x00, 0x80, 0x18, 0x0C,
  0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xFE, 0x00, 0x60, 0x30, 0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x02, 0x04,
  0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x00, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x03, 0x02, 0x00, 0xC0, 0xC1,
  0xF0, 0x1F, 0xF0, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x0C, 0x03, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x03, 0x01, 0x00, 0x20, 0x20, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x06, 0x00, 0x00,
  0x7F, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x0C, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00,
  0x06, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x30, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x21, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x42, 0x00, 0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x82,
  0x00, 0x04, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x30, 0x18, 0x00, 0x7F,
  0xC0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x4C,
  0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x20, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10,
  0x40, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x40, 0x0D, 0x00, 0x32,
  0x00, 0x48, 0x01, 0x10, 0x06, 0x40, 0x08, 0x80, 0x22, 0x00, 0x84, 0x01,
  0x10, 0x04, 0x20, 0x10, 0x80, 0x41, 0x00, 0x84, 0x02, 0x08, 0x08, 0x20,
  0x30, 0x40, 0x41, 0x01, 0x02, 0x06, 0x08, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x83, 0x02, 0x04, 0x04, 0x10, 0x10, 0x40, 0x20, 0x80, 0x82, 0x01, 0x08,
  0x06, 0x30, 0x08, 0x40, 0x31, 0x00, 0x44, 0x01, 0x98, 0x02, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x24, 0x00, 0x90, 0x01, 0x40, 0x05, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0x60, 0x01, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x06, 0x02, 0x00, 0x18, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x08, 0x03, 0x00, 0x08, 0x04, 0x00, 0x10, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x42, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x40, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x30, 0x40, 0x00, 0x40, 0x80, 0x01, 0x00, 0x80, 0x06, 0x01, 0x00,
  0x08, 0x02, 0x00, 0x20, 0x06, 0x00, 0x80, 0x04, 0x03, 0x00, 0x08, 0x04,
  0x00, 0x10, 0x10, 0x00, 0x10, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xB0, 0x00,
  0xC8, 0x00, 0x44, 0x00, 0x42, 0x00, 0x61, 0x00, 0x20, 0x40, 0x20, 0x20,
  0x30, 0x10, 0x10, 0x08, 0x10, 0x06, 0x18, 0x01, 0x08, 0x00, 0x88, 0x00,
  0x4C, 0x00, 0x24, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x82,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x41, 0x06, 0x08, 0x20, 0x82, 0x08, 0x30, 0x41, 0x04, 0x10, 0x00, 0xFF,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x16, 0x00, 0x19, 0x00, 0x08, 0x80, 0x08,
  0x60, 0x0C, 0x10, 0x04, 0x08, 0x04, 0x06, 0x06, 0x01, 0x02, 0x00, 0x83,
  0x00, 0x61, 0x00, 0x11, 0x00, 0x09, 0x80, 0x06, 0x80, 0x01, 0x80, 0x00,
  0x80, 0xFF, 0xFC, 0xC2, 0x10, 0x41, 0x08, 0x20, 0x00, 0x60, 0x01, 0xFC,
  0x41, 0x81, 0x21, 0x00, 0x51, 0x80, 0x28, 0x80, 0x18, 0x80, 0x0C, 0x40,
  0x06, 0x40, 0x03, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x32, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x05,
  0x10, 0x07, 0x04, 0x06, 0x83, 0x06, 0x40, 0xFC, 0x20, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x02, 0x00, 0xC7, 0xF0, 0x26, 0x06,
  0x0B, 0x00, 0x83, 0x80, 0x30, 0xC0, 0x04, 0x60, 0x01, 0x18, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00,
  0x08, 0x80, 0x02, 0x60, 0x01, 0x98, 0x00, 0x46, 0x00, 0x31, 0x80, 0x08,
  0x60, 0x04, 0x24, 0x03, 0x09, 0x81, 0x82, 0x3F, 0x80, 0x00, 0x30, 0x07,
  0xFC, 0x18, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x02, 0x04, 0x03, 0xFC, 0x40, 0x60, 0x68, 0x08,
  0x02, 0x81, 0x80, 0x18, 0x10, 0x01, 0x82, 0x00, 0x18, 0x20, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0C,
  0x08, 0x01, 0xC0, 0x80, 0x34, 0x04, 0x02, 0x40, 0x60, 0xC8, 0x03, 0xF8,
  0x80, 0x00, 0x20, 0x03, 0xF8, 0x18, 0x10, 0x60, 0x11, 0x80, 0x22, 0x00,
  0x48, 0x00, 0x90, 0x02, 0x40, 0x0C, 0x80, 0x31, 0x01, 0x87, 0xFC, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x02, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF1, 0x01, 0x81,
  0x90, 0x20, 0x0A, 0x06, 0x00, 0x60, 0x40, 0x06, 0x08, 0x00, 0x60, 0x80,
  0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x20,
  0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00, 0x18, 0x20, 0x03, 0x82,
  0x00, 0x30, 0x20, 0x07, 0x02, 0x00, 0xD0, 0x10, 0x09, 0x01, 0x83, 0x20,
  0x0F, 0xE2, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x0E, 0x06,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x04, 0x01, 0x1F, 0xC1, 0x30, 0x30, 0xB0, 0x08, 0x70, 0x04, 0x30, 0x02,
  0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0xC4, 0x00, 0x46, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08,
  0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x61, 0x00, 0x40, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x40, 0x30, 0x40, 0x10, 0x40, 0x08, 0x60, 0x04,
  0x60, 0x02, 0x60, 0x02, 0x70, 0x01, 0x64, 0x00, 0xE2, 0x00, 0x61, 0x80,
  0x60, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x06, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x30, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80,
  0x80, 0x04, 0x10, 0x01, 0x00, 0x8F, 0xE1, 0xFC, 0x09, 0x02, 0x30, 0x20,
  0xA0, 0x16, 0x03, 0x0C, 0x01, 0x40, 0x10, 0xC0, 0x18, 0x01, 0x18, 0x01,
  0x80, 0x11, 0x80, 0x10, 0x02, 0x10, 0x01, 0x00, 0x21, 0x00, 0x30, 0x02,
  0x10, 0x02, 0x00, 0x22, 0x00, 0x20, 0x02, 0x20, 0x02, 0x00, 0x42, 0x00,
  0x20, 0x04, 0x20, 0x04, 0x00, 0x42, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00,
  0xC4, 0x00, 0x40, 0x08, 0x40, 0x0C, 0x00, 0x84, 0x00, 0x80, 0x08, 0xC0,
  0x08, 0x00, 0x88, 0x00, 0x80, 0x18, 0x80, 0x08, 0x01, 0x00, 0x04, 0x08,
  0x04, 0x3F, 0x82, 0x60, 0x61, 0x60, 0x10, 0xE0, 0x08, 0x60, 0x04, 0x60,
  0x02, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01,
  0x10, 0x01, 0x88, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x22, 0x00, 0x10, 0x00,
  0x20, 0x01, 0xFE, 0x01, 0x81, 0x81, 0x80, 0x61, 0x80, 0x10, 0x80, 0x08,
  0x80, 0x06, 0x40, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x70, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x03, 0x20, 0x01, 0x18, 0x01, 0x04, 0x01, 0x81, 0x01, 0x80, 0x7F, 0x00,
  0x01, 0x02, 0x00, 0x21, 0xFC, 0x02, 0x60, 0x60, 0x2C, 0x02, 0x02, 0x80,
  0x30, 0x30, 0x01, 0x07, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0x81,
  0x80, 0x10, 0x34, 0x03, 0x02, 0x60, 0x60, 0x23, 0xF8, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0x10, 0x60, 0x64, 0x20, 0x0A, 0x18, 0x01, 0x84, 0x00,
  0x62, 0x00, 0x18, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x0C, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80,
  0x06, 0x20, 0x03, 0x08, 0x01, 0xC2, 0x00, 0x50, 0x40, 0x24, 0x18, 0x32,
  0x03, 0xF8, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x10, 0x23, 0xF0, 0x98, 0x02, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFC, 0x30,
  0x08, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x10, 0x0C,
  0x1F, 0xF0, 0x00, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x0F, 0xFC,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xF0, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x46, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18,
  0x80, 0x0C, 0x40, 0x0C, 0x20, 0x0E, 0x10, 0x0D, 0x04, 0x0C, 0x83, 0xF8,
  0xC0, 0x80, 0x03, 0x00, 0x0B, 0x00, 0x12, 0x00, 0x44, 0x01, 0x88, 0x02,
  0x10, 0x0C, 0x20, 0x10, 0x40, 0x60, 0x80, 0x81, 0x03, 0x02, 0x04, 0x06,
  0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0,
  0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x02, 0xC0, 0x38, 0x02, 0x40, 0x28, 0x04, 0x40, 0x28, 0x04, 0x40, 0x48,
  0x08, 0x40, 0x48, 0x08, 0x40, 0x88, 0x18, 0x40, 0x88, 0x10, 0x41, 0x08,
  0x30, 0x41, 0x08, 0x20, 0x42, 0x08, 0x20, 0x42, 0x08, 0x40, 0x44, 0x04,
  0x40, 0x44, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x05, 0x80, 0x50, 0x05,
  0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x02, 0x00, 0x20, 0x40, 0x08, 0x0C, 0x02, 0x00, 0x80, 0x80, 0x10,
  0x30, 0x01, 0x04, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x02, 0x20, 0x00, 0xC4,
  0x00, 0x10, 0xC0, 0x04, 0x08, 0x01, 0x01, 0x00, 0x60, 0x10, 0x18, 0x02,
  0x02, 0x00, 0x61, 0x80, 0x04, 0x00, 0x00, 0x80, 0x06, 0x01, 0x00, 0x18,
  0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x06, 0x00,
  0x20, 0x08, 0x00, 0x40, 0x30, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01,
  0x02, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x87, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0xC0, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x1C, 0xE0, 0x1C, 0x06, 0x1A, 0x00, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 9, 11, 12, 4, -30 },
  { 44, 21, 30, 22, 1, -30 },
  { 123, 18, 34, 20, 1, -32 },
  { 200, 23, 31, 28, 3, -30 },
  { 290, 21, 30, 23, 1, -30 },
  { 369, 4, 11, 7, 4, -30 },
  { 375, 12, 37, 10, 1, -30 },
  { 431, 12, 37, 10, -3, -30 },
  { 487, 15, 15, 19, 5, -32 },
  { 516, 18, 19, 21, 2, -24 },
  { 559, 6, 10, 7, -2, -5 },
  { 567, 10, 1, 12, 1, -12 },
  { 569, 2, 2, 8, 1, -2 },
  { 570, 18, 30, 13, -2, -30 },
  { 638, 17, 30, 20, 2, -30 },
  { 702, 9, 30, 20, 6, -30 },
  { 736, 19, 30, 20, 0, -30 },
  { 808, 19, 30, 20, 0, -30 },
  { 880, 19, 30, 20, 0, -30 },
  { 952, 19, 30, 20, 1, -30 },
  { 1024, 18, 30, 20, 2, -30 },
  { 1092, 17, 30, 20, 4, -30 },
  { 1156, 19, 30, 20, 1, -30 },
  { 1228, 18, 30, 20, 1, -30 },
  { 1296, 6, 22, 8, 1, -22 },
  { 1313, 9, 27, 8, -2, -22 },
  { 1344, 18, 18, 21, 2, -24 },
  { 1385, 18, 10, 21, 2, -20 },
  { 1408, 18, 18, 21, 2, -24 },
  { 1449, 14, 30, 14, 2, -30 },
  { 1502, 27, 34, 30, 2, -30 },
  { 1617, 19, 30, 20, -2, -30 },
  { 1689, 20, 30, 22, 1, -30 },
  { 1764, 20, 30, 21, 3, -30 },
  { 1839, 22, 30, 24, 1, -30 },
  { 1922, 20, 30, 19, 1, -30 },
  { 1997, 20, 30, 18, 1, -30 },
  { 2072, 22, 30, 25, 3, -30 },
  { 2155, 24, 30, 25, 1, -30 },
  { 2245, 13, 30, 10, -1, -30 },
  { 2294, 16, 37, 9, -7, -30 },
  { 2368, 22, 30, 20, 1, -30 },
  { 2451, 13, 30, 18, 1, -30 },
  { 2500, 30, 30, 30, 1, -30 },
  { 2613, 24, 30, 25, 1, -30 },
  { 2703, 22, 30, 26, 3, -30 },
  { 2786, 20, 30, 20, 1, -30 },
  { 2861, 22, 37, 26, 3, -30 },
  { 2963, 19, 30, 20, 1, -30 },
  { 3035, 19, 30, 18, 0, -30 },
  { 3107, 17, 30, 17, 4, -30 },
  { 3171, 22, 30, 25, 3, -30 },
  { 3254, 19, 30, 20, 4, -30 },
  { 3326, 29, 30, 31, 5, -30 },
  { 3435, 23, 30, 18, -2, -30 },
  { 3522, 17, 30, 17, 4, -30 },
  { 3586, 22, 30, 19, -1, -30 },
  { 3669, 16, 37, 12, -1, -30 },
  { 3743, 6, 30, 13, 4, -30 },
  { 3766, 16, 37, 12, -3, -30 },
  { 3840, 17, 17, 21, 2, -30 },
  { 3877, 14, 1, 14, -3, 4 },
  { 3879, 5, 7, 9, 6, -32 },
  { 3884, 17, 23, 20, 2, -23 },
  { 3933, 18, 32, 21, 1, -32 },
  { 4005, 15, 23, 16, 2, -23 },
  { 4049, 20, 32, 21, 2, -32 },
  { 4129, 15, 23, 18, 2, -23 },
  { 4173, 22, 42, 10, -6, -32 },
  { 4289, 20, 33, 21, 0, -23 },
  { 4372, 17, 32, 20, 1, -32 },
  { 4440, 8, 30, 8, 1, -30 },
  { 4470, 15, 40, 8, -6, -30 },
  { 4545, 17, 32, 16, 1, -32 },
  { 4613, 8, 32, 8, 1, -32 },
  { 4645, 28, 23, 31, 1, -23 },
  { 4726, 17, 23, 20, 1, -23 },
  { 4775, 17, 23, 21, 2, -23 },
  { 4824, 20, 33, 21, -1, -23 },
  { 4907, 18, 33, 21, 2, -23 },
  { 4982, 14, 23, 13, 1, -23 },
  { 5023, 15, 23, 15, 0, -23 },
  { 5067, 10, 28, 11, 2, -28 },
  { 5102, 17, 22, 20, 2, -22 },
  { 5149, 15, 22, 15, 2, -22 },
  { 5191, 24, 22, 24, 2, -22 },
  { 5257, 19, 22, 16, -2, -22 },
  { 5310, 23, 32, 15, -5, -22 },
  { 5402, 17, 22, 15, -1, -22 },
  { 5449, 15, 37, 13, 1, -30 },
  { 5519, 1, 42, 20, 10, -32 },
  { 5525, 14, 37, 13, -2, -30 },
  { 5590, 18, 4, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC42PT7B_H_
