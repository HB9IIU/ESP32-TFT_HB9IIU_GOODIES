#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x21, 0x23, 0x42, 0x42, 0x42, 0x42, 0x44, 0x84, 0x84, 0x84, 0x00,
  0x60, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x40, 0x08, 0x10, 0x3F, 0xFF, 0xE0, 0x20, 0x40, 0x08,
  0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x02, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x1F, 0xFF, 0xF0, 0x20, 0x40, 0x04, 0x08, 0x01, 0x81,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x78,
  0x03, 0xA7, 0x06, 0x20, 0x08, 0x20, 0x08, 0x20, 0x18, 0x20, 0x10, 0x40,
  0x18, 0x40, 0x08, 0x40, 0x08, 0x40, 0x06, 0x80, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0xA0, 0x00, 0x98, 0x01, 0x08, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04,
  0x01, 0x04, 0x02, 0x08, 0x02, 0x18, 0x82, 0x30, 0x7F, 0xC0, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x10, 0x7C, 0x01, 0x04,
  0x20, 0x18, 0x41, 0x00, 0x86, 0x0C, 0x08, 0x20, 0x40, 0x41, 0x02, 0x04,
  0x10, 0x10, 0x40, 0x80, 0x82, 0x04, 0x04, 0x20, 0x20, 0x22, 0x01, 0x02,
  0x10, 0x88, 0x11, 0x1B, 0x40, 0x91, 0x0A, 0x08, 0x90, 0x30, 0xC8, 0x81,
  0x7C, 0x88, 0x08, 0x84, 0x40, 0x40, 0x42, 0x02, 0x06, 0x20, 0x20, 0x21,
  0x01, 0x02, 0x08, 0x08, 0x30, 0x40, 0x41, 0x02, 0x04, 0x10, 0x10, 0x20,
  0x80, 0x82, 0x08, 0x04, 0x30, 0x80, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x19,
  0x80, 0x04, 0x08, 0x01, 0x81, 0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x80,
  0x80, 0x30, 0x10, 0x02, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x00, 0x98,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xA0, 0x00, 0x42, 0x00, 0x10, 0x40,
  0x64, 0x04, 0x09, 0x00, 0xC3, 0x20, 0x08, 0x48, 0x00, 0x91, 0x00, 0x12,
  0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x0A, 0x18, 0x02, 0x41, 0x81, 0x84,
  0x1F, 0xE0, 0xC0, 0x25, 0x24, 0x94, 0x90, 0x00, 0x60, 0x10, 0x04, 0x01,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x00, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x41, 0x04, 0x0C, 0x20, 0x19, 0x00, 0x29, 0xE0, 0xF0,
  0x0A, 0x00, 0x88, 0x08, 0x41, 0x82, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x08, 0x44, 0x23, 0x10,
  0x88, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x03, 0xB0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x23, 0x00, 0x44, 0x00,
  0x98, 0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x20, 0x80, 0x81,
  0x83, 0x01, 0xF8, 0x00, 0x03, 0x0E, 0x1A, 0x22, 0xC2, 0x82, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x00, 0x10, 0x00, 0xF7, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xF7, 0x01,
  0xC0, 0x40, 0x80, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x20, 0x0C, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x01, 0x40,
  0x01, 0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x88, 0x00, 0x84, 0x00, 0x44,
  0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x80, 0x60, 0x40, 0x20, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x20, 0x08, 0x30, 0x04, 0x10, 0x04, 0x10, 0x02, 0x1F,
  0xFF, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x81, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x01, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x40, 0x30,
  0x3F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x73, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x21, 0x80, 0x4E, 0x30, 0x58, 0x08, 0x60, 0x0C, 0x40, 0x04, 0xC0,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x20, 0x20, 0x40, 0x1F, 0x80, 0x7F,
  0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xEE, 0x00, 0x80, 0xC0,
  0x80, 0x20, 0x40, 0x18, 0x40, 0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01,
  0x04, 0x01, 0x81, 0x00, 0x80, 0x41, 0x80, 0x31, 0x00, 0x07, 0x00, 0x0D,
  0x80, 0x18, 0x60, 0x10, 0x08, 0x10, 0x06, 0x10, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x20, 0x04,
  0x08, 0x0C, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x01, 0xDC, 0x02, 0x06, 0x04,
  0x02, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x03, 0x20, 0x03, 0x10, 0x06, 0x18,
  0x0A, 0x0E, 0xF2, 0x01, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0xFE,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x02,
  0x01, 0xDC, 0x20, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x38, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x06, 0x04, 0x00, 0x02, 0x08, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x1F, 0xC1, 0x20, 0x20, 0x41, 0x40,
  0x40, 0x81, 0x40, 0x80, 0x81, 0x41, 0x80, 0x81, 0x81, 0x00, 0x81, 0x81,
  0x01, 0x01, 0x82, 0x01, 0x03, 0x82, 0x01, 0x02, 0x82, 0x03, 0x02, 0x82,
  0x02, 0x04, 0x82, 0x06, 0x04, 0x82, 0x05, 0x08, 0x81, 0x19, 0x10, 0x80,
  0xE0, 0xE0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x09, 0x00, 0x04,
  0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x20, 0x10, 0x08, 0x02, 0x07,
  0xFF, 0x81, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x04,
  0x03, 0xFE, 0x00, 0x80, 0x60, 0x40, 0x0C, 0x10, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80,
  0x10, 0x20, 0x18, 0x1F, 0xF8, 0x04, 0x07, 0x01, 0x00, 0x20, 0x40, 0x0C,
  0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x0C, 0x0F, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x3C, 0xF0, 0x18, 0x04, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x20, 0x30, 0x04, 0x00, 0xC0,
  0x40, 0x04, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x01, 0x84, 0x00, 0x10, 0x40,
  0x02, 0x04, 0x00, 0x40, 0x40, 0x18, 0x04, 0x06, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x1F, 0xFC, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x01, 0x80, 0x30, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x48, 0x03, 0xF8, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x40, 0x01, 0x06, 0x00, 0x20, 0x30, 0x02, 0x00, 0xFF, 0xC0,
  0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x20, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00, 0x08, 0x1F, 0xFF, 0xE0,
  0x40, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80,
  0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x01, 0x01, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x00, 0x03, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x8C, 0x00, 0x80, 0x00, 0x02, 0x00, 0x30, 0x20,
  0x04, 0x04, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x40, 0x40, 0x04,
  0x08, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00,
  0x90, 0x00, 0x12, 0x80, 0x01, 0x48, 0x00, 0x18, 0xC0, 0x01, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x03, 0x00, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40, 0x0C, 0x04, 0x00,
  0x40, 0x80, 0x06, 0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x14, 0x00, 0x03, 0x02, 0x80, 0x00, 0xA0, 0x50,
  0x00, 0x34, 0x0A, 0x00, 0x05, 0x01, 0x40, 0x01, 0x20, 0x48, 0x00, 0x24,
  0x08, 0x80, 0x08, 0x81, 0x10, 0x01, 0x10, 0x22, 0x00, 0x44, 0x04, 0x40,
  0x08, 0x81, 0x08, 0x02, 0x10, 0x21, 0x00, 0xC2, 0x04, 0x20, 0x10, 0x40,
  0x84, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x21, 0x02, 0x02, 0x04, 0x20, 0x40, 0x80, 0x88, 0x08, 0x10,
  0x13, 0x01, 0x02, 0x01, 0x40, 0x20, 0x40, 0x30, 0x08, 0x08, 0x06, 0x01,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x02, 0x00, 0x04, 0x08, 0x00, 0x20, 0x50,
  0x00, 0x81, 0x40, 0x02, 0x05, 0x00, 0x08, 0x12, 0x00, 0x20, 0x48, 0x01,
  0x02, 0x30, 0x04, 0x08, 0x40, 0x10, 0x21, 0x00, 0x40, 0x86, 0x02, 0x02,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x10, 0x20, 0x18, 0x40, 0x80, 0x21, 0x02, 0x00, 0x84, 0x08, 0x01, 0x10,
  0x20, 0x04, 0x81, 0x00, 0x12, 0x04, 0x00, 0x28, 0x10, 0x00, 0xA0, 0x40,
  0x02, 0x81, 0x00, 0x04, 0x08, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x3C,
  0xE0, 0x0C, 0x06, 0x02, 0x00, 0x60, 0x80, 0x04, 0x20, 0x00, 0x4C, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03,
  0x20, 0x00, 0x44, 0x00, 0x18, 0x40, 0x06, 0x08, 0x01, 0x80, 0xC0, 0x60,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x80, 0xC0, 0x40, 0x18, 0x10, 0x02,
  0x04, 0x00, 0x81, 0x00, 0x30, 0x40, 0x0C, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x08, 0x20, 0x04, 0x10, 0x02, 0x04, 0x01, 0x01, 0xFF,
  0x80, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3C, 0xE0, 0x0C, 0x06, 0x02,
  0x00, 0x60, 0x80, 0x04, 0x20, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00,
  0x10, 0x40, 0x06, 0x08, 0x01, 0x80, 0xC0, 0x60, 0x0F, 0xF0, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x03, 0xFC, 0x00, 0x80, 0xC0, 0x40, 0x18, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x00, 0x30, 0x40, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x10, 0x20, 0x04, 0x10, 0x06, 0x04, 0x07, 0x01, 0xFE, 0x00, 0x40,
  0x80, 0x20, 0x20, 0x08, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x04, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x01, 0x08,
  0x00, 0x40, 0x00, 0x18, 0x00, 0xF7, 0xC0, 0xC0, 0x20, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x0C, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x08, 0x00, 0x11, 0x00,
  0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20,
  0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x44,
  0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x18,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x40, 0xC0, 0x08, 0x06, 0x03,
  0x00, 0x1F, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40,
  0x08, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x02, 0x00,
  0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x20, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x70, 0x01, 0x80, 0x0A, 0x00, 0x30, 0x01,
  0x40, 0x0A, 0x00, 0x48, 0x01, 0x40, 0x09, 0x00, 0x28, 0x02, 0x20, 0x09,
  0x00, 0x44, 0x01, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x08, 0x80, 0x42,
  0x02, 0x10, 0x10, 0x40, 0x42, 0x02, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x10, 0xC1, 0x04, 0x02, 0x10, 0x10, 0x80, 0x42, 0x02, 0x30, 0x08,
  0x80, 0x44, 0x01, 0x10, 0x08, 0x80, 0x24, 0x01, 0x20, 0x04, 0x80, 0x24,
  0x00, 0xA0, 0x05, 0x00, 0x14, 0x00, 0xA0, 0x03, 0x80, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x18, 0x08, 0x01, 0x80, 0x40, 0x08, 0x02, 0x00, 0x80, 0x08, 0x08, 0x00,
  0x40, 0x40, 0x02, 0x04, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20,
  0x00, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x02, 0x02, 0x00, 0x10, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x40,
  0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x08, 0x20, 0x10, 0x20, 0x10, 0x20,
  0x20, 0x20, 0x60, 0x10, 0x40, 0x10, 0x80, 0x11, 0x80, 0x11, 0x00, 0x0A,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x84, 0x21, 0x04,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x08, 0x21,
  0x08, 0x42, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFE, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x02, 0x80, 0x08, 0x80, 0x31, 0x00, 0x42, 0x01,
  0x02, 0x06, 0x04, 0x08, 0x08, 0x20, 0x08, 0x40, 0x11, 0x00, 0x24, 0x00,
  0x28, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8, 0x88, 0x44, 0x21, 0x03, 0xF2,
  0x18, 0x14, 0x60, 0x28, 0x80, 0x32, 0x00, 0x4C, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x03,
  0x20, 0x04, 0x40, 0x18, 0x80, 0x51, 0x00, 0xA1, 0x06, 0x41, 0xF9, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xFC, 0x0B, 0x02, 0x0E, 0x02,
  0x14, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x60, 0x08, 0xA0, 0x10, 0x90, 0x30, 0x8F, 0xC0, 0x03, 0xF8,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x10, 0x7F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0xFC, 0x40, 0xC0, 0x90, 0x60, 0x18, 0x10, 0x06,
  0x08, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0x40, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00,
  0x60, 0x80, 0x38, 0x20, 0x0C, 0x08, 0x05, 0x01, 0x06, 0x40, 0x3F, 0x10,
  0x00, 0x03, 0xF0, 0x60, 0x46, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00,
  0x68, 0x06, 0x80, 0xC7, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x08, 0x3F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x40, 0xC0, 0x90, 0x60, 0x18,
  0x10, 0x06, 0x08, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0x40, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01,
  0x82, 0x00, 0x60, 0x80, 0x38, 0x20, 0x0C, 0x08, 0x05, 0x01, 0x06, 0x40,
  0x3F, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x03, 0x01, 0x00, 0x3F, 0x80, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x11, 0xF8, 0x2C, 0x08, 0x70, 0x11, 0x40, 0x23,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x12,
  0x00, 0x24, 0x00, 0x48, 0x01, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x06, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x0C,
  0x20, 0x30, 0x40, 0xC1, 0x03, 0x02, 0x04, 0x04, 0x10, 0x08, 0x40, 0x21,
  0x00, 0x44, 0x00, 0x9C, 0x01, 0x48, 0x03, 0x10, 0x0C, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x80, 0x82, 0x01, 0x84, 0x01, 0x08, 0x02, 0x00,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x00, 0x09, 0xF8, 0x3F, 0x05, 0x02, 0x60, 0x85, 0x01, 0x60, 0x22,
  0x80, 0xA0, 0x11, 0x80, 0x60, 0x08, 0x80, 0x30, 0x04, 0x40, 0x10, 0x02,
  0x60, 0x08, 0x02, 0x20, 0x04, 0x01, 0x10, 0x02, 0x00, 0x88, 0x02, 0x00,
  0x44, 0x01, 0x00, 0x24, 0x00, 0x80, 0x22, 0x00, 0x40, 0x11, 0x00, 0x60,
  0x08, 0x80, 0x20, 0x04, 0x40, 0x10, 0x02, 0x40, 0x08, 0x02, 0x20, 0x04,
  0x01, 0x10, 0x04, 0x00, 0x80, 0x08, 0xFC, 0x16, 0x04, 0x58, 0x08, 0xA0,
  0x11, 0x80, 0x22, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40,
  0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x80, 0x03, 0xF0, 0x18, 0x10, 0x60,
  0x10, 0x80, 0x22, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40,
  0x04, 0x80, 0x11, 0x80, 0x41, 0x81, 0x01, 0xFC, 0x00, 0x02, 0x3F, 0x00,
  0xB0, 0x20, 0x38, 0x08, 0x14, 0x01, 0x06, 0x00, 0x41, 0x80, 0x10, 0x40,
  0x04, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02,
  0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x18, 0x02, 0x0A,
  0x01, 0x02, 0x40, 0xC0, 0x8F, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xF1, 0x0C, 0x09, 0x18, 0x06, 0x10, 0x06, 0x20,
  0x06, 0x60, 0x06, 0x40, 0x06, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x38, 0x80,
  0x30, 0x80, 0x50, 0x40, 0x90, 0x3F, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x08, 0xF0, 0xB0, 0x16, 0x01, 0x40, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xF8, 0x20, 0x11, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x88, 0x04, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x1F, 0xF0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x01, 0x00,
  0x7C, 0x00, 0x10, 0x02, 0x20, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00,
  0x48, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x51, 0x00, 0xA3,
  0x06, 0x83, 0xF1, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80,
  0x21, 0x01, 0x84, 0x04, 0x10, 0x30, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10,
  0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x14, 0x05, 0x00,
  0xA0, 0x28, 0x09, 0x02, 0x40, 0x48, 0x12, 0x04, 0x40, 0x90, 0x22, 0x08,
  0x82, 0x10, 0x44, 0x10, 0x84, 0x11, 0x04, 0x20, 0x88, 0x22, 0x04, 0x81,
  0x10, 0x24, 0x09, 0x01, 0x60, 0x48, 0x0A, 0x02, 0x40, 0x50, 0x14, 0x03,
  0x00, 0xA0, 0x18, 0x02, 0x00, 0x80, 0x10, 0x00, 0x08, 0x01, 0x82, 0x01,
  0x01, 0x00, 0x80, 0xC0, 0x80, 0x20, 0x80, 0x10, 0x80, 0x04, 0xC0, 0x02,
  0x40, 0x01, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x48, 0x00, 0x64, 0x00,
  0x22, 0x00, 0x20, 0x80, 0x20, 0x40, 0x30, 0x20, 0x10, 0x08, 0x10, 0x04,
  0x10, 0x01, 0x00, 0x02, 0x00, 0x30, 0x20, 0x02, 0x01, 0x00, 0x60, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01,
  0x02, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00,
  0x08, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0xA0, 0x00, 0x0A, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0xE0, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x38, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x00, 0xE0, 0x00, 0x3E,
  0x01, 0xC1, 0x81, 0x80, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 8, 10, 11, 4, -27 },
  { 35, 19, 27, 20, 1, -27 },
  { 100, 16, 31, 18, 1, -29 },
  { 162, 21, 28, 26, 3, -28 },
  { 236, 19, 28, 21, 1, -28 },
  { 303, 3, 10, 6, 4, -27 },
  { 307, 11, 33, 9, 1, -27 },
  { 353, 10, 33, 9, -2, -27 },
  { 395, 13, 14, 17, 5, -29 },
  { 418, 16, 17, 19, 2, -22 },
  { 452, 5, 9, 7, -2, -4 },
  { 458, 9, 1, 11, 1, -11 },
  { 460, 2, 2, 7, 1, -2 },
  { 461, 16, 27, 11, -2, -27 },
  { 515, 15, 28, 18, 2, -28 },
  { 568, 8, 27, 18, 6, -27 },
  { 595, 17, 28, 18, 0, -28 },
  { 655, 17, 28, 18, 0, -28 },
  { 715, 17, 27, 18, 0, -27 },
  { 773, 17, 27, 18, 1, -27 },
  { 831, 16, 28, 18, 2, -28 },
  { 887, 16, 27, 18, 3, -27 },
  { 941, 17, 28, 18, 1, -28 },
  { 1001, 16, 28, 18, 1, -28 },
  { 1057, 6, 20, 7, 1, -20 },
  { 1072, 9, 25, 7, -2, -20 },
  { 1101, 16, 17, 19, 2, -22 },
  { 1135, 16, 9, 19, 2, -18 },
  { 1153, 16, 17, 19, 2, -22 },
  { 1187, 12, 28, 13, 2, -28 },
  { 1229, 24, 30, 27, 2, -27 },
  { 1319, 18, 27, 18, -2, -27 },
  { 1380, 18, 27, 20, 1, -27 },
  { 1441, 18, 28, 19, 3, -28 },
  { 1504, 20, 27, 22, 1, -27 },
  { 1572, 18, 27, 18, 1, -27 },
  { 1633, 18, 27, 16, 1, -27 },
  { 1694, 20, 28, 23, 3, -28 },
  { 1764, 22, 27, 23, 1, -27 },
  { 1839, 12, 27, 9, -1, -27 },
  { 1880, 14, 34, 8, -6, -27 },
  { 1940, 20, 27, 18, 1, -27 },
  { 2008, 12, 27, 16, 1, -27 },
  { 2049, 27, 27, 28, 1, -27 },
  { 2141, 22, 27, 23, 1, -27 },
  { 2216, 19, 28, 23, 3, -28 },
  { 2283, 18, 27, 18, 1, -27 },
  { 2344, 19, 34, 23, 3, -28 },
  { 2425, 18, 27, 19, 1, -27 },
  { 2486, 17, 28, 17, 0, -28 },
  { 2546, 16, 27, 16, 3, -27 },
  { 2600, 20, 27, 23, 3, -27 },
  { 2668, 17, 27, 18, 4, -27 },
  { 2726, 27, 27, 28, 4, -27 },
  { 2818, 21, 27, 16, -2, -27 },
  { 2889, 16, 27, 16, 3, -27 },
  { 2943, 20, 27, 17, -1, -27 },
  { 3011, 14, 33, 11, 0, -27 },
  { 3069, 5, 27, 12, 4, -27 },
  { 3086, 14, 33, 11, -3, -27 },
  { 3144, 15, 15, 19, 2, -27 },
  { 3173, 13, 1, 13, -3, 4 },
  { 3175, 4, 6, 8, 6, -29 },
  { 3178, 15, 20, 18, 2, -20 },
  { 3216, 16, 29, 19, 1, -29 },
  { 3274, 13, 20, 15, 2, -20 },
  { 3307, 18, 29, 19, 2, -29 },
  { 3373, 13, 20, 16, 2, -20 },
  { 3406, 19, 38, 9, -5, -29 },
  { 3497, 18, 29, 19, 0, -20 },
  { 3563, 15, 29, 18, 1, -29 },
  { 3618, 7, 27, 7, 1, -27 },
  { 3642, 13, 36, 7, -5, -27 },
  { 3701, 15, 29, 15, 1, -29 },
  { 3756, 7, 29, 7, 1, -29 },
  { 3782, 25, 20, 28, 1, -20 },
  { 3845, 15, 20, 18, 1, -20 },
  { 3883, 15, 20, 19, 2, -20 },
  { 3921, 18, 29, 19, -1, -20 },
  { 3987, 16, 29, 19, 2, -20 },
  { 4045, 12, 20, 12, 1, -20 },
  { 4075, 14, 20, 14, 0, -20 },
  { 4110, 10, 25, 10, 1, -25 },
  { 4142, 15, 20, 18, 2, -20 },
  { 4180, 14, 20, 14, 2, -20 },
  { 4215, 21, 20, 22, 2, -20 },
  { 4268, 17, 20, 15, -1, -20 },
  { 4311, 20, 29, 14, -4, -20 },
  { 4384, 15, 20, 14, -1, -20 },
  { 4422, 13, 33, 12, 1, -27 },
  { 4476, 1, 38, 18, 9, -29 },
  { 4481, 13, 33, 12, -2, -27 },
  { 4535, 16, 3, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC38PT7B_H_
