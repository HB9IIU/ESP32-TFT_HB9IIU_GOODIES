#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x22, 0x85, 0x0A, 0x14, 0x50, 0xA1, 0x42, 0x89, 0x10, 0x00, 0x40, 0x80,
  0x10, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x10, 0x3F, 0xFF, 0xC0, 0x81, 0x00, 0x20, 0x40, 0x08, 0x20,
  0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08, 0x10, 0x3F,
  0xFF, 0xC0, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x02, 0x04,
  0x00, 0x81, 0x00, 0x20, 0x80, 0x18, 0x20, 0x00, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x1F, 0xF0, 0x62, 0x21, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10,
  0x40, 0x20, 0x80, 0x62, 0x00, 0x44, 0x00, 0x68, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80,
  0x41, 0x00, 0x84, 0x41, 0x10, 0xFF, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x0F, 0x00, 0x42, 0x20, 0x08, 0x82, 0x02, 0x20, 0x40,
  0x84, 0x08, 0x10, 0x81, 0x04, 0x20, 0x21, 0x04, 0x04, 0x20, 0x81, 0x08,
  0x10, 0x22, 0x02, 0x04, 0x46, 0x41, 0x91, 0x38, 0x26, 0x43, 0x0C, 0x90,
  0x61, 0x22, 0x0B, 0xC4, 0x81, 0x01, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40,
  0x82, 0x10, 0x10, 0x82, 0x02, 0x10, 0x40, 0x84, 0x08, 0x11, 0x01, 0x04,
  0x20, 0x10, 0x88, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x43, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04,
  0x08, 0x00, 0x84, 0x00, 0x26, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x20,
  0x01, 0x88, 0x04, 0x81, 0x02, 0x40, 0x20, 0x90, 0x08, 0x48, 0x01, 0x12,
  0x00, 0x48, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0xD0, 0x40,
  0x62, 0x0F, 0xE0, 0xC0, 0x29, 0x25, 0x24, 0x90, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x00, 0x01, 0x00, 0x08, 0x00, 0x41, 0x82, 0x03, 0x20,
  0x07, 0x1C, 0x0F, 0x00, 0xC0, 0x09, 0x01, 0x88, 0x18, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x08, 0x44,
  0x22, 0x11, 0x08, 0x80, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x04, 0x10, 0x10, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x88, 0x00, 0x90,
  0x01, 0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x04, 0x20, 0x18, 0x60, 0x20, 0x40, 0x80, 0x7E, 0x00, 0x01,
  0x07, 0x09, 0x32, 0x62, 0x82, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x00, 0xFC, 0x03, 0x06, 0x04, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x80, 0x30, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x12, 0x00, 0x22, 0x00, 0x42, 0x00, 0x84, 0x01, 0x84, 0x01, 0x04, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20, 0x08, 0x40,
  0x08, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x80, 0x20, 0x3F, 0xE0,
  0x00, 0x00, 0x7E, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x0E, 0x02, 0x61, 0x85,
  0x01, 0x14, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x60, 0xC0,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x01, 0xF8, 0x02, 0x04, 0x04, 0x02, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08, 0x02, 0x04, 0x04, 0x06,
  0x18, 0x03, 0x20, 0x01, 0xC0, 0x06, 0x40, 0x18, 0x30, 0x20, 0x10, 0x40,
  0x08, 0xC0, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x40, 0x10, 0x60, 0x20, 0x1F, 0xC0, 0x01, 0xF0, 0x04, 0x18, 0x10,
  0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x62, 0x01, 0x46, 0x0D, 0x03,
  0xE2, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x01, 0xFC, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x20, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x1F, 0x84, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xF1, 0xC0, 0x06, 0x00, 0x40, 0x10, 0x00,
  0x40, 0x40, 0x00, 0x41, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x20, 0x3F, 0x82, 0x40, 0xC1, 0x05, 0x02, 0x04, 0x0A, 0x0C, 0x08, 0x18,
  0x10, 0x10, 0x30, 0x40, 0x20, 0x60, 0x80, 0x81, 0x41, 0x01, 0x02, 0x82,
  0x02, 0x05, 0x04, 0x0C, 0x12, 0x08, 0x10, 0x24, 0x10, 0x50, 0x88, 0x21,
  0x22, 0x10, 0x3C, 0x38, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20,
  0x80, 0x20, 0x40, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x0F, 0xFE, 0x04,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x04, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x03, 0xF8, 0x02,
  0x03, 0x81, 0x00, 0x40, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x84, 0x00, 0x82, 0x01, 0x81, 0xFF,
  0x00, 0x80, 0xC0, 0x40, 0x10, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10,
  0x80, 0x30, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x10, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x81, 0xC0, 0x10, 0x04, 0x02,
  0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x82, 0x00, 0x10, 0x40, 0x01, 0x08,
  0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80,
  0x06, 0x10, 0x00, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x03, 0x02, 0x00,
  0xC0, 0x80, 0x60, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x18, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xA0, 0x08, 0x24, 0x00, 0x04,
  0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x02, 0x18, 0x00, 0x41, 0x00, 0x10, 0x18, 0x02, 0x01, 0xFF, 0x80,
  0x02, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x1F, 0xFF, 0xC1, 0x00, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82,
  0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x03, 0xE0, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x3F,
  0x00, 0x02, 0x00, 0x60, 0x80, 0x18, 0x10, 0x06, 0x02, 0x01, 0x80, 0x40,
  0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x01, 0x18,
  0x00, 0x46, 0x00, 0x09, 0x80, 0x01, 0x70, 0x00, 0x39, 0x00, 0x06, 0x20,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x80, 0x80, 0x10, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x40, 0x80, 0x08,
  0x10, 0x01, 0x80, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x1F, 0xFC, 0x02, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x50, 0x50, 0x00, 0x50, 0x48, 0x00, 0x28, 0x24, 0x00,
  0x24, 0x12, 0x00, 0x12, 0x09, 0x00, 0x12, 0x04, 0x80, 0x09, 0x04, 0x40,
  0x08, 0x82, 0x10, 0x0C, 0x41, 0x08, 0x04, 0x20, 0x84, 0x04, 0x20, 0x42,
  0x02, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x02, 0x08,
  0x20, 0x82, 0x04, 0x08, 0x81, 0x04, 0x04, 0xC0, 0x82, 0x02, 0x40, 0x41,
  0x01, 0x40, 0x20, 0x80, 0xA0, 0x20, 0x80, 0x60, 0x10, 0x40, 0x30, 0x08,
  0x00, 0x02, 0x00, 0x08, 0x30, 0x00, 0x81, 0x80, 0x04, 0x0A, 0x00, 0x20,
  0x50, 0x01, 0x04, 0x80, 0x10, 0x22, 0x00, 0x81, 0x10, 0x04, 0x08, 0x80,
  0x20, 0x42, 0x01, 0x04, 0x10, 0x10, 0x20, 0x80, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x02, 0x10, 0x20, 0x10, 0x81, 0x00, 0x84,
  0x08, 0x02, 0x20, 0x40, 0x12, 0x04, 0x00, 0x90, 0x20, 0x02, 0x81, 0x00,
  0x14, 0x08, 0x00, 0xA0, 0x80, 0x02, 0x04, 0x00, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x30, 0x20, 0x08, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00,
  0x44, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x10,
  0x80, 0x06, 0x10, 0x00, 0x81, 0x00, 0x20, 0x10, 0x18, 0x01, 0xFE, 0x00,
  0x03, 0xF0, 0x02, 0x07, 0x01, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x41, 0x00, 0x40, 0x80, 0xC0, 0x7F, 0x80, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30,
  0x20, 0x08, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x44, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06,
  0x10, 0x00, 0x81, 0x00, 0x20, 0x10, 0x18, 0x01, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x03, 0xF0, 0x02, 0x07, 0x01, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x04, 0x20, 0x02, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x82,
  0x00, 0x41, 0x00, 0xC0, 0x83, 0x80, 0x7F, 0x00, 0x40, 0x80, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x00, 0x00, 0xFE, 0x03, 0x01,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x80, 0x20, 0x7F, 0xC0,
  0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x42,
  0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08,
  0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x0C, 0x00, 0x20, 0x40, 0x04, 0x04, 0x00,
  0x80, 0x20, 0x10, 0x01, 0xFE, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00,
  0x42, 0x01, 0x04, 0x02, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x20, 0x80,
  0x42, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80, 0x09, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x50, 0x03, 0x00, 0x28, 0x02, 0x80, 0x24, 0x01,
  0x40, 0x12, 0x01, 0x20, 0x11, 0x00, 0x90, 0x08, 0x80, 0x88, 0x04, 0x40,
  0x44, 0x04, 0x20, 0x22, 0x02, 0x10, 0x21, 0x02, 0x08, 0x10, 0x81, 0x04,
  0x10, 0x21, 0x02, 0x08, 0x10, 0x81, 0x08, 0x08, 0x40, 0x84, 0x04, 0x40,
  0x44, 0x02, 0x20, 0x22, 0x01, 0x20, 0x11, 0x00, 0x90, 0x09, 0x00, 0x50,
  0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x40, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x02, 0x00, 0x10, 0x10, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x01, 0x00, 0x80, 0x08, 0x10, 0x00, 0x82, 0x00, 0x08,
  0x20, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x05, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x01, 0x10, 0x00,
  0x21, 0x00, 0x04, 0x08, 0x00, 0x40, 0x80, 0x08, 0x08, 0x01, 0x00, 0x80,
  0x30, 0x04, 0x02, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x02, 0x08, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x41, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0xC0,
  0x05, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x1F, 0x80, 0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x82, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x42, 0x08, 0x40, 0x03, 0xF8,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0x20, 0x00, 0x60, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10,
  0x03, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x04, 0x08, 0x04, 0x10, 0x04,
  0x10, 0x02, 0x20, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xFF, 0xF0, 0x84, 0x42,
  0x21, 0x07, 0xE2, 0x10, 0x28, 0x40, 0x51, 0x00, 0x62, 0x00, 0xC8, 0x01,
  0x10, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x06, 0x20, 0x08, 0x40, 0x30, 0x80, 0xA0, 0x82, 0x41, 0xF8,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x09, 0xF8, 0x24, 0x08, 0x50, 0x08, 0xC0, 0x11,
  0x80, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x50, 0x0C, 0xA0, 0x11,
  0x60, 0xC2, 0x7F, 0x00, 0x07, 0xF0, 0xC0, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x07, 0xE2, 0x04, 0x09, 0x04, 0x03, 0x04, 0x01, 0x82, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x03, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0xC1, 0x00, 0xA0,
  0x80, 0xD0, 0x20, 0xD0, 0x0F, 0x88, 0x00, 0x07, 0xE0, 0x60, 0x84, 0x04,
  0x40, 0x12, 0x01, 0x20, 0x09, 0x00, 0xD0, 0x0C, 0x83, 0x87, 0xE0, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x02,
  0x0F, 0xF0, 0x00, 0x00, 0x80, 0x01, 0x90, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x7F,
  0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x02, 0x60, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xF8, 0x81, 0x02, 0x41, 0x00, 0xA1, 0x00, 0x60, 0x80,
  0x10, 0x80, 0x08, 0x40, 0x04, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x60, 0x80, 0x30, 0x40, 0x28,
  0x20, 0x34, 0x08, 0x34, 0x07, 0xE2, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x38, 0xE0, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x09, 0xF8, 0x24, 0x08, 0x50, 0x10, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x40, 0x04, 0x10, 0x00, 0x00, 0x00, 0x02, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x04, 0x80, 0x38, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x04, 0x40, 0x21, 0x01, 0x04, 0x08, 0x10, 0x40, 0x42, 0x02, 0x10,
  0x08, 0x80, 0x26, 0x00, 0xA8, 0x03, 0x10, 0x18, 0x40, 0x41, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x80, 0x42, 0x01, 0x08, 0x02, 0x00, 0x06, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x00, 0x09, 0xF0,
  0x7C, 0x12, 0x09, 0x82, 0x14, 0x05, 0x02, 0x18, 0x06, 0x01, 0x10, 0x04,
  0x01, 0x10, 0x04, 0x02, 0x30, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08,
  0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10,
  0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x20, 0x08, 0x80, 0x20,
  0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x09, 0xF8, 0x24, 0x08, 0x50,
  0x10, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x40, 0x07, 0xF0, 0x20, 0x61, 0x00,
  0x88, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x08, 0x80,
  0x61, 0x03, 0x03, 0xF0, 0x00, 0x02, 0x7E, 0x02, 0x40, 0x81, 0x40, 0x20,
  0xE0, 0x10, 0x60, 0x08, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x08, 0x50, 0x0C, 0x28, 0x04, 0x16, 0x0C, 0x09, 0xFC, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xE2, 0x10, 0x24, 0x40, 0x29, 0x00, 0x62, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24,
  0x00, 0xC8, 0x01, 0x10, 0x06, 0x20, 0x0C, 0x40, 0x28, 0x80, 0xD0, 0x83,
  0x41, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x09, 0xF1, 0x20, 0x14, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07,
  0xF0, 0x40, 0x44, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x44, 0x06, 0x1F, 0xC0, 0x04, 0x04, 0x02, 0x01, 0x00, 0x83,
  0xFC, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x03, 0x00, 0xF8, 0x30, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x20,
  0x18, 0x80, 0xA2, 0x04, 0x87, 0xE2, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x09,
  0x00, 0x48, 0x04, 0x40, 0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10,
  0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02,
  0x80, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x08, 0x82, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x82, 0x20, 0x88, 0x22, 0x09, 0x02,
  0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x00, 0x08, 0x03, 0x04, 0x02, 0x04, 0x04, 0x04, 0x08, 0x02, 0x10,
  0x02, 0x30, 0x02, 0x20, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x30, 0x20, 0x20, 0x20,
  0x40, 0x10, 0x80, 0x10, 0x02, 0x00, 0x20, 0x40, 0x08, 0x08, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x08, 0x80, 0x01,
  0x20, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x02, 0x60, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0E, 0x00, 0xE0,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0F, 0x00, 0x70, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x18, 0x00, 0x7E, 0x03,
  0x03, 0x0E, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 26, 7, 1, -26 },
  { 24, 7, 10, 10, 4, -26 },
  { 33, 18, 26, 19, 1, -26 },
  { 92, 15, 29, 17, 1, -27 },
  { 147, 19, 26, 24, 3, -26 },
  { 209, 18, 26, 20, 1, -26 },
  { 268, 3, 10, 6, 4, -26 },
  { 272, 10, 32, 9, 1, -26 },
  { 312, 10, 32, 9, -2, -26 },
  { 352, 13, 13, 16, 4, -27 },
  { 374, 15, 17, 18, 2, -21 },
  { 406, 5, 9, 6, -2, -4 },
  { 412, 8, 1, 11, 1, -10 },
  { 413, 2, 2, 7, 1, -2 },
  { 414, 16, 26, 11, -2, -26 },
  { 466, 15, 26, 17, 2, -26 },
  { 515, 8, 26, 17, 5, -26 },
  { 541, 16, 26, 17, 0, -26 },
  { 593, 17, 26, 17, 0, -26 },
  { 649, 16, 26, 17, 0, -26 },
  { 701, 17, 26, 17, 0, -26 },
  { 757, 15, 26, 17, 2, -26 },
  { 806, 15, 26, 17, 3, -26 },
  { 855, 16, 26, 17, 1, -26 },
  { 907, 15, 26, 17, 1, -26 },
  { 956, 5, 19, 7, 1, -19 },
  { 968, 8, 24, 7, -2, -19 },
  { 992, 15, 16, 18, 2, -21 },
  { 1022, 15, 9, 18, 2, -17 },
  { 1039, 15, 16, 18, 2, -21 },
  { 1069, 11, 26, 12, 2, -26 },
  { 1105, 23, 29, 26, 2, -26 },
  { 1189, 17, 26, 17, -2, -26 },
  { 1245, 17, 26, 19, 1, -26 },
  { 1301, 18, 26, 18, 2, -26 },
  { 1360, 19, 26, 21, 1, -26 },
  { 1422, 17, 26, 17, 1, -26 },
  { 1478, 17, 26, 15, 1, -26 },
  { 1534, 19, 26, 22, 2, -26 },
  { 1596, 20, 26, 21, 1, -26 },
  { 1661, 11, 26, 9, -1, -26 },
  { 1697, 14, 32, 7, -6, -26 },
  { 1753, 19, 26, 17, 1, -26 },
  { 1815, 11, 26, 15, 1, -26 },
  { 1851, 25, 26, 26, 1, -26 },
  { 1933, 21, 26, 21, 1, -26 },
  { 2002, 19, 26, 22, 2, -26 },
  { 2064, 17, 26, 17, 1, -26 },
  { 2120, 19, 32, 22, 2, -26 },
  { 2196, 17, 26, 18, 1, -26 },
  { 2252, 16, 26, 16, 0, -26 },
  { 2304, 15, 26, 15, 3, -26 },
  { 2353, 20, 26, 21, 2, -26 },
  { 2418, 15, 26, 17, 4, -26 },
  { 2467, 25, 26, 27, 4, -26 },
  { 2549, 20, 26, 15, -2, -26 },
  { 2614, 15, 26, 15, 3, -26 },
  { 2663, 19, 26, 16, -1, -26 },
  { 2725, 13, 32, 11, 0, -26 },
  { 2777, 5, 26, 11, 4, -26 },
  { 2794, 13, 32, 11, -2, -26 },
  { 2846, 16, 15, 18, 1, -26 },
  { 2876, 12, 1, 12, -3, 4 },
  { 2878, 4, 6, 8, 5, -28 },
  { 2881, 15, 19, 17, 2, -19 },
  { 2917, 15, 27, 18, 1, -27 },
  { 2968, 12, 19, 14, 2, -19 },
  { 2997, 17, 27, 18, 2, -27 },
  { 3055, 13, 19, 16, 2, -19 },
  { 3086, 18, 37, 8, -5, -28 },
  { 3170, 17, 28, 18, 0, -19 },
  { 3230, 15, 27, 17, 1, -27 },
  { 3281, 6, 26, 7, 1, -26 },
  { 3301, 13, 35, 7, -5, -26 },
  { 3358, 14, 27, 14, 1, -27 },
  { 3406, 7, 27, 7, 1, -27 },
  { 3430, 24, 19, 26, 1, -19 },
  { 3487, 15, 19, 17, 1, -19 },
  { 3523, 14, 19, 18, 2, -19 },
  { 3557, 17, 27, 18, -1, -19 },
  { 3615, 15, 27, 18, 2, -19 },
  { 3666, 12, 19, 12, 1, -19 },
  { 3695, 13, 19, 13, 0, -19 },
  { 3726, 9, 24, 9, 1, -24 },
  { 3753, 14, 19, 17, 2, -19 },
  { 3787, 13, 19, 13, 2, -19 },
  { 3818, 20, 19, 21, 2, -19 },
  { 3866, 16, 19, 14, -1, -19 },
  { 3904, 19, 28, 13, -4, -19 },
  { 3971, 14, 19, 13, -1, -19 },
  { 4005, 13, 32, 12, 1, -26 },
  { 4057, 1, 36, 17, 8, -27 },
  { 4062, 13, 32, 12, -2, -26 },
  { 4114, 15, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC36PT7B_H_
