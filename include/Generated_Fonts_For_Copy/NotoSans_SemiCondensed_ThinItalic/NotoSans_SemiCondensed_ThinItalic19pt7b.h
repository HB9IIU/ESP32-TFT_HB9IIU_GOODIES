#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x40, 0x08, 0x59, 0x99, 0xA0, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x3F, 0xC2, 0x41, 0x10, 0x48, 0x12, 0x3F, 0xE2,
  0x20, 0x90, 0x44, 0x11, 0x00, 0x04, 0x1F, 0x28, 0x48, 0x48, 0x48, 0x30,
  0x08, 0x14, 0x12, 0x12, 0x24, 0xF8, 0x20, 0x20, 0x38, 0x49, 0x09, 0x22,
  0x24, 0x48, 0x91, 0x14, 0xA2, 0xEC, 0xA9, 0x6A, 0x21, 0x44, 0x48, 0x91,
  0x22, 0x24, 0x87, 0x00, 0x06, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x80,
  0xC0, 0xD0, 0x44, 0x50, 0xA8, 0x2A, 0x04, 0x83, 0x1F, 0x20, 0x6A, 0x80,
  0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x80, 0x10,
  0x82, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x09, 0x21,
  0xD8, 0xC6, 0x91, 0x02, 0x00, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08,
  0x08, 0x08, 0x29, 0x40, 0xF0, 0x80, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x22, 0x21, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x13, 0xD2,
  0x22, 0x22, 0x44, 0x44, 0x48, 0x0E, 0x08, 0x80, 0x20, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07, 0xF0, 0x0F, 0x18, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x68, 0x0C, 0x01, 0x00, 0x80, 0x40, 0x20, 0x27,
  0xE0, 0x00, 0x80, 0x80, 0xC0, 0xA0, 0x90, 0x48, 0x48, 0x44, 0x42, 0x41,
  0x3F, 0xE0, 0x80, 0x40, 0x20, 0x0F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00,
  0xF8, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x27, 0xE0, 0x0F, 0x10, 0x20,
  0x20, 0x40, 0x58, 0xA4, 0xC2, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0xFE,
  0x04, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x00,
  0x0F, 0x08, 0x48, 0x24, 0x12, 0x08, 0x88, 0x38, 0x28, 0x62, 0x20, 0xA0,
  0x50, 0x24, 0x21, 0xE0, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81, 0x82, 0x46,
  0x3A, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x00, 0x24, 0x48, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x02, 0x03, 0x0C, 0x30,
  0xC0, 0x78, 0x10, 0x41, 0x04, 0x21, 0x08, 0x41, 0x04, 0x00, 0x02, 0x00,
  0x0F, 0xE1, 0x01, 0x20, 0x14, 0x31, 0x4C, 0x98, 0x89, 0x91, 0x19, 0x11,
  0x91, 0x19, 0x32, 0x8C, 0xC8, 0x00, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x01,
  0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x1F, 0x10, 0x48, 0x28,
  0x18, 0x0C, 0x04, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x09, 0xF8, 0x84,
  0x41, 0x40, 0xA0, 0x50, 0x48, 0x27, 0xE0, 0x07, 0xC6, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x0F,
  0x80, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xC0,
  0x60, 0x50, 0x28, 0x67, 0xC0, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x40, 0x7E,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0xC6, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x0E, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x41, 0x0F, 0xC0, 0x20, 0x48, 0x12, 0x04, 0x81, 0x40, 0x50, 0x27, 0xF9,
  0x02, 0x40, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x38, 0x84, 0x21,
  0x10, 0x84, 0x21, 0x10, 0x84, 0x70, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0xE0, 0x20, 0x90, 0x48,
  0x44, 0x44, 0x42, 0x41, 0x40, 0xE0, 0x48, 0x44, 0x21, 0x10, 0x88, 0x44,
  0x10, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x7C, 0x20, 0x09,
  0x00, 0xC8, 0x04, 0x60, 0x65, 0x03, 0x28, 0x29, 0x42, 0x4A, 0x12, 0x49,
  0x24, 0x49, 0x22, 0x89, 0x14, 0x48, 0xC2, 0x44, 0x20, 0x20, 0x48, 0x13,
  0x04, 0xC1, 0x48, 0x52, 0x14, 0x89, 0x12, 0x44, 0xA1, 0x28, 0x32, 0x0C,
  0x81, 0x20, 0x40, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0x3E, 0x21, 0x21,
  0x21, 0x41, 0x41, 0x41, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x41, 0x0D, 0x80, 0x80, 0x10, 0x06, 0x00, 0x3E, 0x21, 0x21,
  0x21, 0x41, 0x41, 0x42, 0x7C, 0x48, 0x88, 0x84, 0x84, 0x84, 0x82, 0x0F,
  0x08, 0x48, 0x04, 0x02, 0x01, 0x00, 0x40, 0x18, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x27, 0xE0, 0xFF, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50,
  0x14, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x82, 0x1F, 0x00, 0x81,
  0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0x40,
  0x40, 0x82, 0x0C, 0x10, 0x61, 0x83, 0x0C, 0x28, 0xA1, 0x45, 0x12, 0x28,
  0x92, 0x44, 0x91, 0x45, 0x0A, 0x28, 0x61, 0x83, 0x0C, 0x10, 0x40, 0x80,
  0x10, 0x44, 0x10, 0x88, 0x24, 0x09, 0x02, 0x80, 0x40, 0x10, 0x0C, 0x04,
  0x82, 0x21, 0x08, 0x41, 0x20, 0x40, 0x81, 0x82, 0x84, 0x84, 0x88, 0x50,
  0x50, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1F, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x07, 0xF0,
  0x1E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0xE0, 0x92, 0x49, 0x12, 0x49, 0x22, 0x40, 0x1E, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0xF0,
  0x08, 0x0C, 0x14, 0x14, 0x22, 0x42, 0x42, 0x81, 0xFE, 0xA4, 0x3D, 0x42,
  0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0xF4, 0x10, 0x08, 0x04, 0x04,
  0x02, 0xF1, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x25, 0xE0,
  0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xF0, 0x00, 0x80, 0x40,
  0x20, 0x23, 0xD2, 0x19, 0x05, 0x04, 0x82, 0x41, 0x20, 0x90, 0x88, 0xC7,
  0xA0, 0x3C, 0x85, 0x0C, 0x2F, 0x90, 0x20, 0x40, 0x80, 0xF0, 0x00, 0xC0,
  0x40, 0x20, 0x08, 0x02, 0x03, 0x40, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x03, 0x00, 0x1E,
  0x90, 0xC8, 0x28, 0x24, 0x12, 0x09, 0x04, 0x84, 0x46, 0x3D, 0x00, 0x80,
  0x40, 0x44, 0x61, 0xC0, 0x10, 0x10, 0x10, 0x20, 0x2F, 0x31, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x11, 0x00, 0x22, 0x22, 0x44, 0x44,
  0x88, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x10, 0x10, 0x20, 0x21, 0x22,
  0x24, 0x28, 0x50, 0x68, 0x48, 0x44, 0x84, 0x84, 0x11, 0x12, 0x22, 0x22,
  0x44, 0x44, 0x88, 0x2E, 0x79, 0x8C, 0x48, 0x42, 0x42, 0x14, 0x10, 0xA1,
  0x05, 0x08, 0x48, 0x42, 0x82, 0x14, 0x10, 0x80, 0x2F, 0x31, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x3E, 0x85, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x84, 0xF0, 0x17, 0x86, 0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x08,
  0x82, 0x21, 0x17, 0x84, 0x01, 0x00, 0x40, 0x20, 0x00, 0x3D, 0x43, 0x41,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0xF4, 0x04, 0x04, 0x04, 0x08, 0x2E,
  0x60, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x00, 0x3E, 0x81, 0x02, 0x03,
  0x01, 0x01, 0x02, 0x05, 0xF0, 0x22, 0x4F, 0x44, 0x88, 0x88, 0x88, 0xC0,
  0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x83, 0x0A,
  0x14, 0x48, 0x92, 0x24, 0x50, 0x40, 0x80, 0x84, 0x30, 0x8A, 0x31, 0x4A,
  0x49, 0x49, 0x49, 0x29, 0x46, 0x28, 0xC2, 0x10, 0x40, 0x10, 0x88, 0x84,
  0x81, 0x80, 0x80, 0x40, 0x50, 0x48, 0x42, 0x41, 0x00, 0x10, 0x44, 0x21,
  0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x0C, 0x00, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81,
  0xF0, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x10, 0x81, 0x04, 0x10, 0x42, 0x08,
  0x20, 0x60, 0xFF, 0xFF, 0xE0, 0x18, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0xC0, 0x70, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 6, 2, -14 },
  { 11, 10, 14, 10, 0, -14 },
  { 29, 8, 15, 9, 1, -14 },
  { 44, 11, 14, 13, 1, -14 },
  { 64, 10, 14, 10, 0, -14 },
  { 82, 2, 5, 3, 2, -14 },
  { 84, 5, 17, 5, 1, -14 },
  { 95, 5, 17, 5, -1, -14 },
  { 106, 7, 7, 9, 2, -14 },
  { 113, 8, 9, 10, 1, -11 },
  { 122, 3, 4, 3, -1, -2 },
  { 124, 4, 1, 6, 1, -6 },
  { 125, 1, 1, 4, 0, -1 },
  { 126, 8, 14, 6, -1, -14 },
  { 140, 8, 14, 9, 1, -14 },
  { 154, 4, 14, 9, 3, -14 },
  { 161, 9, 14, 9, 0, -14 },
  { 177, 9, 14, 9, 0, -14 },
  { 193, 9, 14, 9, 0, -14 },
  { 209, 9, 14, 9, 0, -14 },
  { 225, 8, 14, 9, 1, -14 },
  { 239, 7, 14, 9, 2, -14 },
  { 252, 9, 14, 9, 0, -14 },
  { 268, 8, 14, 9, 1, -14 },
  { 282, 3, 10, 4, 0, -10 },
  { 286, 4, 12, 4, -1, -10 },
  { 292, 8, 8, 10, 1, -11 },
  { 300, 8, 5, 10, 1, -9 },
  { 305, 8, 8, 10, 1, -11 },
  { 313, 6, 14, 7, 1, -14 },
  { 324, 12, 15, 14, 1, -13 },
  { 347, 9, 14, 9, -1, -14 },
  { 363, 9, 14, 10, 1, -14 },
  { 379, 10, 14, 10, 1, -14 },
  { 397, 9, 14, 11, 1, -14 },
  { 413, 8, 14, 9, 1, -14 },
  { 427, 8, 14, 8, 1, -14 },
  { 441, 10, 14, 11, 1, -14 },
  { 459, 10, 14, 11, 1, -14 },
  { 477, 5, 14, 5, 0, -14 },
  { 486, 7, 17, 4, -3, -14 },
  { 501, 9, 14, 9, 1, -14 },
  { 517, 5, 14, 8, 1, -14 },
  { 526, 13, 14, 14, 1, -14 },
  { 549, 10, 14, 11, 1, -14 },
  { 567, 10, 14, 12, 1, -14 },
  { 585, 8, 14, 9, 1, -14 },
  { 599, 10, 17, 12, 1, -14 },
  { 621, 8, 14, 9, 1, -14 },
  { 635, 9, 14, 8, 0, -14 },
  { 651, 8, 14, 8, 2, -14 },
  { 665, 10, 14, 11, 1, -14 },
  { 683, 8, 14, 9, 2, -14 },
  { 697, 13, 14, 14, 2, -14 },
  { 720, 10, 14, 8, -1, -14 },
  { 738, 8, 14, 8, 2, -14 },
  { 752, 9, 14, 9, 0, -14 },
  { 768, 7, 17, 6, 0, -14 },
  { 783, 3, 14, 6, 2, -14 },
  { 789, 7, 17, 6, -1, -14 },
  { 804, 8, 8, 9, 1, -14 },
  { 812, 7, 1, 6, -2, 2 },
  { 813, 2, 3, 4, 3, -15 },
  { 814, 8, 10, 9, 1, -10 },
  { 824, 9, 14, 9, 0, -14 },
  { 840, 7, 10, 7, 1, -10 },
  { 849, 9, 14, 9, 1, -14 },
  { 865, 7, 10, 8, 1, -10 },
  { 874, 10, 20, 4, -3, -15 },
  { 899, 9, 15, 9, 0, -10 },
  { 916, 8, 14, 9, 0, -14 },
  { 930, 4, 14, 4, 0, -14 },
  { 937, 7, 19, 4, -3, -14 },
  { 954, 8, 14, 7, 0, -14 },
  { 968, 4, 14, 4, 0, -14 },
  { 975, 13, 10, 14, 0, -10 },
  { 992, 8, 10, 9, 0, -10 },
  { 1002, 7, 10, 9, 1, -10 },
  { 1011, 10, 14, 9, -1, -10 },
  { 1029, 8, 14, 9, 1, -10 },
  { 1043, 7, 10, 6, 0, -10 },
  { 1052, 7, 10, 7, 0, -10 },
  { 1061, 4, 13, 5, 1, -13 },
  { 1068, 8, 10, 9, 1, -10 },
  { 1078, 7, 10, 7, 1, -10 },
  { 1087, 11, 10, 11, 1, -10 },
  { 1101, 9, 10, 7, -1, -10 },
  { 1113, 10, 15, 7, -2, -10 },
  { 1132, 7, 10, 7, 0, -10 },
  { 1141, 6, 17, 6, 1, -14 },
  { 1154, 1, 19, 9, 4, -14 },
  { 1157, 7, 17, 6, -1, -14 },
  { 1172, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC19PT7B_H_
