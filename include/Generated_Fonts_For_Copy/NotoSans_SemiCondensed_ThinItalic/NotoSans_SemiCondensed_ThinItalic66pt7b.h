#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00,
  0x18, 0x0C, 0x60, 0x61, 0x81, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x03,
  0x08, 0x0C, 0x20, 0x31, 0x80, 0x86, 0x02, 0x10, 0x18, 0x40, 0x61, 0x01,
  0x8C, 0x04, 0x30, 0x10, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x03, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE2, 0x1F,
  0x00, 0x70, 0x20, 0x30, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x10,
  0x00, 0x00, 0xE1, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x30, 0x18, 0x08, 0x03, 0x03, 0x00, 0xE0, 0x30, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0C, 0x03, 0x87, 0x00, 0x01, 0x80, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x01, 0x80, 0x06,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x20, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x01, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x80,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x70, 0x80,
  0x06, 0x0C, 0x3F, 0xC8, 0x00, 0xC1, 0x87, 0x06, 0x80, 0x0C, 0x30, 0xE0,
  0x2C, 0x01, 0x83, 0x0C, 0x03, 0xC0, 0x18, 0x61, 0x80, 0x3C, 0x03, 0x0C,
  0x10, 0x03, 0xE0, 0x60, 0xC3, 0x00, 0x37, 0x0E, 0x18, 0x30, 0x03, 0x3F,
  0x83, 0x06, 0x00, 0x30, 0xF0, 0x30, 0x60, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x80, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0x40, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x18, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x08, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x00, 0x0E, 0x1C,
  0x03, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x03, 0x0C, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x06, 0x30, 0x00,
  0x60, 0x06, 0x30, 0x00, 0x30, 0x0C, 0x60, 0x00, 0x30, 0x0C, 0x60, 0x00,
  0x18, 0x18, 0xC0, 0x00, 0x18, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0xC0, 0x00,
  0x04, 0x60, 0xC0, 0x00, 0x06, 0x60, 0x80, 0x00, 0x03, 0xC0, 0x80, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x0C, 0xC0, 0xE0, 0x00, 0x18, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x38, 0x00,
  0xE0, 0x60, 0x1E, 0x03, 0xC0, 0x30, 0x0F, 0xFF, 0x00, 0x18, 0x01, 0xF0,
  0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x18,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x38, 0x02, 0x00, 0x38, 0x04, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x20, 0x00,
  0x06, 0x40, 0x38, 0x07, 0x9F, 0xF0, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x32, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x10, 0x06, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00,
  0x1C, 0x00, 0x30, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x0E, 0x80, 0x76, 0x03,
  0x18, 0x38, 0x61, 0x81, 0x1C, 0x0C, 0xE0, 0x32, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xDF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x20, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0xFC, 0x00, 0x10, 0x7F, 0xF8, 0x01, 0x0E, 0x01, 0xC0,
  0x33, 0x80, 0x0E, 0x03, 0x60, 0x00, 0x60, 0x2C, 0x00, 0x03, 0x06, 0x80,
  0x00, 0x30, 0x78, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x83, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x38,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07, 0x08, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1E,
  0x0C, 0x00, 0x03, 0x60, 0x60, 0x00, 0x64, 0x03, 0x00, 0x1C, 0xC0, 0x1C,
  0x07, 0x8C, 0x00, 0xFF, 0xE0, 0x80, 0x03, 0xF0, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x70, 0x3C, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x1E, 0x01, 0xC0, 0x80, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x81, 0x80, 0x01, 0xFF, 0x80, 0x18, 0x60, 0x00, 0xE0, 0x78,
  0x03, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x63, 0x00, 0x0C, 0x00, 0xC0, 0x0C,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x98, 0x00, 0xC0, 0x02, 0x00, 0x33, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x60, 0x06, 0x00, 0x18, 0x00, 0x98, 0x01, 0x80,
  0x03, 0x00, 0x33, 0x00, 0x30, 0x00, 0x40, 0x06, 0x60, 0x0C, 0x00, 0x18,
  0x00, 0xCC, 0x01, 0x80, 0x03, 0x00, 0x19, 0x00, 0x20, 0x00, 0x60, 0x02,
  0x60, 0x0C, 0x00, 0x08, 0x00, 0xCC, 0x01, 0x80, 0x03, 0x00, 0x19, 0x80,
  0x30, 0x00, 0x60, 0x02, 0x30, 0x06, 0x00, 0x1C, 0x00, 0xC6, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x18, 0x03, 0x00, 0x1C,
  0x00, 0xC3, 0x00, 0x60, 0x06, 0x80, 0x30, 0x60, 0x0C, 0x01, 0x90, 0x0C,
  0x0C, 0x00, 0xC0, 0x73, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x60, 0xE0, 0x30,
  0x01, 0xFE, 0x07, 0xF0, 0x06, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x01, 0x00, 0x20, 0x00, 0x06, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x03,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xF0, 0x04, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x02, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x80,
  0x00, 0x07, 0x00, 0x20, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x01, 0xE0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x40, 0x01, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x02, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xE1, 0x00, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x61, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0xE0, 0x02, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x07, 0x00, 0x01, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x02, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x01, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x00, 0x8F, 0x80,
  0x00, 0x00, 0x67, 0x60, 0x00, 0x00, 0x1B, 0x8C, 0x00, 0x00, 0x07, 0xC3,
  0x00, 0x00, 0x01, 0x60, 0x40, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x1A, 0x00, 0x68, 0x00, 0x00, 0x00, 0x78, 0x01, 0xA0, 0x00,
  0x00, 0x03, 0x60, 0x04, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x13, 0x00, 0x00,
  0x00, 0x64, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x21, 0x00, 0x00, 0x01,
  0x8C, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x06, 0x10, 0x00, 0x00, 0x31,
  0x80, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18,
  0x01, 0x06, 0x00, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x30, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0xC0, 0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x10, 0x03, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x0C, 0x00,
  0x60, 0x04, 0x00, 0x20, 0x60, 0x01, 0x00, 0x30, 0x00, 0x81, 0x80, 0x04,
  0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x01,
  0x80, 0x03, 0x30, 0x00, 0x60, 0x06, 0x00, 0x04, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x16, 0x00, 0x06, 0x00, 0x40, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x06, 0x80, 0x00, 0x01, 0x80, 0x36,
  0x00, 0x00, 0x08, 0x01, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x80, 0x00, 0x06,
  0x00, 0xC6, 0x00, 0x00, 0x30, 0x06, 0x30, 0x00, 0x01, 0x00, 0x30, 0x80,
  0x00, 0x18, 0x01, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x80, 0x00, 0x30, 0x06, 0x06, 0x00, 0x01, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x80, 0x01, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x01, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x06, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x80,
  0x20, 0x06, 0x00, 0x06, 0x03, 0x00, 0x20, 0x00, 0x30, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x18, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x20,
  0x06, 0x00, 0x00, 0xC3, 0x00, 0x20, 0x00, 0x06, 0x18, 0x03, 0x00, 0x00,
  0x30, 0xC0, 0x18, 0x00, 0x00, 0xC6, 0x00, 0xC0, 0x00, 0x06, 0x20, 0x06,
  0x00, 0x00, 0x33, 0x00, 0x60, 0x00, 0x00, 0xD8, 0x03, 0x00, 0x00, 0x06,
  0xC0, 0x18, 0x00, 0x00, 0x34, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x04, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0x80, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x80, 0x00, 0x40, 0x06, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x34, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x90, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60,
  0x00, 0x20, 0x40, 0x00, 0x61, 0x80, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x10, 0x00, 0x20, 0x60, 0x00,
  0xC0, 0x40, 0x01, 0x81, 0x80, 0x06, 0x01, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x04, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0x40, 0x06, 0x01, 0x80, 0x08, 0x01, 0x00, 0x18, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x08, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x60, 0x30,
  0x00, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x83, 0x00, 0x01, 0x82, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x21, 0x80, 0x00, 0x63, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x26, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00,
  0x01, 0xB0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x02,
  0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xFC, 0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C,
  0x00, 0x1F, 0xF0, 0x20, 0x07, 0x87, 0x04, 0x03, 0x80, 0x31, 0x80, 0xE0,
  0x03, 0x30, 0x38, 0x00, 0x24, 0x0E, 0x00, 0x06, 0x81, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1E, 0x0C, 0x00,
  0x06, 0x80, 0x80, 0x01, 0x90, 0x18, 0x00, 0x36, 0x03, 0x00, 0x1C, 0xC0,
  0x30, 0x07, 0x10, 0x03, 0x83, 0x82, 0x00, 0x3F, 0xE0, 0x40, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x3F, 0xE0,
  0x00, 0x83, 0x83, 0x80, 0x0C, 0x70, 0x06, 0x00, 0x67, 0x00, 0x18, 0x03,
  0x70, 0x00, 0x60, 0x17, 0x00, 0x03, 0x01, 0xB0, 0x00, 0x18, 0x0F, 0x00,
  0x00, 0x60, 0x78, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x60, 0x50, 0x00, 0x06, 0x02, 0xC0, 0x00, 0x60, 0x36, 0x00, 0x07,
  0x01, 0x98, 0x00, 0x70, 0x0C, 0xE0, 0x07, 0x00, 0x43, 0xC0, 0xE0, 0x06,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7C,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x1E, 0x03, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x3C, 0x3C, 0x30, 0x01, 0xC0, 0x0C,
  0x60, 0x07, 0x00, 0x0C, 0x80, 0x1C, 0x00, 0x19, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0xC0, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x3C, 0x03, 0x00, 0x00,
  0xD0, 0x06, 0x00, 0x03, 0xA0, 0x04, 0x00, 0x06, 0xC0, 0x0C, 0x00, 0x19,
  0x80, 0x18, 0x00, 0x63, 0x00, 0x18, 0x03, 0x84, 0x00, 0x1C, 0x1E, 0x08,
  0x00, 0x1F, 0xF0, 0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x20, 0x00, 0x38, 0x60, 0x00, 0xE0, 0x60, 0x07, 0xC0, 0x63, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x20,
  0x0F, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x78, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x3C, 0x3C, 0x30, 0x03, 0x80,
  0x18, 0xC0, 0x1C, 0x00, 0x32, 0x00, 0xE0, 0x00, 0xC8, 0x07, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x03, 0x40, 0x30,
  0x00, 0x1D, 0x00, 0x40, 0x00, 0x6C, 0x01, 0x80, 0x03, 0x30, 0x06, 0x00,
  0x18, 0xC0, 0x0C, 0x01, 0xC2, 0x00, 0x1C, 0x1E, 0x18, 0x00, 0x3F, 0xE0,
  0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x1F, 0xF0, 0x01, 0x07, 0x07, 0x80,
  0x63, 0x80, 0x30, 0x0C, 0xC0, 0x03, 0x01, 0xB0, 0x00, 0x60, 0x2C, 0x00,
  0x04, 0x05, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x02, 0x07,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04,
  0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x0E, 0x00, 0x00, 0x63, 0x60, 0x00, 0x0C, 0xCC,
  0x00, 0x01, 0xB0, 0x80, 0x00, 0x2C, 0x18, 0x00, 0x07, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x81, 0xFE,
  0x00, 0xFF, 0x80, 0x08, 0x70, 0xF0, 0x1C, 0x3C, 0x01, 0x8C, 0x03, 0x87,
  0x00, 0x60, 0x19, 0x80, 0x18, 0xE0, 0x03, 0x01, 0x30, 0x00, 0x8C, 0x00,
  0x30, 0x16, 0x00, 0x0D, 0x80, 0x03, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x30,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x00, 0x08, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x00, 0x18, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x08, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x81,
  0xFF, 0x00, 0x08, 0x78, 0x3C, 0x01, 0x8E, 0x00, 0xC0, 0x19, 0x80, 0x06,
  0x01, 0x30, 0x00, 0x60, 0x16, 0x00, 0x02, 0x03, 0x40, 0x00, 0x30, 0x3C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x20, 0x38, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x10, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x07, 0x81, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x3F, 0xE0, 0x00, 0x10, 0x78, 0x70, 0x00, 0x31, 0xC0, 0x18, 0x00, 0x33,
  0x80, 0x0C, 0x00, 0x37, 0x00, 0x06, 0x00, 0x26, 0x00, 0x06, 0x00, 0x6C,
  0x00, 0x06, 0x00, 0x78, 0x00, 0x03, 0x00, 0x78, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x30, 0x05, 0x00, 0x00, 0x60, 0x05, 0x80, 0x00, 0xC0, 0x0D, 0x80,
  0x01, 0xC0, 0x0C, 0xC0, 0x03, 0x80, 0x0C, 0xE0, 0x07, 0x00, 0x0C, 0x78,
  0x1C, 0x00, 0x08, 0x1F, 0xF8, 0x00, 0x18, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x10, 0x03, 0xC3,
  0xC3, 0x00, 0xE0, 0x06, 0x30, 0x1C, 0x00, 0x32, 0x03, 0x80, 0x03, 0x20,
  0x70, 0x00, 0x1A, 0x06, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x40, 0xC0, 0x00, 0x34, 0x04,
  0x00, 0x06, 0xC0, 0x60, 0x00, 0xCC, 0x06, 0x00, 0x18, 0xC0, 0x30, 0x07,
  0x08, 0x01, 0xC0, 0xE1, 0x80, 0x0F, 0xF8, 0x18, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x81, 0xFC, 0x02, 0x1E, 0x10, 0x18, 0xE0, 0x00, 0x66, 0x00,
  0x01, 0x30, 0x00, 0x05, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x3F, 0x01, 0xC0, 0x02, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0xF8, 0x07, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x80, 0x7F, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x10, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x14, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x01, 0xB0, 0x30,
  0x00, 0x66, 0x06, 0x00, 0x1C, 0x80, 0x60, 0x07, 0x10, 0x07, 0x03, 0x86,
  0x00, 0x7F, 0xE0, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x20,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x10,
  0x18, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x01, 0xB0, 0x00, 0x18, 0x00, 0x0D, 0x80, 0x01, 0xC0, 0x00, 0xCC,
  0x00, 0x0A, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00, 0x23, 0x00, 0x04, 0x80,
  0x03, 0x18, 0x00, 0x66, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x06,
  0x0C, 0x00, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60,
  0xC0, 0x10, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x10, 0x08, 0x06,
  0x03, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x06, 0x01, 0x81, 0x80, 0x20,
  0x60, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x20, 0xC0, 0x08, 0x10, 0x01, 0x06,
  0x00, 0x41, 0x80, 0x08, 0x60, 0x03, 0x08, 0x00, 0x43, 0x00, 0x18, 0xC0,
  0x02, 0x30, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x06, 0x60, 0x00, 0x88, 0x00,
  0x33, 0x00, 0x04, 0xC0, 0x01, 0xB0, 0x00, 0x24, 0x00, 0x0D, 0x80, 0x01,
  0x60, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x27, 0xDF, 0x00,
  0x07, 0x80, 0x38, 0x01, 0xE0, 0x03, 0xE0, 0xE8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 47, 14, 2, -47 },
  { 72, 14, 17, 19, 7, -47 },
  { 102, 33, 47, 35, 2, -47 },
  { 296, 28, 54, 31, 2, -50 },
  { 485, 36, 49, 44, 5, -48 },
  { 706, 32, 49, 36, 2, -48 },
  { 902, 5, 17, 11, 7, -47 },
  { 913, 18, 57, 16, 2, -47 },
  { 1042, 18, 57, 16, -4, -47 },
  { 1171, 23, 24, 30, 8, -50 },
  { 1240, 27, 30, 33, 4, -38 },
  { 1342, 9, 15, 11, -3, -7 },
  { 1359, 15, 2, 19, 2, -19 },
  { 1363, 3, 4, 12, 2, -4 },
  { 1365, 28, 47, 20, -3, -47 },
  { 1530, 27, 49, 31, 3, -48 },
  { 1696, 14, 47, 31, 10, -47 },
  { 1779, 30, 48, 31, 0, -48 },
  { 1959, 30, 49, 31, 0, -48 },
  { 2143, 30, 48, 31, 0, -48 },
  { 2323, 30, 48, 31, 1, -47 },
  { 2503, 28, 49, 31, 3, -48 },
  { 2675, 27, 47, 31, 6, -47 },
  { 2834, 29, 49, 31, 2, -48 },
  { 3012, 28, 49, 31, 2, -48 },
  { 3184, 10, 35, 12, 1, -35 },
  { 3228, 14, 43, 13, -3, -35 },
  { 3304, 27, 29, 33, 4, -38 },
  { 3402, 27, 15, 33, 4, -31 },
  { 3453, 27, 29, 33, 4, -38 },
  { 3551, 20, 48, 23, 4, -48 },
  { 3671, 43, 53, 47, 3, -47 },
  { 3956, 31, 47, 31, -4, -47 },
  { 4139, 31, 47, 34, 2, -47 },
  { 4322, 33, 49, 33, 4, -48 },
  { 4525, 34, 47, 38, 2, -47 },
  { 4725, 31, 47, 31, 2, -47 },
  { 4908, 31, 47, 28, 2, -47 },
  { 5091, 35, 49, 40, 4, -48 },
  { 5306, 37, 47, 39, 2, -47 },
  { 5524, 20, 47, 16, -1, -47 },
  { 5642, 25, 58, 13, -11, -47 },
  { 5824, 34, 47, 31, 2, -47 },
  { 6024, 21, 47, 28, 2, -47 },
  { 6148, 46, 47, 48, 2, -47 },
  { 6419, 37, 47, 39, 2, -47 },
  { 6637, 35, 49, 41, 4, -48 },
  { 6852, 30, 47, 32, 2, -47 },
  { 7029, 35, 59, 41, 4, -48 },
  { 7288, 30, 47, 32, 2, -47 },
  { 7465, 30, 49, 29, 0, -48 },
  { 7649, 27, 47, 27, 6, -47 },
  { 7808, 36, 48, 39, 4, -47 },
  { 8024, 30, 47, 31, 6, -47 },
  { 8201, 46, 47, 49, 7, -47 },
  { 8472, 37, 47, 28, -4, -47 },
  { 8690, 27, 47, 27, 6, -47 },
  { 8849, 34, 47, 30, -1, -47 },
  { 9049, 25, 57, 19, -1, -47 },
  { 9228, 9, 47, 21, 7, -47 },
  { 9281, 24, 57, 19, -4, -47 },
  { 9452, 27, 26, 32, 3, -47 },
  { 9540, 22, 1, 22, -5, 7 },
  { 9543, 7, 10, 14, 10, -50 },
  { 9552, 27, 36, 32, 3, -35 },
  { 9674, 29, 51, 33, 1, -50 },
  { 9859, 23, 36, 25, 3, -35 },
  { 9963, 31, 51, 33, 3, -50 },
  { 10161, 24, 36, 28, 3, -35 },
  { 10269, 34, 66, 16, -9, -50 },
  { 10550, 30, 51, 33, 1, -35 },
  { 10742, 27, 50, 32, 2, -50 },
  { 10911, 13, 47, 12, 1, -47 },
  { 10988, 23, 63, 13, -9, -47 },
  { 11170, 27, 50, 26, 1, -50 },
  { 11339, 13, 50, 12, 1, -50 },
  { 11421, 44, 35, 48, 1, -35 },
  { 11614, 28, 35, 32, 1, -35 },
  { 11737, 26, 36, 32, 3, -35 },
  { 11854, 32, 50, 33, -2, -35 },
  { 12054, 28, 50, 33, 3, -35 },
  { 12229, 22, 35, 21, 1, -35 },
  { 12326, 24, 36, 24, 0, -35 },
  { 12434, 16, 44, 17, 3, -43 },
  { 12522, 27, 36, 32, 3, -35 },
  { 12644, 24, 35, 24, 3, -35 },
  { 12749, 37, 35, 38, 4, -35 },
  { 12911, 29, 35, 26, -2, -35 },
  { 13038, 36, 51, 24, -8, -35 },
  { 13268, 26, 35, 24, -1, -35 },
  { 13382, 23, 57, 21, 2, -47 },
  { 13546, 1, 66, 31, 16, -50 },
  { 13555, 23, 58, 21, -4, -47 },
  { 13722, 27, 6, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC66PT7B_H_
