#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x66, 0x0C, 0x81, 0x10,
  0x22, 0x04, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x88, 0x13, 0x06, 0x40, 0x88,
  0x11, 0x02, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x02, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x40, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x00, 0x20, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x40, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x10, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x38, 0x87, 0x80, 0xC1, 0x01, 0x03, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x10, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0B, 0x80, 0x00, 0x31, 0x80, 0x00, 0x41, 0x80, 0x00,
  0x81, 0x80, 0x01, 0x03, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x01, 0x81, 0x80, 0x03, 0x02,
  0x00, 0x04, 0x1C, 0x0C, 0x08, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x1C, 0xE0, 0x00, 0x80, 0xC0,
  0x80, 0x06, 0x06, 0x02, 0x00, 0x10, 0x10, 0x0C, 0x00, 0xC0, 0xC0, 0x30,
  0x06, 0x02, 0x00, 0xC0, 0x10, 0x08, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06,
  0x01, 0x00, 0x30, 0x10, 0x04, 0x00, 0x80, 0xC0, 0x30, 0x02, 0x06, 0x00,
  0xC0, 0x08, 0x10, 0x03, 0x00, 0x60, 0xC0, 0x08, 0x01, 0x86, 0x00, 0x20,
  0x04, 0x10, 0x30, 0x80, 0x10, 0xC3, 0xF2, 0x00, 0xC6, 0x18, 0x68, 0x02,
  0x10, 0xC0, 0xA0, 0x18, 0xC6, 0x03, 0xC0, 0xC2, 0x10, 0x0D, 0x02, 0x10,
  0xC0, 0x37, 0x38, 0xC2, 0x00, 0xCF, 0x82, 0x18, 0x03, 0x00, 0x18, 0x60,
  0x0C, 0x00, 0xC1, 0x00, 0x20, 0x02, 0x04, 0x00, 0x80, 0x18, 0x30, 0x02,
  0x00, 0xC0, 0xC0, 0x18, 0x02, 0x02, 0x00, 0x60, 0x18, 0x08, 0x01, 0x00,
  0xC0, 0x20, 0x04, 0x02, 0x00, 0x80, 0x30, 0x18, 0x02, 0x00, 0x80, 0xC0,
  0x08, 0x06, 0x02, 0x00, 0x20, 0x10, 0x18, 0x00, 0xC0, 0xC0, 0x40, 0x01,
  0x86, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x60, 0x20, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0x10, 0x01, 0x00, 0x06, 0x00, 0x20,
  0x00, 0xC0, 0x04, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x60,
  0x0C, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x00, 0x80, 0x18, 0xC0, 0x18, 0x02, 0x10, 0x01, 0x00, 0xC6, 0x00, 0x30,
  0x11, 0x80, 0x02, 0x06, 0x30, 0x00, 0x60, 0x84, 0x00, 0x04, 0x31, 0x80,
  0x00, 0xCC, 0x30, 0x00, 0x0D, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x07, 0x01, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x62, 0x03, 0x00,
  0x38, 0x60, 0x30, 0x1C, 0x04, 0x03, 0xFF, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x33, 0x22, 0x26, 0x64, 0x44, 0xC8, 0x88, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x30, 0x10, 0x06, 0x04, 0x00, 0x61,
  0x00, 0x06, 0x40, 0x40, 0xE7, 0xF0, 0x0E, 0x00, 0x05, 0x00, 0x06, 0x40,
  0x03, 0x08, 0x01, 0x82, 0x00, 0xC0, 0x40, 0x60, 0x10, 0x10, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x06, 0x08, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xC3, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x08, 0x00, 0x20, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x32, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00,
  0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02,
  0x20, 0x00, 0x18, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x60, 0x80, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x10, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0xE0, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x06, 0x01, 0xA0, 0x36, 0x0E, 0x61, 0x84, 0x70, 0x4C, 0x04,
  0x80, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x38, 0x01, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x1C, 0x07, 0x80, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x32, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x84, 0x00, 0x01, 0x84, 0x00, 0x03, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x18, 0x00, 0x40, 0x18, 0x00, 0x80, 0x10, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x10, 0x06, 0x00, 0x30, 0x04, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x18, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x40, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0xFE,
  0x00, 0x0F, 0xC7, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x80, 0x03,
  0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1E, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x1E, 0x00, 0x21, 0xFF, 0x00, 0xCE,
  0x03, 0x81, 0xB0, 0x03, 0x02, 0xC0, 0x03, 0x07, 0x00, 0x02, 0x1C, 0x00,
  0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x62, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x03, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x00, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x00,
  0x80, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0xE0, 0x00, 0x33, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xC3, 0x00, 0x03, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x18, 0x00, 0x20, 0x30, 0x00, 0x30, 0x20, 0x00, 0x10, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x30, 0x60,
  0x00, 0x20, 0x20, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE1, 0xC0, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x00,
  0x01, 0x06, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x01,
  0x18, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x70,
  0xC0, 0x01, 0xC0, 0x80, 0x06, 0x81, 0x80, 0x39, 0x01, 0xE1, 0xC6, 0x00,
  0xFE, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x10, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xE0, 0xC0, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x8E,
  0x04, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x86, 0x00, 0x3F, 0xE0, 0x10,
  0x80, 0x0C, 0x04, 0x02, 0x30, 0x06, 0x01, 0x80, 0x44, 0x01, 0x80, 0x30,
  0x09, 0x80, 0x20, 0x04, 0x01, 0x30, 0x0C, 0x00, 0x80, 0x24, 0x03, 0x00,
  0x30, 0x05, 0x80, 0x40, 0x06, 0x01, 0xB0, 0x18, 0x00, 0x80, 0x36, 0x03,
  0x00, 0x10, 0x06, 0x80, 0x40, 0x06, 0x00, 0x90, 0x08, 0x00, 0xC0, 0x32,
  0x03, 0x00, 0x10, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x98, 0x0C, 0x00, 0xC0,
  0x33, 0x01, 0x80, 0x38, 0x04, 0x60, 0x30, 0x07, 0x01, 0x8C, 0x02, 0x01,
  0x20, 0x61, 0x80, 0x60, 0x64, 0x18, 0x10, 0x06, 0x38, 0xC6, 0x02, 0x00,
  0x7C, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x03, 0x20, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x10, 0x08, 0x00, 0x18, 0x04, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x01,
  0x00, 0x04, 0x00, 0x80, 0x06, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x01, 0x00, 0x0C, 0x01, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x20, 0x60, 0x00, 0x10, 0x20,
  0x00, 0x08, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18, 0x00, 0x01, 0x88,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x08, 0x00,
  0x0C, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x10, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x03, 0xFF, 0xF0, 0x01, 0x00, 0xFC, 0x00, 0x80, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x0C, 0x00,
  0x1C, 0x06, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xC1, 0xF0, 0x03, 0x80, 0x08, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80,
  0x10, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x04, 0x00, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x38,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x01, 0xFF, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0x40, 0x1C, 0x00, 0x0C,
  0x00, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x02, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x81, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x99, 0x00, 0x00, 0x0B,
  0x18, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x10, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x10, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x16, 0x00, 0x00, 0x05, 0x00,
  0xB0, 0x00, 0x00, 0x68, 0x05, 0x80, 0x00, 0x02, 0x40, 0x64, 0x00, 0x00,
  0x36, 0x03, 0x20, 0x00, 0x01, 0x30, 0x11, 0x00, 0x00, 0x19, 0x00, 0x88,
  0x00, 0x01, 0x88, 0x04, 0x40, 0x00, 0x08, 0xC0, 0x63, 0x00, 0x00, 0xC6,
  0x03, 0x18, 0x00, 0x04, 0x30, 0x10, 0xC0, 0x00, 0x61, 0x00, 0x82, 0x00,
  0x02, 0x08, 0x04, 0x10, 0x00, 0x30, 0xC0, 0x60, 0x80, 0x01, 0x06, 0x03,
  0x04, 0x00, 0x18, 0x20, 0x10, 0x20, 0x01, 0x81, 0x00, 0x81, 0x80, 0x08,
  0x08, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x60, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x02, 0x00, 0xC1,
  0x80, 0x20, 0x10, 0x06, 0x08, 0x01, 0x00, 0x80, 0x10, 0xC0, 0x18, 0x0C,
  0x00, 0x84, 0x00, 0xC0, 0x60, 0x04, 0x60, 0x06, 0x02, 0x00, 0x22, 0x00,
  0x20, 0x10, 0x01, 0x30, 0x01, 0x01, 0x80, 0x0D, 0x00, 0x18, 0x0C, 0x00,
  0x78, 0x00, 0xC0, 0x60, 0x03, 0x80, 0x04, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10, 0x1C, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x03, 0x01, 0x60, 0x00, 0x08, 0x04, 0x80, 0x00, 0x20,
  0x12, 0x00, 0x00, 0x80, 0xCC, 0x00, 0x06, 0x03, 0x10, 0x00, 0x18, 0x08,
  0x40, 0x00, 0x40, 0x21, 0x80, 0x01, 0x00, 0x82, 0x00, 0x04, 0x06, 0x08,
  0x00, 0x30, 0x18, 0x30, 0x00, 0xC0, 0x40, 0x40, 0x02, 0x01, 0x01, 0x00,
  0x08, 0x04, 0x06, 0x00, 0x60, 0x30, 0x08, 0x01, 0x80, 0xC0, 0x20, 0x04,
  0x02, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x00, 0x40, 0x60, 0x04, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x04, 0x00, 0x20, 0x20, 0x10, 0x00, 0x80, 0x80, 0x40,
  0x03, 0x02, 0x03, 0x00, 0x04, 0x18, 0x0C, 0x00, 0x10, 0x60, 0x20, 0x00,
  0x61, 0x00, 0x80, 0x00, 0x84, 0x02, 0x00, 0x02, 0x30, 0x18, 0x00, 0x0C,
  0xC0, 0x60, 0x00, 0x13, 0x01, 0x00, 0x00, 0x48, 0x04, 0x00, 0x01, 0xA0,
  0x30, 0x00, 0x02, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x04,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x0E,
  0x01, 0x80, 0x06, 0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01,
  0x06, 0x00, 0x01, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x08, 0x00, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x02,
  0x01, 0x00, 0x03, 0x01, 0x00, 0x01, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01,
  0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x08, 0x00, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x18, 0x06, 0x00, 0x10, 0x06, 0x00, 0x10, 0x02, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x20, 0x01, 0x00,
  0x20, 0x01, 0x80, 0x20, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0xC0,
  0x40, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x20, 0x80, 0x00, 0x20, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x18, 0x00, 0x40, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x18, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0x05, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0x80, 0x60, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x20, 0x04, 0x00, 0x20, 0x0C,
  0x00, 0x20, 0x08, 0x00, 0x20, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x10, 0x80, 0x00, 0x11, 0x80, 0x00, 0x11, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x16, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x28, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x04, 0x80,
  0x00, 0xF0, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0xC8, 0x00, 0x0B, 0x00,
  0x02, 0x20, 0x00, 0x6C, 0x00, 0x18, 0x80, 0x01, 0x10, 0x00, 0x43, 0x00,
  0x0C, 0x40, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x08, 0x30, 0x01, 0x84, 0x00,
  0x60, 0xC0, 0x04, 0x10, 0x01, 0x03, 0x00, 0x30, 0x40, 0x04, 0x0C, 0x00,
  0x81, 0x00, 0x30, 0x30, 0x06, 0x04, 0x00, 0x80, 0xC0, 0x18, 0x10, 0x06,
  0x03, 0x00, 0x40, 0x40, 0x10, 0x0C, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x04, 0x02, 0x00, 0xC0, 0x60, 0x10, 0x18, 0x03, 0x01, 0x00, 0x40, 0x60,
  0x0C, 0x0C, 0x01, 0x01, 0x00, 0x10, 0x20, 0x04, 0x0C, 0x00, 0x41, 0x80,
  0x10, 0x20, 0x01, 0x06, 0x00, 0x41, 0x80, 0x04, 0x10, 0x01, 0x04, 0x00,
  0x10, 0xC0, 0x04, 0x30, 0x00, 0x42, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00,
  0x62, 0x00, 0x04, 0x40, 0x01, 0x98, 0x00, 0x13, 0x00, 0x06, 0x40, 0x00,
  0x48, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x68, 0x00, 0x05, 0x00, 0x01,
  0xE0, 0x00, 0x14, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x14, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x02, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x01, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x90, 0x00, 0x04,
  0x40, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x04, 0x08, 0x00, 0x30, 0x20,
  0x01, 0x80, 0x80, 0x04, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x10, 0x04,
  0x00, 0x40, 0x30, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00,
  0x21, 0x80, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x14,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60,
  0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x01,
  0x80, 0xC0, 0x02, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x30, 0x03, 0x00, 0x40,
  0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x30, 0x00,
  0x10, 0x40, 0x00, 0x31, 0x80, 0x00, 0x26, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xC0, 0xC1, 0x06, 0x08, 0x30, 0x40, 0x83, 0x00, 0x1F,
  0x00, 0x01, 0xF7, 0x8C, 0x06, 0x01, 0x90, 0x18, 0x01, 0x20, 0x60, 0x03,
  0x41, 0x80, 0x03, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x86, 0x00, 0x01, 0x0C,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x21, 0x80,
  0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x70, 0x20, 0x00, 0xA0, 0x40, 0x02, 0xC0, 0xC0, 0x0D,
  0x00, 0xC0, 0x32, 0x01, 0xC1, 0xC4, 0x00, 0xFE, 0x08, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x7E, 0x00, 0x43, 0xCF, 0x00, 0x8C, 0x06, 0x01, 0x30, 0x06, 0x06,
  0xC0, 0x06, 0x0F, 0x00, 0x0C, 0x14, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60,
  0x00, 0x21, 0x80, 0x00, 0x43, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x30, 0x00, 0x04, 0x60, 0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x43, 0x80, 0x01, 0x85, 0x00, 0x06, 0x0B,
  0x00, 0x18, 0x13, 0x00, 0x60, 0x63, 0x03, 0x80, 0xC3, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x8F, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x60,
  0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x83, 0x00,
  0x1E, 0x70, 0x80, 0x18, 0x06, 0x20, 0x0C, 0x00, 0xD8, 0x06, 0x00, 0x16,
  0x03, 0x00, 0x07, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x01, 0x00,
  0x07, 0x80, 0x40, 0x03, 0x40, 0x18, 0x01, 0x90, 0x03, 0x00, 0xC4, 0x00,
  0xE0, 0xE1, 0x00, 0x0F, 0xF0, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1E, 0x70, 0x0E, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x10, 0x00,
  0xC6, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x44, 0x00, 0x19, 0x80, 0x06,
  0x20, 0x01, 0x8C, 0x00, 0xE1, 0x81, 0xF0, 0x3F, 0xF0, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x09, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xE1, 0x00, 0xE0, 0x31, 0x01, 0x80,
  0x19, 0x03, 0x00, 0x0B, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x50, 0x20, 0x00,
  0xF0, 0x20, 0x01, 0xA0, 0x30, 0x03, 0x20, 0x10, 0x06, 0x20, 0x1C, 0x1C,
  0x60, 0x07, 0xF8, 0x60, 0x00, 0x80, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x1C,
  0x00, 0xF8, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x07, 0xE0, 0x08, 0x79, 0xE0, 0x23, 0x00,
  0xC0, 0x90, 0x03, 0x06, 0x80, 0x04, 0x1E, 0x00, 0x10, 0x70, 0x00, 0x41,
  0x80, 0x01, 0x06, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC2, 0x00,
  0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x20,
  0x00, 0x30, 0x80, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x61, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x03,
  0x38, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x04, 0x08, 0x00, 0x60, 0x20, 0x03, 0x00, 0x80,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x40, 0x30, 0x01, 0x01, 0x80,
  0x04, 0x04, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x60, 0x00, 0x63, 0x80, 0x01, 0x92, 0x00, 0x04, 0x8C, 0x00, 0x14, 0x30,
  0x00, 0x60, 0x40, 0x03, 0x81, 0x80, 0x0C, 0x02, 0x00, 0x20, 0x0C, 0x00,
  0x80, 0x30, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x02, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x30, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x80, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x21, 0xCE, 0x07, 0x9C, 0x02,
  0x60, 0x30, 0xC0, 0x60, 0x2C, 0x01, 0x98, 0x03, 0x06, 0x80, 0x1B, 0x00,
  0x30, 0x50, 0x00, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x60, 0x00,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x80, 0x01, 0x00, 0x02, 0x08, 0x00, 0x10, 0x00,
  0x61, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x41, 0x00, 0x02,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x00, 0x41, 0x00, 0x02, 0x00, 0x0C, 0x30,
  0x00, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x08, 0x20, 0x00, 0x40, 0x00,
  0x82, 0x00, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x80, 0x01, 0x04, 0x00, 0x08, 0x00, 0x10, 0x40,
  0x00, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x07, 0xE0, 0x08, 0x79, 0xE0, 0x23, 0x01, 0x80, 0x90, 0x03,
  0x06, 0x80, 0x04, 0x16, 0x00, 0x10, 0x70, 0x00, 0x41, 0x80, 0x01, 0x06,
  0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00,
  0x08, 0x60, 0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80,
  0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00, 0x61, 0x00, 0x01,
  0x84, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0x80,
  0x01, 0xE7, 0x80, 0x1C, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x20, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x13, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x34,
  0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x60, 0x00, 0xC0, 0x80, 0x06, 0x03, 0x00, 0x30, 0x07,
  0x03, 0x80, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x43, 0xCF, 0x00, 0x23, 0x01, 0x80, 0x13, 0x00, 0x60, 0x1B, 0x00, 0x18,
  0x0F, 0x00, 0x0C, 0x05, 0x00, 0x02, 0x03, 0x80, 0x01, 0x01, 0x80, 0x00,
  0x81, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x38, 0x00, 0x18, 0x1C,
  0x00, 0x18, 0x0B, 0x00, 0x18, 0x04, 0xC0, 0x18, 0x02, 0x30, 0x38, 0x03,
  0x0F, 0xF0, 0x01, 0x80, 0x80, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF7, 0x84, 0x06,
  0x01, 0x88, 0x18, 0x01, 0x90, 0x60, 0x01, 0x61, 0x80, 0x03, 0x83, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x06,
  0x20, 0x00, 0x08, 0x40, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x28, 0x20,
  0x00, 0xF0, 0x40, 0x03, 0x40, 0xC0, 0x0C, 0x80, 0x80, 0x31, 0x01, 0xC0,
  0xC6, 0x00, 0xFF, 0x0C, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x87, 0xB0, 0x23,
  0x00, 0x09, 0x00, 0x06, 0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3C, 0xFC, 0x0C, 0x00, 0x83, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC2, 0x00, 0x10, 0x70, 0x0E, 0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x7F, 0xF8, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xFE, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x40, 0x00,
  0x60, 0x80, 0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x0C,
  0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x83,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x82, 0x00, 0x06, 0x04, 0x00,
  0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x01, 0x40, 0x40, 0x06,
  0x80, 0xC0, 0x19, 0x00, 0xC0, 0xC2, 0x00, 0xFF, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00,
  0x11, 0x80, 0x06, 0x10, 0x00, 0x82, 0x00, 0x30, 0x40, 0x04, 0x08, 0x01,
  0x81, 0x00, 0x20, 0x20, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x08,
  0x03, 0x03, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0x86, 0x00, 0x10, 0xC0,
  0x02, 0x30, 0x00, 0x44, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xB0, 0x01, 0x40, 0x06, 0xC0,
  0x0D, 0x00, 0x13, 0x00, 0x24, 0x00, 0xCC, 0x01, 0x90, 0x02, 0x30, 0x04,
  0x40, 0x18, 0xC0, 0x31, 0x00, 0x43, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x18,
  0x08, 0x10, 0x10, 0x60, 0x20, 0x40, 0xC1, 0x81, 0x81, 0x02, 0x06, 0x04,
  0x04, 0x08, 0x08, 0x30, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x01,
  0x0C, 0x02, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x30, 0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x16, 0x00,
  0x2C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x03, 0x01, 0x80, 0x06, 0x00,
  0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x80, 0x00, 0x31, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x82, 0x00, 0x01, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0x00, 0x0C,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x10, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x01, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x04, 0x01, 0x80, 0x00, 0x20, 0x08,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x11, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x40, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xC0, 0x02, 0xC0, 0xE0, 0x0F, 0x00, 0x78, 0x74, 0x00, 0x3F,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 39, 11, 1, -39 },
  { 55, 11, 14, 16, 6, -39 },
  { 75, 28, 39, 28, 1, -39 },
  { 212, 23, 44, 26, 2, -41 },
  { 339, 30, 40, 36, 4, -39 },
  { 489, 27, 40, 30, 1, -39 },
  { 624, 4, 14, 9, 6, -39 },
  { 631, 15, 48, 13, 2, -39 },
  { 721, 15, 48, 13, -4, -39 },
  { 811, 18, 20, 24, 7, -41 },
  { 856, 23, 24, 27, 3, -31 },
  { 925, 7, 13, 9, -2, -6 },
  { 937, 12, 1, 16, 2, -15 },
  { 939, 3, 3, 10, 1, -3 },
  { 941, 23, 39, 16, -2, -39 },
  { 1054, 22, 40, 26, 3, -39 },
  { 1164, 12, 39, 26, 8, -39 },
  { 1223, 24, 39, 26, 0, -39 },
  { 1340, 25, 40, 26, 0, -39 },
  { 1465, 24, 39, 26, 0, -39 },
  { 1582, 24, 40, 26, 1, -39 },
  { 1702, 23, 40, 26, 3, -39 },
  { 1817, 22, 39, 26, 5, -39 },
  { 1925, 24, 40, 26, 1, -39 },
  { 2045, 23, 40, 26, 2, -39 },
  { 2160, 8, 29, 10, 1, -29 },
  { 2189, 11, 36, 10, -2, -29 },
  { 2239, 23, 23, 27, 3, -31 },
  { 2306, 23, 12, 27, 3, -25 },
  { 2341, 23, 23, 27, 3, -31 },
  { 2408, 17, 39, 19, 3, -39 },
  { 2491, 35, 43, 39, 2, -38 },
  { 2680, 25, 39, 25, -3, -39 },
  { 2802, 25, 39, 28, 2, -39 },
  { 2924, 26, 40, 27, 4, -39 },
  { 3054, 28, 39, 31, 2, -39 },
  { 3191, 25, 39, 25, 2, -39 },
  { 3313, 25, 39, 23, 2, -39 },
  { 3435, 28, 40, 33, 4, -39 },
  { 3575, 30, 39, 32, 2, -39 },
  { 3722, 17, 39, 13, -1, -39 },
  { 3805, 20, 48, 11, -9, -39 },
  { 3925, 28, 39, 25, 2, -39 },
  { 4062, 16, 39, 23, 2, -39 },
  { 4140, 37, 39, 39, 2, -39 },
  { 4321, 30, 39, 32, 2, -39 },
  { 4468, 28, 40, 33, 4, -39 },
  { 4608, 24, 39, 26, 2, -39 },
  { 4725, 28, 48, 33, 4, -39 },
  { 4893, 24, 39, 26, 2, -39 },
  { 5010, 25, 40, 24, 0, -39 },
  { 5135, 22, 39, 22, 5, -39 },
  { 5243, 28, 40, 32, 4, -39 },
  { 5383, 24, 39, 25, 5, -39 },
  { 5500, 38, 39, 40, 6, -39 },
  { 5686, 30, 39, 23, -3, -39 },
  { 5833, 22, 39, 22, 5, -39 },
  { 5941, 28, 39, 24, -1, -39 },
  { 6078, 20, 48, 16, -1, -39 },
  { 6198, 8, 39, 17, 5, -39 },
  { 6237, 20, 48, 16, -4, -39 },
  { 6357, 23, 22, 27, 2, -39 },
  { 6421, 18, 1, 18, -4, 6 },
  { 6424, 6, 8, 12, 8, -41 },
  { 6430, 23, 30, 26, 2, -29 },
  { 6517, 23, 42, 27, 1, -41 },
  { 6638, 20, 30, 21, 2, -29 },
  { 6713, 26, 42, 27, 2, -41 },
  { 6850, 19, 30, 23, 3, -29 },
  { 6922, 27, 54, 13, -7, -41 },
  { 7105, 24, 42, 27, 1, -29 },
  { 7231, 22, 41, 26, 1, -41 },
  { 7344, 10, 39, 10, 1, -39 },
  { 7393, 19, 52, 10, -8, -39 },
  { 7517, 22, 41, 21, 1, -41 },
  { 7630, 10, 41, 10, 1, -41 },
  { 7682, 36, 29, 40, 1, -29 },
  { 7813, 22, 29, 26, 1, -29 },
  { 7893, 22, 30, 26, 2, -29 },
  { 7976, 25, 41, 27, -1, -29 },
  { 8105, 23, 42, 27, 2, -29 },
  { 8226, 18, 29, 17, 1, -29 },
  { 8292, 19, 30, 20, 0, -29 },
  { 8364, 13, 37, 14, 2, -36 },
  { 8425, 23, 29, 26, 2, -28 },
  { 8509, 19, 28, 19, 3, -28 },
  { 8576, 30, 28, 31, 3, -28 },
  { 8681, 24, 28, 21, -2, -28 },
  { 8765, 29, 41, 20, -6, -28 },
  { 8914, 21, 28, 19, -1, -28 },
  { 8988, 18, 48, 17, 2, -39 },
  { 9096, 1, 54, 25, 13, -41 },
  { 9103, 19, 48, 17, -3, -39 },
  { 9217, 23, 4, 27, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC54PT7B_H_
