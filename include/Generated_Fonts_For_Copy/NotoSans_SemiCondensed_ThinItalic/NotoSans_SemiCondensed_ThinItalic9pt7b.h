#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xE0, 0x31, 0xD5, 0xA6, 0x50, 0x27, 0x64, 0x25, 0xE4,
  0x46, 0xB9, 0xBE, 0xB6, 0xC0, 0x22, 0x94, 0xCA, 0xCB, 0xC0, 0xC0, 0x6A,
  0x49, 0x20, 0x24, 0x92, 0xB0, 0x5F, 0x00, 0x5D, 0x20, 0xC0, 0xC0, 0x80,
  0x25, 0x29, 0x00, 0x25, 0x59, 0x99, 0xE0, 0xD5, 0x60, 0x25, 0x11, 0x24,
  0xE0, 0x61, 0x16, 0x11, 0xE0, 0x13, 0x59, 0x62, 0x74, 0x61, 0x1E, 0x34,
  0x47, 0x99, 0xE0, 0xE5, 0x29, 0x00, 0x25, 0x56, 0x99, 0xF0, 0x25, 0x99,
  0x71, 0xE0, 0x40, 0x80, 0x40, 0xA0, 0x71, 0x10, 0xFC, 0xC5, 0x40, 0x64,
  0x94, 0x20, 0x3D, 0x5A, 0xEB, 0xBE, 0x07, 0x00, 0x11, 0x4A, 0x64, 0xC4,
  0x7A, 0x5D, 0x29, 0x78, 0x78, 0x88, 0x88, 0xE0, 0x7A, 0x53, 0x18, 0xF8,
  0x74, 0x78, 0x8E, 0x74, 0x78, 0x88, 0x78, 0x8A, 0x99, 0xF0, 0x4A, 0x5F,
  0x18, 0xC8, 0x69, 0x29, 0x00, 0x24, 0xA4, 0x94, 0x5B, 0x11, 0x4A, 0x48,
  0x49, 0x49, 0xC0, 0x46, 0x89, 0x35, 0x6B, 0x54, 0x80, 0x4B, 0x5B, 0x39,
  0x48, 0x69, 0x99, 0x99, 0xE0, 0x75, 0x5A, 0x88, 0x69, 0x99, 0x99, 0xA4,
  0x20, 0x75, 0x5A, 0x99, 0x34, 0x44, 0x21, 0xE0, 0xF4, 0x48, 0x88, 0x99,
  0x99, 0x9E, 0x9A, 0xAC, 0x88, 0xA6, 0x9D, 0xB6, 0x92, 0x40, 0x29, 0x84,
  0x45, 0x48, 0xBA, 0xC8, 0x88, 0x71, 0x24, 0x8E, 0x69, 0x49, 0x30, 0xFC,
  0x31, 0x22, 0x22, 0xE0, 0x25, 0x90, 0xE0, 0xC0, 0x79, 0x99, 0xE0, 0x44,
  0x75, 0x99, 0xE0, 0x78, 0x88, 0xE0, 0x08, 0x5D, 0x29, 0x4B, 0x80, 0x79,
  0x68, 0xE0, 0x12, 0x22, 0x44, 0x44, 0xC0, 0x79, 0x99, 0xE1, 0xE0, 0x44,
  0x75, 0x99, 0x90, 0x56, 0xA0, 0x24, 0xA4, 0x94, 0x44, 0x56, 0x4A, 0xA0,
  0x55, 0xA8, 0x7D, 0x59, 0x65, 0xA4, 0x75, 0x99, 0x90, 0x79, 0x99, 0xE0,
  0x75, 0x99, 0xE8, 0x80, 0x79, 0x99, 0xE1, 0x20, 0x6A, 0x48, 0x71, 0x1E,
  0x4D, 0x49, 0x80, 0x55, 0x99, 0xE0, 0x9A, 0xAC, 0x80, 0xCE, 0xAD, 0x4A,
  0x00, 0x96, 0x4A, 0xA0, 0x4A, 0x94, 0x42, 0x23, 0x00, 0x65, 0x4C, 0x29,
  0x45, 0x30, 0xFF, 0x80, 0x32, 0x21, 0x22, 0xC0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 5, 7, 6, 1, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 1, 1, -6 },
  { 23, 3, 7, 2, 0, -6 },
  { 26, 3, 7, 2, -1, -6 },
  { 29, 3, 3, 4, 1, -7 },
  { 31, 3, 4, 5, 1, -5 },
  { 33, 1, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 1, 1, 2, 0, -1 },
  { 36, 3, 6, 3, 0, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 2, 6, 4, 1, -6 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 3, 6, 4, 1, -6 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 2, 5, 2, 0, -5 },
  { 76, 2, 6, 2, 0, -5 },
  { 78, 3, 4, 5, 1, -5 },
  { 80, 3, 2, 5, 1, -4 },
  { 81, 3, 4, 5, 1, -5 },
  { 83, 3, 7, 3, 0, -7 },
  { 86, 6, 7, 6, 0, -6 },
  { 92, 5, 6, 4, -1, -6 },
  { 96, 5, 6, 5, 0, -6 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 4, 6, 4, 0, -6 },
  { 111, 4, 6, 4, 0, -6 },
  { 114, 4, 7, 5, 1, -7 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 3, 6, 2, 0, -6 },
  { 125, 3, 8, 2, -1, -6 },
  { 128, 5, 6, 4, 0, -6 },
  { 132, 3, 6, 4, 0, -6 },
  { 135, 7, 6, 7, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 4, 9, 6, 1, -7 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 4, 7, 4, 0, -7 },
  { 164, 4, 6, 4, 1, -6 },
  { 167, 4, 6, 5, 1, -6 },
  { 170, 4, 6, 4, 1, -6 },
  { 173, 6, 6, 7, 1, -6 },
  { 178, 5, 6, 4, -1, -6 },
  { 182, 4, 6, 4, 1, -6 },
  { 185, 4, 6, 4, 0, -6 },
  { 188, 3, 7, 3, 0, -6 },
  { 191, 1, 6, 3, 1, -6 },
  { 192, 4, 7, 3, -1, -6 },
  { 196, 4, 3, 4, 0, -6 },
  { 198, 3, 1, 3, -1, 1 },
  { 199, 1, 2, 2, 1, -7 },
  { 200, 4, 5, 4, 0, -5 },
  { 203, 4, 7, 4, 0, -7 },
  { 207, 4, 5, 3, 0, -5 },
  { 210, 5, 7, 4, 0, -7 },
  { 215, 4, 5, 4, 0, -5 },
  { 218, 4, 9, 2, -1, -7 },
  { 223, 4, 7, 4, 0, -5 },
  { 227, 4, 7, 4, 0, -7 },
  { 231, 2, 6, 2, 0, -6 },
  { 233, 3, 8, 2, -1, -6 },
  { 236, 4, 7, 3, 0, -7 },
  { 240, 2, 7, 2, 0, -7 },
  { 242, 6, 5, 7, 0, -5 },
  { 246, 4, 5, 4, 0, -5 },
  { 249, 4, 5, 4, 0, -5 },
  { 252, 4, 7, 4, 0, -5 },
  { 256, 4, 7, 4, 0, -5 },
  { 260, 3, 5, 3, 0, -5 },
  { 262, 3, 5, 3, 0, -5 },
  { 264, 3, 6, 2, 0, -6 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 4, 5, 3, 0, -5 },
  { 273, 5, 5, 5, 1, -5 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 5, 7, 3, -1, -5 },
  { 285, 3, 5, 3, 0, -5 },
  { 287, 3, 7, 3, 0, -6 },
  { 290, 1, 9, 4, 2, -7 },
  { 292, 4, 7, 3, -1, -6 },
  { 296, 3, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC9PT7B_H_
