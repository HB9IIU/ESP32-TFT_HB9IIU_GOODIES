#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x10, 0x62,
  0x0C, 0xC1, 0x10, 0x22, 0x04, 0x41, 0x88, 0x23, 0x04, 0x40, 0x88, 0x11,
  0x04, 0x20, 0x88, 0x10, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00,
  0xC0, 0x20, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02,
  0x00, 0x02, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x60, 0x10, 0x00, 0x10,
  0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x20, 0x18, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x40, 0x20, 0x00, 0x30, 0x08, 0x03, 0xFF, 0xFF, 0xF8, 0x02, 0x01,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x04,
  0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x20, 0x18, 0x00,
  0x08, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x0E, 0x20, 0xC0, 0x60, 0x80, 0x03,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x60, 0x60, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x83, 0x00, 0x02, 0x08, 0x00,
  0x0C, 0x20, 0x00, 0x1C, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x30, 0x00, 0x04, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x81,
  0x00, 0x02, 0x06, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x81, 0x80,
  0x04, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x06, 0x0C, 0x0C,
  0x70, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x67, 0x00, 0x0C, 0x0C, 0x10, 0x00, 0x81, 0x81, 0x80, 0x10, 0x30,
  0x18, 0x03, 0x02, 0x01, 0x80, 0x20, 0x20, 0x18, 0x06, 0x06, 0x01, 0x80,
  0xC0, 0x40, 0x18, 0x08, 0x04, 0x01, 0x81, 0x80, 0xC0, 0x10, 0x30, 0x0C,
  0x01, 0x02, 0x00, 0x80, 0x10, 0x60, 0x08, 0x03, 0x0C, 0x00, 0x80, 0x30,
  0x80, 0x08, 0x02, 0x18, 0x7C, 0x80, 0x61, 0x1C, 0x68, 0x04, 0x21, 0x02,
  0x80, 0xC6, 0x20, 0x38, 0x08, 0x46, 0x03, 0xC1, 0x88, 0x40, 0x37, 0x71,
  0x8C, 0x03, 0x3C, 0x10, 0xC0, 0x30, 0x03, 0x08, 0x03, 0x00, 0x60, 0x80,
  0x30, 0x04, 0x18, 0x02, 0x00, 0xC1, 0x80, 0x20, 0x18, 0x10, 0x02, 0x01,
  0x01, 0x00, 0x60, 0x30, 0x10, 0x04, 0x06, 0x01, 0x00, 0x40, 0x40, 0x10,
  0x0C, 0x0C, 0x01, 0x00, 0x80, 0x80, 0x10, 0x18, 0x10, 0x01, 0x81, 0x03,
  0x00, 0x18, 0x20, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x04,
  0x00, 0x80, 0x06, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x18, 0x00, 0x40, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x10, 0x04, 0x00,
  0x0C, 0x06, 0x00, 0x02, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x36, 0x00, 0x00, 0x71, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x20, 0x04, 0x60, 0x18, 0x06, 0x60, 0x04,
  0x02, 0x20, 0x03, 0x03, 0x30, 0x00, 0x81, 0x10, 0x00, 0x21, 0x88, 0x00,
  0x18, 0x8C, 0x00, 0x04, 0x86, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0xE0, 0x40, 0x00, 0xD0, 0x30, 0x00, 0xCC, 0x18, 0x00, 0xC2, 0x07,
  0x01, 0xC1, 0x80, 0xFF, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x11, 0x32, 0x22,
  0x26, 0x44, 0x44, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x30, 0x10, 0x03, 0x04, 0x00, 0x71, 0x00, 0x06, 0x40, 0xC0, 0x7F,
  0xE0, 0x0C, 0x00, 0x0D, 0x00, 0x06, 0x60, 0x03, 0x08, 0x01, 0x83, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x04, 0x30, 0x86, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x20, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xC7, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x20, 0x10,
  0x01, 0x81, 0x80, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00,
  0x04, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x19, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x19, 0x00, 0x00,
  0xC8, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20,
  0x60, 0x02, 0x01, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x00, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x34, 0x0D, 0x87, 0x31, 0x84, 0x60,
  0xB0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x79, 0xE0,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0xF0, 0x03,
  0x80, 0x30, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x82, 0x00, 0x06, 0x07, 0x00, 0x38,
  0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x0D,
  0x80, 0x00, 0x33, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00,
  0x08, 0x04, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x08, 0x02, 0x00,
  0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x1E,
  0x00, 0x07, 0xFF, 0x80, 0x08, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x01, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x03, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0xC0, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x3F, 0xC0, 0x67,
  0x03, 0x02, 0x60, 0x0C, 0x16, 0x00, 0x31, 0xE0, 0x00, 0x8E, 0x00, 0x04,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42,
  0x00, 0x06, 0x10, 0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x30, 0x18, 0x03,
  0x00, 0x60, 0x30, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x79, 0xE0, 0x03, 0x80, 0x60, 0x04, 0x00, 0x60, 0x10, 0x00, 0x40, 0x60,
  0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x30, 0x01, 0x80, 0x20, 0x02,
  0x00, 0x20, 0x18, 0x00, 0x60, 0x60, 0x00, 0x63, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0E, 0x30, 0x00, 0x70, 0x18, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x10, 0x18, 0x00, 0x30, 0x60, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00,
  0x08, 0x20, 0x00, 0x30, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0xC0, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xE7, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00,
  0x11, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x20, 0x00, 0x60,
  0x80, 0x02, 0x83, 0x00, 0x1A, 0x06, 0x01, 0xD8, 0x0F, 0x3C, 0x40, 0x0F,
  0xC1, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x20, 0x1C,
  0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x03, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xC0, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xE0, 0x1F, 0x38, 0x10, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x43, 0x00, 0x1F, 0x80,
  0x21, 0x00, 0x38, 0x70, 0x11, 0x80, 0x30, 0x10, 0x08, 0x80, 0x30, 0x08,
  0x04, 0xC0, 0x30, 0x04, 0x02, 0x40, 0x30, 0x06, 0x01, 0x20, 0x10, 0x02,
  0x00, 0xB0, 0x18, 0x01, 0x00, 0x58, 0x08, 0x01, 0x80, 0x68, 0x0C, 0x00,
  0xC0, 0x34, 0x06, 0x00, 0x40, 0x16, 0x02, 0x00, 0x20, 0x1B, 0x01, 0x00,
  0x30, 0x0D, 0x80, 0x80, 0x18, 0x04, 0xC0, 0x40, 0x18, 0x06, 0x60, 0x20,
  0x0C, 0x02, 0x30, 0x10, 0x0E, 0x03, 0x18, 0x0C, 0x0D, 0x83, 0x0C, 0x02,
  0x0C, 0x43, 0x02, 0x00, 0xFC, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x28, 0x00, 0x00, 0x48, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x88, 0x00, 0x01, 0x88, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x08, 0x04, 0x00, 0x18, 0x04, 0x00, 0x10, 0x04, 0x00, 0x30, 0x04, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x04, 0x00,
  0xFF, 0xFE, 0x01, 0x80, 0x06, 0x01, 0x00, 0x06, 0x03, 0x00, 0x02, 0x02,
  0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x01, 0xFF, 0xF0, 0x01,
  0x00, 0x1C, 0x01, 0x00, 0x06, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0xE0, 0x0F, 0xFF, 0x80, 0x08,
  0x1F, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x10, 0x00, 0x10, 0x10,
  0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x08, 0x30, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0,
  0x03, 0x80, 0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xC7, 0xC0, 0x0E, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x40,
  0x0E, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x20, 0x00, 0x18, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x0C, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x08, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x40, 0x7F, 0xFF, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xC4, 0x00, 0x00, 0x11, 0x80, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x08, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x20, 0x03, 0x80, 0x3C, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x08, 0x0F, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x77, 0x80, 0x07, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x04, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x10, 0x30,
  0x00, 0x04, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x23,
  0x80, 0x00, 0x09, 0xA0, 0x00, 0x02, 0xCC, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0x70, 0x40, 0x00, 0x18, 0x18, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x20, 0x04, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00,
  0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x40, 0x04,
  0x00, 0x18, 0x01, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x07, 0x80, 0xA0, 0x00, 0x00, 0xA0, 0x34, 0x00, 0x00,
  0x34, 0x04, 0x80, 0x00, 0x05, 0x80, 0x90, 0x00, 0x01, 0xB0, 0x12, 0x00,
  0x00, 0x24, 0x06, 0x40, 0x00, 0x0C, 0x80, 0xCC, 0x00, 0x03, 0x10, 0x11,
  0x80, 0x00, 0x46, 0x02, 0x10, 0x00, 0x18, 0xC0, 0x42, 0x00, 0x02, 0x10,
  0x18, 0x40, 0x00, 0xC2, 0x03, 0x08, 0x00, 0x10, 0x40, 0x41, 0x00, 0x06,
  0x18, 0x08, 0x30, 0x00, 0x83, 0x01, 0x06, 0x00, 0x30, 0x40, 0x60, 0x40,
  0x0C, 0x08, 0x0C, 0x08, 0x01, 0x01, 0x01, 0x01, 0x00, 0x60, 0x60, 0x20,
  0x20, 0x08, 0x08, 0x0C, 0x04, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x18, 0x18, 0x0C, 0x04, 0x03, 0x02, 0x01, 0x80, 0x80, 0x20, 0xC0,
  0x20, 0x30, 0x04, 0x30, 0x04, 0x06, 0x00, 0x84, 0x00, 0x80, 0x80, 0x11,
  0x80, 0x30, 0x10, 0x02, 0x20, 0x06, 0x02, 0x00, 0x6C, 0x00, 0x80, 0xC0,
  0x0D, 0x00, 0x10, 0x18, 0x01, 0xE0, 0x02, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x40, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x80, 0x70, 0x00, 0x04, 0x02, 0x80, 0x00, 0x60, 0x34, 0x00, 0x02, 0x01,
  0x30, 0x00, 0x10, 0x08, 0x80, 0x00, 0x80, 0x44, 0x00, 0x0C, 0x06, 0x30,
  0x00, 0x60, 0x30, 0x80, 0x02, 0x01, 0x04, 0x00, 0x10, 0x08, 0x30, 0x00,
  0x80, 0x40, 0x80, 0x0C, 0x06, 0x04, 0x00, 0x60, 0x30, 0x30, 0x02, 0x01,
  0x00, 0x80, 0x10, 0x08, 0x04, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x00,
  0x80, 0x60, 0x30, 0x04, 0x02, 0x01, 0x00, 0x30, 0x10, 0x08, 0x00, 0x81,
  0x80, 0xC0, 0x04, 0x0C, 0x06, 0x00, 0x30, 0x40, 0x20, 0x00, 0x82, 0x01,
  0x00, 0x04, 0x10, 0x08, 0x00, 0x31, 0x80, 0xC0, 0x00, 0x8C, 0x06, 0x00,
  0x04, 0x40, 0x20, 0x00, 0x32, 0x01, 0x00, 0x00, 0x90, 0x08, 0x00, 0x05,
  0x80, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x02, 0x00, 0xE0, 0x04, 0x00, 0x60, 0x08, 0x00,
  0x60, 0x30, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x30, 0x10, 0x00, 0xC0, 0x60, 0x07, 0x00, 0xFF, 0xF8, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC3, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x00, 0x80, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x02, 0x00, 0xE0, 0x04, 0x00, 0x60, 0x08, 0x00, 0x60, 0x30, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x80,
  0x01, 0x83, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x60, 0x10, 0x01,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x80,
  0x04, 0x01, 0x00, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x60, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x82, 0x00,
  0x03, 0x04, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0xFC, 0x03,
  0x80, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x0C, 0x07, 0x00, 0x70,
  0x03, 0xFF, 0x80, 0x00, 0x50, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08,
  0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x08, 0x04,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x30, 0x40, 0x00, 0x40, 0x80, 0x01, 0x81, 0x00, 0x02, 0x02,
  0x00, 0x0C, 0x04, 0x00, 0x10, 0x08, 0x00, 0x60, 0x10, 0x00, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x20, 0x01, 0x00,
  0xC0, 0x02, 0x01, 0x00, 0x04, 0x06, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30,
  0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x0C, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x03, 0x00,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x14, 0x00, 0x09, 0x00, 0x06,
  0x80, 0x03, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x32, 0x00, 0x18, 0x80,
  0x04, 0x40, 0x02, 0x10, 0x01, 0x88, 0x00, 0x42, 0x00, 0x21, 0x80, 0x18,
  0x40, 0x04, 0x30, 0x02, 0x08, 0x01, 0x86, 0x00, 0xC1, 0x00, 0x20, 0xC0,
  0x10, 0x20, 0x0C, 0x18, 0x06, 0x04, 0x01, 0x03, 0x00, 0x80, 0x80, 0x60,
  0x60, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x40, 0x10, 0x30, 0x08, 0x18, 0x02, 0x04, 0x01, 0x02, 0x00, 0x41, 0x80,
  0x20, 0x40, 0x08, 0x20, 0x04, 0x18, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x21,
  0x00, 0x18, 0xC0, 0x04, 0x20, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x66, 0x00,
  0x11, 0x00, 0x0C, 0x80, 0x02, 0x60, 0x01, 0xB0, 0x00, 0x48, 0x00, 0x34,
  0x00, 0x0B, 0x00, 0x06, 0x80, 0x01, 0x40, 0x00, 0xF0, 0x00, 0x28, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x30, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00,
  0x10, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06,
  0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x10, 0x00, 0x10, 0x02, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0x30, 0x00, 0x18, 0x80, 0x00, 0x84, 0x00, 0x08, 0x20, 0x00, 0xC1,
  0x80, 0x04, 0x0C, 0x00, 0x60, 0x20, 0x06, 0x01, 0x00, 0x20, 0x08, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00, 0x41, 0x80, 0x03,
  0x08, 0x00, 0x18, 0xC0, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x36, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x00, 0x86, 0x00, 0x08,
  0x10, 0x00, 0xC0, 0x80, 0x04, 0x06, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x06, 0x18, 0x00,
  0x11, 0x80, 0x00, 0x88, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0x80, 0xC1, 0x82, 0x08, 0x10, 0x60, 0x81, 0x00, 0x7F, 0x08,
  0x0E, 0x0C, 0x40, 0xC0, 0x32, 0x0C, 0x00, 0xB0, 0xC0, 0x03, 0x04, 0x00,
  0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x18,
  0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01,
  0x18, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x41, 0x00, 0x1E, 0x08, 0x01, 0xA0,
  0x60, 0x19, 0x01, 0x81, 0x88, 0x07, 0xF8, 0x40, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x1F, 0xE0, 0x08,
  0xC0, 0xC0, 0x64, 0x01, 0x81, 0x20, 0x02, 0x05, 0x80, 0x08, 0x1C, 0x00,
  0x30, 0xE0, 0x00, 0x43, 0x80, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x10,
  0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00,
  0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x01,
  0x0C, 0x00, 0x0C, 0x70, 0x00, 0x21, 0xC0, 0x01, 0x85, 0x00, 0x0C, 0x14,
  0x00, 0x60, 0x48, 0x03, 0x03, 0x30, 0x18, 0x08, 0x7F, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xC0, 0x70, 0x10, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0x00,
  0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x40, 0x0E, 0x06, 0x60,
  0x0C, 0x01, 0xB0, 0x0C, 0x00, 0x50, 0x0C, 0x00, 0x28, 0x04, 0x00, 0x1C,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x20, 0x20, 0x00,
  0x10, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x01, 0xE0, 0x10, 0x01, 0xA0, 0x08, 0x00, 0x90, 0x06, 0x01, 0x88, 0x01,
  0x81, 0x84, 0x00, 0x7F, 0x84, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x38, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x20, 0x40, 0x06, 0x10, 0x00, 0xC6,
  0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0xC4, 0x00, 0x30, 0x80, 0x0C, 0x30,
  0x07, 0x04, 0x0F, 0x80, 0xFF, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x3F,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC2, 0x01, 0xC0, 0xC4, 0x06, 0x00, 0xD8, 0x18,
  0x00, 0xA0, 0x60, 0x01, 0x40, 0x80, 0x03, 0x83, 0x00, 0x03, 0x04, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC2, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x3C, 0x08, 0x00, 0xD0, 0x10, 0x03, 0x20, 0x30,
  0x0C, 0x40, 0x30, 0x31, 0x80, 0x3F, 0xC2, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x08, 0x01, 0x80,
  0x1C, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x21, 0xFE, 0x01, 0x18, 0x18, 0x19, 0x00, 0x60, 0x90,
  0x03, 0x05, 0x00, 0x08, 0x30, 0x00, 0x41, 0x80, 0x02, 0x18, 0x00, 0x10,
  0xC0, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00,
  0x10, 0x80, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18,
  0x00, 0x30, 0x80, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02,
  0x10, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00, 0x08, 0x60, 0x00, 0x43, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x70, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x02, 0x30,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x01, 0x81, 0x00, 0x10, 0x18, 0x01, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x10, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0x81, 0x80, 0x04,
  0x18, 0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x19, 0xC0, 0x00, 0x9B, 0x00,
  0x05, 0x88, 0x00, 0x38, 0x40, 0x03, 0x83, 0x00, 0x18, 0x08, 0x00, 0x80,
  0x60, 0x04, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x10, 0x01, 0x00,
  0x80, 0x08, 0x04, 0x00, 0x60, 0x60, 0x01, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00,
  0x02, 0x1F, 0xC0, 0x7F, 0x00, 0x98, 0x18, 0x60, 0x60, 0x4C, 0x02, 0x30,
  0x08, 0x16, 0x00, 0x98, 0x03, 0x05, 0x00, 0x3C, 0x00, 0xC1, 0x80, 0x0E,
  0x00, 0x10, 0xE0, 0x03, 0x80, 0x0C, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0x00, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x80, 0x02, 0x00, 0x08, 0x60,
  0x00, 0x80, 0x02, 0x18, 0x00, 0x60, 0x01, 0x84, 0x00, 0x10, 0x00, 0x41,
  0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x00, 0x04, 0x30, 0x00, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0x00, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x80, 0x02, 0x00,
  0x08, 0x60, 0x00, 0x80, 0x02, 0x18, 0x00, 0x60, 0x01, 0x84, 0x00, 0x18,
  0x00, 0x61, 0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x00, 0x04, 0x30, 0x00,
  0x40, 0x01, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x1F, 0xE0, 0x11, 0x81,
  0x81, 0x30, 0x06, 0x09, 0x00, 0x30, 0x50, 0x00, 0x83, 0x00, 0x04, 0x38,
  0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x04,
  0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x86,
  0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00,
  0x86, 0x00, 0x04, 0x30, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x0E, 0x06, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00,
  0x42, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x34, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x58, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x0C, 0x20, 0x00, 0x41, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x00,
  0xC0, 0x60, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x87, 0xF8, 0x00,
  0x8C, 0x0C, 0x01, 0x98, 0x06, 0x01, 0x30, 0x02, 0x01, 0x60, 0x03, 0x01,
  0xC0, 0x03, 0x03, 0x80, 0x01, 0x03, 0x80, 0x01, 0x03, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x1C,
  0x00, 0x18, 0x14, 0x00, 0x30, 0x14, 0x00, 0x60, 0x12, 0x00, 0xC0, 0x33,
  0x01, 0x80, 0x31, 0xFF, 0x00, 0x20, 0x30, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x04, 0x07, 0x03, 0x10, 0x30,
  0x04, 0xC1, 0x80, 0x0A, 0x0C, 0x00, 0x28, 0x20, 0x00, 0xE1, 0x80, 0x01,
  0x84, 0x00, 0x06, 0x30, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70,
  0xC0, 0x01, 0xC3, 0x00, 0x0F, 0x04, 0x00, 0x68, 0x10, 0x01, 0x20, 0x60,
  0x0C, 0x80, 0xC0, 0xC6, 0x01, 0xFE, 0x18, 0x00, 0x80, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x1F, 0x81, 0x18, 0x01, 0x30, 0x00,
  0x90, 0x00, 0x50, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xC0, 0x70, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x80, 0x0C, 0x38,
  0x06, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x07, 0xFF, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xE0, 0x18, 0x00, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x0C, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80,
  0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x21,
  0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x1C, 0x18,
  0x01, 0xA0, 0x40, 0x19, 0x03, 0x01, 0x88, 0x0F, 0xF0, 0xC0, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03,
  0x30, 0x00, 0x8C, 0x00, 0x43, 0x00, 0x30, 0x40, 0x08, 0x10, 0x06, 0x04,
  0x01, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x83,
  0x00, 0x60, 0x80, 0x18, 0x60, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00,
  0x09, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0xC8, 0x03, 0x20, 0x08, 0xC0, 0x22, 0x01, 0x8C, 0x06, 0x20,
  0x10, 0xC0, 0x42, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0xC0, 0x83, 0x02, 0x0C,
  0x18, 0x30, 0x40, 0xC1, 0x01, 0x04, 0x0C, 0x30, 0x10, 0xC0, 0x42, 0x01,
  0x08, 0x04, 0x60, 0x11, 0x80, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x11, 0x00,
  0x48, 0x01, 0x20, 0x05, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00,
  0x14, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x06, 0x02, 0x00, 0x18, 0x06, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x20, 0x40,
  0x00, 0x61, 0x00, 0x00, 0x46, 0x00, 0x00, 0x98, 0x00, 0x01, 0xA0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x08, 0x00, 0x04, 0x18, 0x00, 0x18, 0x10, 0x00, 0x60,
  0x20, 0x01, 0x80, 0x60, 0x02, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0xC0, 0x01, 0x03, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x20, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x20,
  0x02, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x04, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x0B, 0x07, 0x00, 0x60, 0x0E, 0x0D,
  0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 11, 13, 15, 5, -36 },
  { 64, 26, 36, 27, 1, -36 },
  { 181, 22, 42, 24, 1, -39 },
  { 297, 28, 38, 34, 4, -37 },
  { 430, 25, 38, 28, 1, -37 },
  { 549, 4, 13, 8, 5, -36 },
  { 556, 14, 44, 12, 2, -36 },
  { 633, 14, 44, 12, -3, -36 },
  { 710, 18, 19, 23, 6, -39 },
  { 753, 21, 24, 26, 3, -30 },
  { 816, 6, 12, 9, -2, -5 },
  { 825, 11, 1, 15, 2, -14 },
  { 827, 3, 3, 10, 1, -3 },
  { 829, 21, 36, 15, -2, -36 },
  { 924, 21, 38, 24, 2, -37 },
  { 1024, 11, 36, 24, 7, -36 },
  { 1074, 23, 37, 24, 0, -37 },
  { 1181, 23, 38, 24, 0, -37 },
  { 1291, 23, 37, 24, 0, -37 },
  { 1398, 23, 37, 24, 1, -36 },
  { 1505, 21, 38, 24, 3, -37 },
  { 1605, 21, 36, 24, 4, -36 },
  { 1700, 23, 38, 24, 1, -37 },
  { 1810, 22, 38, 24, 1, -37 },
  { 1915, 8, 27, 10, 1, -27 },
  { 1942, 11, 34, 10, -2, -27 },
  { 1989, 21, 22, 26, 3, -29 },
  { 2047, 21, 12, 26, 3, -24 },
  { 2079, 21, 22, 26, 3, -29 },
  { 2137, 16, 37, 18, 3, -37 },
  { 2211, 33, 41, 36, 2, -36 },
  { 2381, 24, 37, 24, -3, -37 },
  { 2492, 24, 36, 26, 2, -36 },
  { 2600, 25, 38, 26, 3, -37 },
  { 2719, 26, 36, 30, 2, -36 },
  { 2836, 23, 36, 24, 2, -36 },
  { 2940, 23, 36, 22, 2, -36 },
  { 3044, 27, 38, 31, 3, -37 },
  { 3173, 28, 36, 30, 2, -36 },
  { 3299, 16, 36, 12, -1, -36 },
  { 3371, 19, 45, 10, -8, -36 },
  { 3478, 26, 36, 24, 2, -36 },
  { 3595, 15, 36, 22, 2, -36 },
  { 3663, 35, 36, 37, 2, -36 },
  { 3821, 29, 36, 30, 2, -36 },
  { 3952, 27, 38, 31, 3, -37 },
  { 4081, 23, 36, 25, 2, -36 },
  { 4185, 27, 46, 31, 3, -37 },
  { 4341, 23, 36, 25, 2, -36 },
  { 4445, 23, 38, 22, 0, -37 },
  { 4555, 21, 36, 21, 5, -36 },
  { 4650, 28, 37, 30, 3, -36 },
  { 4780, 23, 36, 24, 5, -36 },
  { 4884, 35, 36, 38, 6, -36 },
  { 5042, 28, 36, 21, -3, -36 },
  { 5168, 21, 36, 21, 5, -36 },
  { 5263, 26, 36, 23, -1, -36 },
  { 5380, 19, 44, 15, -1, -36 },
  { 5485, 8, 36, 16, 5, -36 },
  { 5521, 18, 44, 15, -3, -36 },
  { 5620, 21, 21, 25, 2, -37 },
  { 5676, 17, 1, 17, -4, 5 },
  { 5679, 6, 8, 11, 7, -39 },
  { 5685, 21, 28, 25, 2, -27 },
  { 5759, 22, 40, 25, 1, -39 },
  { 5869, 18, 28, 20, 2, -27 },
  { 5932, 25, 40, 25, 2, -39 },
  { 6057, 19, 28, 22, 2, -27 },
  { 6124, 26, 51, 12, -7, -39 },
  { 6290, 23, 39, 25, 1, -27 },
  { 6403, 21, 39, 25, 1, -39 },
  { 6506, 10, 37, 10, 1, -37 },
  { 6553, 18, 49, 10, -7, -37 },
  { 6664, 21, 39, 20, 1, -39 },
  { 6767, 10, 39, 9, 1, -39 },
  { 6816, 34, 27, 37, 1, -27 },
  { 6931, 21, 27, 25, 1, -27 },
  { 7002, 21, 28, 25, 2, -27 },
  { 7076, 24, 39, 25, -1, -27 },
  { 7193, 22, 39, 25, 2, -27 },
  { 7301, 17, 27, 16, 1, -27 },
  { 7359, 18, 28, 19, 0, -27 },
  { 7422, 12, 35, 13, 2, -34 },
  { 7475, 21, 28, 25, 2, -27 },
  { 7549, 18, 27, 18, 3, -27 },
  { 7610, 28, 27, 30, 3, -27 },
  { 7705, 23, 27, 20, -2, -27 },
  { 7783, 27, 39, 19, -6, -27 },
  { 7915, 20, 27, 18, -1, -27 },
  { 7983, 18, 44, 16, 1, -36 },
  { 8082, 1, 51, 24, 12, -39 },
  { 8089, 18, 44, 16, -3, -36 },
  { 8188, 21, 4, 26, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC51PT7B_H_
