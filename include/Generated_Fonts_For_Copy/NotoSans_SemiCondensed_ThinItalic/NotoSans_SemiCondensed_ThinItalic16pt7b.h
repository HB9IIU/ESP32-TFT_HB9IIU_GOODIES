#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0xB6, 0xE0, 0x09, 0x04, 0x84, 0x8F,
  0xF1, 0x21, 0x20, 0x91, 0xFE, 0x28, 0x24, 0x12, 0x00, 0x04, 0x3C, 0xA1,
  0x42, 0x87, 0x02, 0x0A, 0x12, 0x2B, 0x61, 0x02, 0x00, 0x20, 0xA8, 0xA2,
  0x52, 0x49, 0x44, 0xBE, 0xB2, 0xA9, 0x14, 0x92, 0x51, 0x28, 0xE0, 0x0C,
  0x12, 0x12, 0x22, 0x14, 0x18, 0x28, 0x49, 0x85, 0x82, 0x86, 0x7A, 0xF0,
  0x18, 0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x04, 0x20, 0x11, 0x11, 0x11,
  0x11, 0x12, 0x24, 0x48, 0x12, 0x87, 0xD8, 0x90, 0x40, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x00, 0x56, 0xE0, 0x80, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x40, 0x82, 0x00, 0x18, 0x94, 0x51, 0x86, 0x18, 0x61, 0x86,
  0x28, 0xBC, 0x3D, 0x22, 0x22, 0x24, 0x44, 0x40, 0x1C, 0x44, 0x08, 0x10,
  0x20, 0x81, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x1C, 0x44, 0x08, 0x10, 0x20,
  0x8F, 0x02, 0x02, 0x04, 0x17, 0xC0, 0x02, 0x04, 0x18, 0x51, 0x24, 0x89,
  0x22, 0xFE, 0x08, 0x20, 0x40, 0x1E, 0x40, 0x81, 0x03, 0x80, 0x80, 0x81,
  0x02, 0x0B, 0xE0, 0x0E, 0x61, 0x02, 0x08, 0x1F, 0x21, 0x42, 0x85, 0x0A,
  0x27, 0x80, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00,
  0x0C, 0x64, 0x89, 0x12, 0x22, 0x8A, 0x22, 0x83, 0x06, 0x13, 0xC0, 0x1C,
  0x44, 0x8A, 0x14, 0x28, 0x51, 0x9D, 0x04, 0x08, 0x27, 0x80, 0x24, 0x00,
  0x00, 0x80, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80, 0x06, 0x71, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30, 0x31, 0x8C,
  0x20, 0x00, 0x70, 0x42, 0x10, 0x88, 0x88, 0x80, 0x01, 0x00, 0x1F, 0x88,
  0x14, 0x06, 0x3D, 0x92, 0x68, 0x9A, 0x26, 0x92, 0xAF, 0xA4, 0x08, 0x01,
  0xF0, 0x02, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x3E, 0x21, 0x41, 0x41, 0x81,
  0x7E, 0x85, 0x0A, 0x16, 0x53, 0xA1, 0x41, 0x85, 0x0B, 0xE0, 0x0F, 0x10,
  0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x7E, 0x41,
  0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x8C, 0xF0, 0x7E, 0x81, 0x02,
  0x07, 0xD0, 0x20, 0x40, 0x81, 0x03, 0xE0, 0x7E, 0x81, 0x02, 0x04, 0x0F,
  0x20, 0x40, 0x81, 0x02, 0x00, 0x0F, 0x08, 0x48, 0x08, 0x08, 0x04, 0x02,
  0x1D, 0x02, 0x81, 0x41, 0x20, 0x8F, 0xC0, 0x40, 0xA0, 0x90, 0x48, 0x27,
  0xF4, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x21, 0x00, 0x39, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x30, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04,
  0x13, 0x80, 0x43, 0x44, 0x48, 0x50, 0x60, 0x50, 0x90, 0x90, 0x88, 0x88,
  0x84, 0x44, 0x44, 0x48, 0x88, 0x88, 0xF0, 0x20, 0x64, 0x09, 0x83, 0x30,
  0x66, 0x15, 0x24, 0xA4, 0xA4, 0xA4, 0x94, 0x93, 0x12, 0x42, 0x00, 0x20,
  0xB0, 0x94, 0x4A, 0x25, 0x14, 0x4A, 0x29, 0x14, 0x86, 0x42, 0x21, 0x00,
  0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C,
  0x7C, 0x85, 0x0A, 0x14, 0x5F, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1E, 0x21,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x6C, 0x10, 0x08,
  0x08, 0x7E, 0x85, 0x0A, 0x14, 0x4F, 0x24, 0x44, 0x89, 0x12, 0x20, 0x1E,
  0x41, 0x02, 0x02, 0x04, 0x06, 0x02, 0x04, 0x08, 0x17, 0xC0, 0xFE, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x40, 0xA0, 0x90, 0x48,
  0x28, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x42, 0x1E, 0x00, 0x87, 0x0A, 0x24,
  0x49, 0x12, 0x28, 0x50, 0xC1, 0x82, 0x00, 0x84, 0x31, 0x8A, 0x31, 0x4A,
  0x29, 0x49, 0x49, 0x29, 0x46, 0x28, 0xC6, 0x10, 0xC2, 0x10, 0x00, 0x11,
  0x88, 0x84, 0x81, 0x80, 0x80, 0x40, 0x50, 0x48, 0x24, 0x21, 0x20, 0x80,
  0x82, 0x89, 0x22, 0x45, 0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3F, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFC, 0x3C, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x83, 0x80, 0xAA, 0xA9, 0x54, 0x1C,
  0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x23, 0x80, 0x18, 0xA2,
  0x91, 0x86, 0x10, 0xF8, 0x90, 0x39, 0x18, 0x61, 0x86, 0x18, 0xA2, 0xF8,
  0x20, 0x40, 0x81, 0x63, 0x24, 0x50, 0xA1, 0x42, 0x85, 0x17, 0xC0, 0x3A,
  0x21, 0x08, 0x42, 0x10, 0xF0, 0x02, 0x04, 0x09, 0xD4, 0x50, 0xA1, 0x42,
  0x85, 0x12, 0x27, 0xC0, 0x32, 0x63, 0x1F, 0x42, 0x10, 0xF0, 0x07, 0x08,
  0x08, 0x1C, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0xC0, 0x1D, 0x22, 0x42, 0x42, 0x42, 0x82, 0x84, 0x44, 0x7C, 0x04,
  0x04, 0x08, 0xF0, 0x10, 0x40, 0x81, 0x63, 0x24, 0x50, 0xA1, 0x42, 0x8A,
  0x14, 0x20, 0x20, 0x14, 0x92, 0x52, 0x00, 0x08, 0x00, 0x11, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x23, 0x00, 0x20, 0x40, 0x81, 0x12, 0x49, 0x14, 0x38,
  0x50, 0x92, 0x24, 0x40, 0x24, 0x92, 0x92, 0x4A, 0x40, 0x0C, 0xC6, 0x64,
  0x88, 0xA1, 0x14, 0x42, 0x88, 0x51, 0x14, 0x22, 0x84, 0x40, 0x0C, 0x64,
  0x8A, 0x14, 0x28, 0x51, 0x42, 0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62,
  0xF0, 0x0C, 0x64, 0x8A, 0x14, 0x28, 0x50, 0xA2, 0xF9, 0x02, 0x04, 0x08,
  0x00, 0x3A, 0x8A, 0x14, 0x28, 0x50, 0xA2, 0x44, 0xF8, 0x10, 0x20, 0x41,
  0x00, 0x0C, 0xC2, 0x10, 0x41, 0x04, 0x20, 0x80, 0x39, 0x14, 0x10, 0x20,
  0x40, 0x82, 0xF0, 0x44, 0xF4, 0x88, 0x88, 0x88, 0xC0, 0x46, 0x18, 0x61,
  0x8A, 0x28, 0xBE, 0x8E, 0x29, 0x24, 0xA2, 0x84, 0x20, 0x88, 0xCC, 0xA6,
  0x55, 0x4A, 0xA6, 0x52, 0x11, 0x08, 0x23, 0x14, 0x14, 0x08, 0x18, 0x28,
  0x44, 0xC4, 0x11, 0x88, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x60, 0x10, 0x10,
  0x08, 0x08, 0x18, 0x00, 0x3C, 0x21, 0x08, 0x21, 0x08, 0x3C, 0x1C, 0x41,
  0x04, 0x20, 0x8C, 0x08, 0x41, 0x04, 0x10, 0x40, 0x80, 0xFF, 0xFF, 0x18,
  0x20, 0x82, 0x08, 0x20, 0xC4, 0x10, 0x42, 0x08, 0x23, 0x00, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 5, 2, -11 },
  { 8, 9, 11, 8, 0, -11 },
  { 21, 7, 13, 8, 0, -12 },
  { 33, 9, 12, 11, 1, -12 },
  { 47, 8, 12, 9, 0, -12 },
  { 59, 1, 4, 3, 2, -11 },
  { 60, 5, 14, 4, 0, -11 },
  { 69, 4, 14, 4, -1, -11 },
  { 76, 6, 6, 7, 2, -12 },
  { 81, 7, 7, 8, 1, -9 },
  { 88, 2, 4, 3, -1, -2 },
  { 89, 3, 1, 5, 1, -5 },
  { 90, 1, 1, 3, 0, -1 },
  { 91, 7, 11, 5, -1, -11 },
  { 101, 6, 12, 8, 1, -12 },
  { 110, 4, 11, 8, 2, -11 },
  { 116, 7, 12, 8, 0, -12 },
  { 127, 7, 12, 8, 0, -12 },
  { 138, 7, 12, 8, 0, -12 },
  { 149, 7, 11, 8, 0, -11 },
  { 159, 7, 12, 8, 1, -12 },
  { 170, 7, 11, 8, 1, -11 },
  { 180, 7, 12, 8, 0, -12 },
  { 191, 7, 12, 8, 0, -12 },
  { 202, 3, 9, 3, 0, -9 },
  { 206, 4, 11, 3, -1, -9 },
  { 212, 7, 7, 8, 1, -9 },
  { 219, 7, 4, 8, 1, -8 },
  { 223, 7, 7, 8, 1, -9 },
  { 230, 5, 12, 6, 1, -12 },
  { 238, 10, 12, 11, 1, -11 },
  { 253, 8, 11, 7, -1, -11 },
  { 264, 7, 11, 8, 1, -11 },
  { 274, 8, 12, 8, 1, -12 },
  { 286, 8, 11, 9, 1, -11 },
  { 297, 7, 11, 7, 1, -11 },
  { 307, 7, 11, 7, 1, -11 },
  { 317, 9, 12, 10, 1, -12 },
  { 331, 9, 11, 9, 1, -11 },
  { 344, 5, 11, 4, 0, -11 },
  { 351, 6, 14, 3, -3, -11 },
  { 362, 8, 11, 8, 1, -11 },
  { 373, 4, 11, 7, 1, -11 },
  { 379, 11, 11, 12, 1, -11 },
  { 395, 9, 11, 10, 1, -11 },
  { 408, 8, 12, 10, 1, -12 },
  { 420, 7, 11, 8, 1, -11 },
  { 430, 8, 15, 10, 1, -12 },
  { 445, 7, 11, 8, 1, -11 },
  { 455, 7, 12, 7, 0, -12 },
  { 466, 7, 11, 7, 1, -11 },
  { 476, 9, 11, 9, 1, -11 },
  { 489, 7, 11, 7, 2, -11 },
  { 499, 11, 11, 12, 2, -11 },
  { 515, 9, 11, 7, -1, -11 },
  { 528, 7, 11, 7, 1, -11 },
  { 538, 8, 11, 7, 0, -11 },
  { 549, 6, 14, 5, 0, -11 },
  { 560, 2, 11, 5, 2, -11 },
  { 563, 6, 14, 5, -1, -11 },
  { 574, 6, 6, 8, 1, -11 },
  { 579, 5, 1, 5, -1, 1 },
  { 580, 2, 2, 3, 2, -12 },
  { 581, 6, 9, 8, 1, -9 },
  { 588, 7, 12, 8, 0, -12 },
  { 599, 5, 9, 6, 1, -9 },
  { 605, 7, 12, 8, 1, -12 },
  { 616, 5, 9, 7, 1, -9 },
  { 622, 8, 16, 4, -2, -12 },
  { 638, 8, 13, 8, 0, -9 },
  { 651, 7, 12, 8, 0, -12 },
  { 662, 3, 11, 3, 0, -11 },
  { 667, 5, 15, 3, -2, -11 },
  { 677, 7, 12, 6, 0, -12 },
  { 688, 3, 12, 3, 0, -12 },
  { 693, 11, 9, 12, 0, -9 },
  { 706, 7, 9, 8, 0, -9 },
  { 714, 6, 9, 8, 1, -9 },
  { 721, 7, 13, 8, 0, -9 },
  { 733, 7, 13, 8, 1, -9 },
  { 745, 6, 9, 5, 0, -9 },
  { 752, 6, 9, 6, 0, -9 },
  { 759, 4, 11, 4, 1, -11 },
  { 765, 6, 8, 8, 1, -8 },
  { 771, 6, 8, 6, 1, -8 },
  { 777, 9, 8, 9, 1, -8 },
  { 786, 8, 8, 6, -1, -8 },
  { 794, 9, 12, 6, -2, -8 },
  { 808, 6, 8, 6, 0, -8 },
  { 814, 6, 14, 5, 0, -11 },
  { 825, 1, 16, 7, 3, -12 },
  { 827, 6, 14, 5, -1, -11 },
  { 838, 7, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC16PT7B_H_
