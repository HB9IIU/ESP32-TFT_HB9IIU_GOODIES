#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x18,
  0xC0, 0xC4, 0x06, 0x60, 0x23, 0x01, 0x18, 0x18, 0x80, 0xC4, 0x06, 0x60,
  0x23, 0x01, 0x10, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x23, 0x01, 0x10, 0x18,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC2,
  0x02, 0x00, 0x20, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x86, 0x0F, 0x00, 0x60, 0x60, 0x20,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x08, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18,
  0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x80, 0x30, 0x30, 0x0E, 0x02,
  0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x18, 0x07, 0x06, 0x00, 0x01, 0x00,
  0xE0, 0x30, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x10, 0x00,
  0x40, 0x18, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x01, 0x80, 0x30, 0x01,
  0x00, 0x18, 0x02, 0x00, 0x10, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x06,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x00, 0x80, 0x06, 0x0C, 0x00, 0x0C,
  0x00, 0x40, 0x81, 0xF8, 0x80, 0x0C, 0x18, 0x79, 0xC8, 0x00, 0xC3, 0x0E,
  0x06, 0x80, 0x18, 0x21, 0xC0, 0x6C, 0x01, 0x86, 0x18, 0x02, 0xC0, 0x30,
  0xC3, 0x00, 0x2C, 0x06, 0x0C, 0x30, 0x03, 0x60, 0xE1, 0x86, 0x00, 0x37,
  0xFC, 0x30, 0x60, 0x03, 0x1F, 0x03, 0x04, 0x00, 0x20, 0x00, 0x60, 0xC0,
  0x02, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x18,
  0x08, 0x00, 0x60, 0x03, 0x01, 0x80, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x00, 0xE1,
  0xC0, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x72, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x01, 0x80, 0x03, 0x0C, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x38, 0x00, 0x60, 0x04, 0x30, 0x00,
  0x60, 0x0C, 0x60, 0x00, 0x30, 0x08, 0x60, 0x00, 0x30, 0x18, 0xC0, 0x00,
  0x18, 0x30, 0xC0, 0x00, 0x08, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x80, 0x00,
  0x06, 0xC0, 0x80, 0x00, 0x06, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x0D, 0x80, 0xE0, 0x00,
  0x18, 0xC0, 0x60, 0x00, 0x70, 0x40, 0x30, 0x00, 0xE0, 0x60, 0x1C, 0x07,
  0x80, 0x20, 0x0F, 0xFE, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x18, 0xC4,
  0x63, 0x18, 0x84, 0x63, 0x10, 0x84, 0x63, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x38, 0x06, 0x00, 0x1C, 0x08, 0x00, 0x1C, 0x10, 0x00, 0x0E, 0x20,
  0x00, 0x06, 0x41, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x84, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x08, 0x00,
  0xE0, 0x18, 0x03, 0x80, 0x10, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03,
  0x03, 0x00, 0xFF, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x36, 0x07, 0x30,
  0x71, 0x0E, 0x18, 0xE0, 0xCC, 0x06, 0xC0, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x02,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x04, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x83, 0xFF, 0x00, 0x10, 0xF0, 0x78, 0x03, 0x18, 0x00, 0xC0, 0x37, 0x00,
  0x06, 0x02, 0x40, 0x00, 0x60, 0x68, 0x00, 0x03, 0x07, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x38,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xE0, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x34, 0x06,
  0x00, 0x06, 0xC0, 0x70, 0x00, 0xCC, 0x03, 0x80, 0x38, 0x80, 0x1F, 0xFE,
  0x18, 0x00, 0x7F, 0x81, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x70, 0x3C, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1C, 0x01, 0xC1, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x01, 0xFE, 0x00, 0x30,
  0xC0, 0x01, 0xFF, 0xE0, 0x0C, 0x30, 0x00, 0xE0, 0x18, 0x03, 0x18, 0x00,
  0x60, 0x06, 0x00, 0xC6, 0x00, 0x30, 0x01, 0x00, 0x33, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0xD8, 0x01, 0x80, 0x02, 0x00, 0x36, 0x00, 0x40, 0x01, 0x80, 0x0D, 0x80,
  0x30, 0x00, 0x60, 0x02, 0x60, 0x0C, 0x00, 0x10, 0x01, 0x90, 0x06, 0x00,
  0x0C, 0x00, 0x6C, 0x01, 0x80, 0x03, 0x00, 0x1B, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0xC0, 0x18, 0x00, 0x20, 0x03, 0x30, 0x04, 0x00, 0x18, 0x00, 0xCC,
  0x01, 0x00, 0x06, 0x00, 0x63, 0x00, 0x40, 0x03, 0x80, 0x18, 0xC0, 0x10,
  0x00, 0xE0, 0x0C, 0x30, 0x06, 0x00, 0x78, 0x07, 0x0C, 0x01, 0x80, 0x36,
  0x01, 0x83, 0x00, 0x60, 0x18, 0x80, 0xC0, 0xC0, 0x0C, 0x0C, 0x30, 0xE0,
  0x30, 0x01, 0xFE, 0x0F, 0xF0, 0x0C, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x00, 0x81, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0x40, 0x02, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x40, 0x07, 0xE0, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x1E, 0x00, 0x20, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x1F, 0x80, 0x03, 0x00, 0x03, 0x80, 0x04, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x02, 0x00, 0x03, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x01, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x08, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x38, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x80, 0x06, 0x00, 0x07, 0x80, 0x01,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFE,
  0x08, 0x00, 0x03, 0xFF, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x80, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0xE7, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x04, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x08, 0x70, 0x00,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x01, 0x9D, 0x80, 0x00, 0x00, 0x66, 0x60,
  0x00, 0x00, 0x1B, 0x0C, 0x00, 0x00, 0x05, 0x83, 0x00, 0x00, 0x03, 0xC0,
  0x40, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xB0, 0x07, 0x80,
  0x00, 0x00, 0x0D, 0x00, 0x24, 0x00, 0x00, 0x00, 0xD8, 0x03, 0x20, 0x00,
  0x00, 0x06, 0xC0, 0x19, 0x00, 0x00, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0x20, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x23, 0x00, 0x00, 0x01,
  0x18, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x06, 0x10, 0x00, 0x00, 0xC3, 0x00,
  0x20, 0xC0, 0x00, 0x06, 0x18, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x00, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x20, 0x04, 0x0C,
  0x00, 0x01, 0x03, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18, 0x03, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x18, 0x08, 0x00, 0x0C, 0x04, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x60, 0x04, 0x03, 0x00, 0x06, 0x03, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x04,
  0x00, 0xC0, 0x10, 0x01, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0xC0, 0x04, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x60, 0x60, 0x03, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x03, 0x00, 0x08,
  0x30, 0x00, 0x80, 0x18, 0x00, 0x41, 0x00, 0x04, 0x00, 0x80, 0x03, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x19, 0x80, 0x03, 0x00, 0x60, 0x00, 0xCC, 0x00,
  0x18, 0x03, 0x00, 0x06, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x36, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x00, 0x00,
  0x60, 0x07, 0x80, 0x00, 0x03, 0x00, 0x26, 0x00, 0x00, 0x18, 0x03, 0x30,
  0x00, 0x00, 0x80, 0x19, 0x80, 0x00, 0x0C, 0x00, 0xC6, 0x00, 0x00, 0x60,
  0x06, 0x30, 0x00, 0x03, 0x00, 0x21, 0x80, 0x00, 0x18, 0x03, 0x06, 0x00,
  0x00, 0x80, 0x18, 0x30, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x06,
  0x06, 0x00, 0x03, 0x00, 0x20, 0x30, 0x00, 0x18, 0x03, 0x00, 0x80, 0x00,
  0x80, 0x18, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x03, 0x00, 0x60, 0x06, 0x00, 0x10, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x00, 0x80, 0x10, 0x03, 0x00, 0x06, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x04, 0x00, 0x06, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x10, 0x03, 0x00, 0x00, 0x81, 0x80, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x60, 0x04, 0x00, 0x00, 0x83, 0x00,
  0x60, 0x00, 0x06, 0x10, 0x03, 0x00, 0x00, 0x31, 0x80, 0x18, 0x00, 0x00,
  0x8C, 0x00, 0x80, 0x00, 0x06, 0x60, 0x0C, 0x00, 0x00, 0x32, 0x00, 0x60,
  0x00, 0x00, 0x90, 0x03, 0x00, 0x00, 0x07, 0x80, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x80, 0x1F, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x04, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x80, 0x1F, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x20, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x02, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x01,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x40, 0x00, 0x40, 0xC0, 0x00, 0xC1, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0x10,
  0x00, 0x60, 0x40, 0x01, 0x80, 0x40, 0x01, 0x01, 0x00, 0x0C, 0x01, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x10, 0x01,
  0x80, 0x40, 0x06, 0x00, 0x40, 0x06, 0x01, 0x00, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x10, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x01, 0x00, 0x40, 0x06,
  0x01, 0x00, 0x04, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x60,
  0x20, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x00, 0x61, 0x80, 0x01, 0x82, 0x00, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0x62, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x64, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x83, 0x0C, 0x18, 0x60,
  0xC1, 0x06, 0x08, 0x10, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x0C,
  0x01, 0xC0, 0x71, 0x00, 0x60, 0x06, 0x20, 0x18, 0x00, 0x64, 0x06, 0x00,
  0x05, 0x81, 0x80, 0x00, 0xB0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x14, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x01, 0xB0, 0x18, 0x00,
  0x66, 0x03, 0x00, 0x18, 0x80, 0x30, 0x06, 0x10, 0x03, 0x83, 0x86, 0x00,
  0x3F, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x7C, 0x00,
  0x08, 0x3F, 0xF0, 0x01, 0x87, 0x01, 0xC0, 0x18, 0xC0, 0x0C, 0x01, 0x98,
  0x00, 0x60, 0x13, 0x00, 0x06, 0x03, 0x60, 0x00, 0x30, 0x3C, 0x00, 0x03,
  0x03, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x70,
  0x00, 0x01, 0x07, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x28, 0x00,
  0x03, 0x02, 0x80, 0x00, 0x60, 0x6C, 0x00, 0x0C, 0x06, 0x60, 0x01, 0x80,
  0x47, 0x00, 0x30, 0x04, 0x38, 0x0E, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xC0, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x1C, 0x07, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x1F, 0xFC, 0x18,
  0x00, 0x70, 0x1C, 0x20, 0x03, 0x80, 0x0C, 0xC0, 0x0E, 0x00, 0x0D, 0x80,
  0x18, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x14, 0x01, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x78, 0x03, 0x00, 0x01, 0xB0, 0x06, 0x00, 0x07, 0x60,
  0x06, 0x00, 0x0C, 0x80, 0x0C, 0x00, 0x71, 0x00, 0x0C, 0x01, 0xC6, 0x00,
  0x0E, 0x0F, 0x0C, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00,
  0x01, 0x84, 0x00, 0x07, 0x18, 0x00, 0x38, 0x30, 0x01, 0xE0, 0x60, 0x3F,
  0x00, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x40, 0x1E,
  0x03, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x30, 0x01, 0xC0, 0x70, 0x80, 0x1C, 0x00, 0x62, 0x00, 0xE0, 0x00, 0xD8,
  0x03, 0x00, 0x03, 0x60, 0x18, 0x00, 0x05, 0x00, 0xC0, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0xC0, 0x30, 0x00, 0x1B, 0x00, 0xC0, 0x00, 0xEC, 0x01, 0x80, 0x03,
  0x20, 0x06, 0x00, 0x39, 0x80, 0x0C, 0x01, 0xC6, 0x00, 0x1C, 0x1E, 0x18,
  0x00, 0x3F, 0xE0, 0x60, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x1F, 0x80, 0x04, 0x1F, 0xFC, 0x01,
  0x87, 0x01, 0xC0, 0x33, 0x80, 0x18, 0x06, 0xE0, 0x01, 0x80, 0x90, 0x00,
  0x30, 0x16, 0x00, 0x06, 0x07, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x30, 0x00,
  0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x70, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x70, 0x00, 0x03, 0x1A, 0x00,
  0x00, 0x66, 0x60, 0x00, 0x0D, 0x8C, 0x00, 0x01, 0x60, 0xC0, 0x00, 0x78,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x04, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x10, 0xFF, 0xC0, 0x3F, 0xF0, 0x06, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0xCC, 0x00, 0xC3, 0x00, 0x30, 0x13, 0x00, 0x18, 0xC0,
  0x06, 0x02, 0xC0, 0x01, 0x30, 0x00, 0x40, 0xD0, 0x00, 0x2C, 0x00, 0x08,
  0x1E, 0x00, 0x05, 0x00, 0x01, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x80, 0x00, 0x20, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x06, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x10,
  0x7F, 0xF0, 0x06, 0x1C, 0x07, 0x00, 0xCE, 0x00, 0x60, 0x13, 0x00, 0x06,
  0x02, 0x40, 0x00, 0xC0, 0xD8, 0x00, 0x18, 0x1E, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x30, 0x00, 0x06, 0x04,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x08, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x08, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x20, 0xFF, 0xC0, 0x00,
  0xC3, 0x80, 0xE0, 0x01, 0x8C, 0x00, 0xC0, 0x02, 0x30, 0x00, 0xC0, 0x04,
  0xC0, 0x01, 0x80, 0x1B, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x03, 0x00, 0x78,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x04, 0x01, 0xC0, 0x00, 0x08, 0x07, 0x00,
  0x00, 0x10, 0x0E, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x00, 0x50, 0x00, 0x06, 0x00, 0xA0, 0x00, 0x18, 0x03,
  0x60, 0x00, 0x60, 0x06, 0x60, 0x01, 0x80, 0x0C, 0xE0, 0x06, 0x00, 0x18,
  0xE0, 0x78, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x83,
  0x00, 0x70, 0x1C, 0x20, 0x1C, 0x00, 0x62, 0x03, 0x80, 0x03, 0x60, 0x30,
  0x00, 0x36, 0x06, 0x00, 0x01, 0x40, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x7C, 0x0C, 0x00,
  0x06, 0xC0, 0x60, 0x00, 0xC8, 0x06, 0x00, 0x18, 0x80, 0x30, 0x07, 0x18,
  0x01, 0xC1, 0xE1, 0x80, 0x0F, 0xF8, 0x18, 0x00, 0x1C, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xF8, 0x02, 0x0F, 0xF0, 0x18, 0xE0, 0x00, 0x67, 0x00, 0x01,
  0x38, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0x38, 0x1C, 0x00,
  0x10, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0xF0, 0x0E, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x40, 0x3F, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x04, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x3C, 0x0C,
  0x00, 0x0D, 0x01, 0x80, 0x03, 0x20, 0x30, 0x00, 0xC4, 0x03, 0x00, 0x31,
  0x80, 0x38, 0x1C, 0x30, 0x03, 0xFE, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x40, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x01, 0x80,
  0x20, 0x01, 0x80, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x10, 0x18, 0x00, 0x10, 0x30, 0x00, 0x10, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x04,
  0xC0, 0x01, 0xA0, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x0C, 0xC0, 0x03, 0x20,
  0x01, 0x8C, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x03, 0x0C, 0x00,
  0x42, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x04, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00, 0x43, 0x00, 0x10,
  0xC0, 0x04, 0x30, 0x01, 0x0C, 0x00, 0x46, 0x00, 0x11, 0x80, 0x04, 0x60,
  0x01, 0x18, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00,
  0x58, 0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01,
  0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x05, 0xC0, 0x70, 0x01, 0xE0, 0x03, 0x80, 0xE8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 46, 13, 2, -46 },
  { 70, 13, 16, 19, 7, -46 },
  { 96, 34, 46, 34, 1, -46 },
  { 292, 28, 53, 31, 2, -49 },
  { 478, 36, 48, 44, 5, -47 },
  { 694, 32, 48, 36, 2, -47 },
  { 886, 5, 16, 10, 7, -46 },
  { 896, 18, 56, 16, 2, -46 },
  { 1022, 18, 56, 16, -4, -46 },
  { 1148, 23, 23, 29, 8, -49 },
  { 1215, 27, 30, 33, 4, -38 },
  { 1317, 9, 15, 11, -3, -7 },
  { 1334, 15, 1, 19, 2, -18 },
  { 1336, 3, 4, 12, 2, -4 },
  { 1338, 28, 46, 20, -3, -46 },
  { 1499, 27, 48, 31, 3, -47 },
  { 1661, 13, 46, 31, 10, -46 },
  { 1736, 29, 47, 31, 0, -47 },
  { 1907, 30, 48, 31, 0, -47 },
  { 2087, 29, 47, 31, 0, -47 },
  { 2258, 29, 47, 31, 1, -46 },
  { 2429, 28, 48, 31, 3, -47 },
  { 2597, 26, 46, 31, 6, -46 },
  { 2747, 28, 48, 31, 2, -47 },
  { 2915, 28, 48, 31, 2, -47 },
  { 3083, 10, 35, 12, 1, -35 },
  { 3127, 14, 43, 12, -3, -35 },
  { 3203, 27, 28, 33, 4, -37 },
  { 3298, 27, 15, 33, 4, -30 },
  { 3349, 27, 28, 33, 4, -37 },
  { 3444, 20, 47, 22, 4, -47 },
  { 3562, 42, 52, 46, 3, -46 },
  { 3835, 31, 47, 30, -4, -47 },
  { 4018, 31, 46, 34, 2, -46 },
  { 4197, 32, 48, 33, 4, -47 },
  { 4389, 34, 46, 38, 2, -46 },
  { 4585, 30, 46, 30, 2, -46 },
  { 4758, 30, 46, 28, 2, -46 },
  { 4931, 35, 48, 39, 4, -47 },
  { 5141, 37, 46, 39, 2, -46 },
  { 5354, 20, 46, 15, -1, -46 },
  { 5469, 24, 57, 13, -10, -46 },
  { 5640, 34, 46, 31, 2, -46 },
  { 5836, 20, 46, 27, 2, -46 },
  { 5951, 45, 46, 47, 2, -46 },
  { 6210, 37, 46, 39, 2, -46 },
  { 6423, 34, 48, 40, 4, -47 },
  { 6627, 30, 46, 31, 2, -46 },
  { 6800, 34, 58, 40, 4, -47 },
  { 7047, 30, 46, 32, 2, -46 },
  { 7220, 30, 48, 29, 0, -47 },
  { 7400, 27, 46, 27, 6, -46 },
  { 7556, 35, 47, 39, 4, -46 },
  { 7762, 29, 46, 30, 6, -46 },
  { 7929, 46, 46, 48, 7, -46 },
  { 8194, 36, 46, 27, -4, -46 },
  { 8401, 27, 46, 27, 6, -46 },
  { 8557, 33, 46, 29, -1, -46 },
  { 8747, 24, 56, 19, -1, -46 },
  { 8915, 10, 46, 20, 6, -46 },
  { 8973, 24, 56, 19, -4, -46 },
  { 9141, 27, 27, 32, 3, -47 },
  { 9233, 21, 1, 22, -5, 7 },
  { 9236, 6, 11, 14, 10, -50 },
  { 9245, 27, 36, 32, 3, -35 },
  { 9367, 28, 50, 32, 1, -49 },
  { 9542, 23, 36, 25, 3, -35 },
  { 9646, 31, 50, 32, 3, -49 },
  { 9840, 23, 36, 28, 3, -35 },
  { 9944, 33, 66, 15, -9, -50 },
  { 10217, 30, 51, 32, 1, -35 },
  { 10409, 27, 49, 31, 1, -49 },
  { 10575, 12, 47, 12, 1, -47 },
  { 10646, 23, 63, 12, -9, -47 },
  { 10828, 27, 49, 25, 1, -49 },
  { 10994, 13, 49, 12, 1, -49 },
  { 11074, 43, 35, 48, 1, -35 },
  { 11263, 27, 35, 31, 1, -35 },
  { 11382, 26, 36, 32, 3, -35 },
  { 11499, 31, 50, 32, -2, -35 },
  { 11693, 28, 50, 32, 3, -35 },
  { 11868, 22, 35, 21, 1, -35 },
  { 11965, 23, 36, 24, 0, -35 },
  { 12069, 16, 44, 17, 2, -43 },
  { 12157, 27, 35, 31, 3, -34 },
  { 12276, 24, 34, 23, 3, -34 },
  { 12378, 36, 34, 38, 4, -34 },
  { 12531, 29, 34, 25, -2, -34 },
  { 12655, 34, 50, 24, -7, -34 },
  { 12868, 25, 34, 23, -1, -34 },
  { 12975, 23, 56, 21, 2, -46 },
  { 13136, 2, 65, 30, 15, -49 },
  { 13153, 23, 56, 21, -4, -46 },
  { 13314, 27, 6, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC65PT7B_H_
