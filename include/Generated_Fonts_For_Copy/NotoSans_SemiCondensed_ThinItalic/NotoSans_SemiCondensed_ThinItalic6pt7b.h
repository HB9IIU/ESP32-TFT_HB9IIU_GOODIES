#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0x80, 0x6B, 0xE0, 0x5D, 0x2C, 0xFD, 0x77, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0xF8, 0xB4, 0x5D, 0x00, 0xC0, 0xC0, 0x00, 0x5A, 0xF6, 0xE0,
  0xF0, 0x65, 0x60, 0x6C, 0xF0, 0x2A, 0xA0, 0xE8, 0xF0, 0x6A, 0xF0, 0xEA,
  0xEA, 0xF0, 0xF5, 0xE0, 0x00, 0x30, 0xEC, 0xFC, 0xF8, 0x5A, 0x7F, 0xBC,
  0x60, 0x5F, 0x7E, 0xF0, 0x72, 0x60, 0x76, 0xF0, 0x7A, 0x60, 0x7A, 0x40,
  0x7A, 0x9E, 0x5D, 0xAA, 0x6A, 0x55, 0xC0, 0x6B, 0x50, 0x6B, 0x55, 0xFD,
  0x5D, 0xAA, 0x79, 0x9E, 0x77, 0x40, 0x79, 0x9E, 0x20, 0x77, 0x50, 0xF8,
  0xE0, 0xEA, 0x99, 0xAE, 0xEA, 0xDE, 0xAC, 0xAB, 0x60, 0xEA, 0x6A, 0x60,
  0xEA, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xC0, 0x80, 0xF7, 0x00, 0x5A, 0xDE,
  0xEC, 0x2E, 0xDC, 0xEC, 0x25, 0x25, 0x80, 0xF7, 0x60, 0x5A, 0xDA, 0x70,
  0x15, 0xC0, 0x57, 0x4C, 0xF8, 0xFB, 0xD0, 0xF6, 0x80, 0xF7, 0x80, 0xF7,
  0xC0, 0xF7, 0x20, 0xE8, 0xDC, 0xEA, 0xB7, 0x00, 0xF8, 0xDA, 0xA0, 0xDC,
  0x52, 0x4C, 0x6C, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 1, 0, -4 },
  { 14, 1, 5, 1, 0, -4 },
  { 15, 2, 3, 3, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 2, 4, 3, 1, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 1, 3, 1, 0, -3 },
  { 41, 1, 4, 1, 0, -3 },
  { 42, 3, 2, 3, 0, -3 },
  { 43, 3, 2, 3, 0, -3 },
  { 44, 3, 2, 3, 0, -3 },
  { 45, 2, 4, 2, 0, -4 },
  { 46, 4, 5, 4, 0, -4 },
  { 49, 2, 4, 3, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 2, 4, 1, 0, -4 },
  { 65, 2, 5, 1, -1, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 2, 4, 3, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 4, 5, 4, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 2, 4, 2, 1, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 2, 4, 3, 1, -4 },
  { 89, 4, 4, 4, 1, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 2, 4, 2, 1, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 2, 5, 2, 0, -4 },
  { 98, 1, 4, 2, 1, -4 },
  { 99, 2, 5, 2, 0, -4 },
  { 101, 3, 2, 3, 0, -4 },
  { 102, 2, 1, 2, 0, 0 },
  { 103, 1, 1, 1, 1, -5 },
  { 104, 3, 3, 3, 0, -3 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 2, 3, 2, 0, -3 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 2, 3, 3, 0, -3 },
  { 112, 3, 6, 1, -1, -5 },
  { 115, 3, 4, 3, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 1, 4, 1, 0, -4 },
  { 120, 2, 5, 1, -1, -4 },
  { 122, 3, 5, 2, 0, -5 },
  { 124, 1, 5, 1, 0, -5 },
  { 125, 4, 3, 4, 0, -3 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 3, 4, 3, 0, -3 },
  { 133, 3, 4, 3, 0, -3 },
  { 135, 2, 3, 2, 0, -3 },
  { 136, 2, 3, 2, 0, -3 },
  { 137, 2, 4, 2, 0, -4 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 2, 3, 2, 0, -3 },
  { 141, 4, 3, 3, 0, -3 },
  { 143, 2, 3, 2, 0, -3 },
  { 144, 4, 4, 2, -1, -3 },
  { 146, 2, 3, 2, 0, -3 },
  { 147, 2, 5, 2, 0, -4 },
  { 149, 1, 6, 3, 1, -5 },
  { 150, 2, 5, 2, 0, -4 },
  { 152, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC6PT7B_H_
