#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x21, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x46, 0x89, 0x14, 0x28, 0x51,
  0x22, 0x44, 0x88, 0x00, 0x83, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40,
  0x10, 0x40, 0x08, 0x20, 0x08, 0x10, 0x7F, 0xFF, 0x02, 0x08, 0x01, 0x04,
  0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x81, 0xFF,
  0xFC, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x02, 0x04, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x81, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x0F, 0xC0, 0x64, 0x61, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x42, 0x00, 0x44, 0x00, 0x50, 0x00, 0x60, 0x00, 0x70, 0x00, 0xB0,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x86, 0x01,
  0x18, 0x7B, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x01, 0x30, 0x08, 0x42, 0x02, 0x10, 0x40, 0x82, 0x08, 0x10, 0x81,
  0x04, 0x10, 0x21, 0x82, 0x04, 0x20, 0x40, 0x88, 0x08, 0x11, 0x02, 0x04,
  0x47, 0x40, 0x93, 0x18, 0x22, 0x42, 0x84, 0x90, 0x51, 0x22, 0x09, 0xC4,
  0x81, 0x01, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40, 0x82, 0x08, 0x20, 0x82,
  0x04, 0x10, 0x40, 0x84, 0x08, 0x21, 0x00, 0x84, 0x60, 0x1F, 0x00, 0x00,
  0x60, 0x00, 0xCC, 0x00, 0x82, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x20, 0x08, 0x10, 0x04, 0x10, 0x02, 0x10, 0x00, 0xB0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x44, 0x00, 0xC2, 0x06, 0x40, 0x82, 0x40, 0x41, 0x40,
  0x11, 0x20, 0x09, 0x10, 0x02, 0x88, 0x01, 0x84, 0x00, 0xC2, 0x00, 0xA0,
  0x80, 0x88, 0x3F, 0x82, 0x00, 0x56, 0xAA, 0x80, 0x00, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x0C,
  0x0C, 0x00, 0x01, 0x00, 0x20, 0x02, 0x08, 0x20, 0x62, 0x01, 0xA1, 0x07,
  0xE0, 0xA0, 0x12, 0x02, 0x10, 0x41, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x11, 0x22, 0x44, 0x88, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x08, 0xC0, 0xC0, 0x82, 0x02,
  0x10, 0x08, 0x40, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x08, 0x10, 0x40, 0x3E,
  0x00, 0x06, 0x14, 0xCA, 0x18, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x00, 0x30,
  0x07, 0x18, 0x10, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x03,
  0x8C, 0x0C, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x80, 0x60, 0x7F, 0xC0, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x42, 0x01, 0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x82,
  0x02, 0x08, 0x04, 0x30, 0x08, 0x40, 0x11, 0xFF, 0xFC, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x03, 0xFF, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x09, 0x00, 0x1E, 0xE0, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x80, 0x60, 0x7F, 0x80, 0x00, 0x18, 0x07, 0x10,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x7C, 0x16, 0x18, 0xA0, 0x13, 0x00, 0x4C, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x04,
  0x10, 0x20, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00, 0xE0,
  0x06, 0x30, 0x10, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x84,
  0x02, 0x08, 0x04, 0x10, 0x10, 0x10, 0xC0, 0x12, 0x00, 0x38, 0x01, 0x88,
  0x0C, 0x08, 0x30, 0x08, 0x40, 0x11, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x02, 0x20, 0x0C, 0x20, 0x30, 0x3F, 0x80, 0x00, 0xE0, 0x0C,
  0x40, 0x40, 0x82, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x40, 0x50, 0x86, 0x81,
  0xA2, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0xFE, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x84, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x10, 0x10, 0x20,
  0x20, 0x40, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x0E,
  0x06, 0x30, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0x80, 0x60, 0x04, 0x00, 0x60, 0x10, 0x00, 0x40, 0x40, 0x00,
  0x41, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x0F, 0xC1, 0x20, 0x60, 0x82,
  0x41, 0x82, 0x04, 0x82, 0x04, 0x12, 0x08, 0x08, 0x24, 0x10, 0x10, 0x48,
  0x40, 0x40, 0x90, 0x80, 0x81, 0x21, 0x01, 0x04, 0x82, 0x06, 0x09, 0x04,
  0x0C, 0x21, 0x0C, 0x28, 0x82, 0x0F, 0x9E, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x14,
  0x00, 0x24, 0x00, 0x24, 0x00, 0x44, 0x00, 0x44, 0x00, 0x82, 0x00, 0x82,
  0x01, 0x02, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x07, 0xFE, 0x08, 0x02,
  0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x80, 0x01, 0x07, 0xFC, 0x04, 0x02, 0x04, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x18, 0x1F, 0xF0, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10,
  0x80, 0x60, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x71, 0xC0, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x01, 0x01, 0x80, 0x40, 0x10, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01,
  0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x08, 0x10, 0x0C, 0x08,
  0x0C, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x38, 0xF0, 0x30, 0x04, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x0F, 0xC8,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x82, 0x00, 0x40, 0x40, 0x10, 0x0F, 0xF8,
  0x00, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x20, 0x80,
  0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x10, 0x00, 0x82, 0x00,
  0x10, 0x40, 0x02, 0x0F, 0xFF, 0xC2, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00,
  0x41, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01,
  0x04, 0x00, 0x20, 0x80, 0x04, 0x20, 0x01, 0x04, 0x00, 0x20, 0x07, 0xE0,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x07, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x0F, 0x00, 0x04, 0x00, 0xC1, 0x00, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x02, 0x04, 0x00, 0x82, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x04, 0x40, 0x01, 0x30, 0x00, 0x54, 0x00, 0x29, 0x00, 0x0C, 0x20, 0x02,
  0x08, 0x00, 0x81, 0x00, 0x20, 0x40, 0x10, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x07, 0xFF, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x0A, 0x00, 0x0A, 0x0A, 0x00, 0x0A, 0x0A, 0x00,
  0x12, 0x09, 0x00, 0x14, 0x09, 0x00, 0x24, 0x11, 0x00, 0x44, 0x11, 0x00,
  0x44, 0x11, 0x00, 0x88, 0x11, 0x00, 0x88, 0x21, 0x01, 0x08, 0x21, 0x01,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x10, 0x20, 0x84, 0x10, 0x40, 0x88,
  0x10, 0x40, 0x88, 0x10, 0x40, 0x90, 0x10, 0x40, 0x90, 0x20, 0x40, 0xA0,
  0x20, 0x80, 0x60, 0x20, 0x80, 0x40, 0x20, 0x04, 0x00, 0x20, 0xC0, 0x04,
  0x18, 0x00, 0x85, 0x00, 0x10, 0x90, 0x04, 0x12, 0x00, 0x82, 0x40, 0x10,
  0x44, 0x02, 0x10, 0x80, 0x42, 0x10, 0x10, 0x41, 0x02, 0x08, 0x20, 0x42,
  0x04, 0x08, 0x40, 0x42, 0x08, 0x08, 0x41, 0x01, 0x08, 0x20, 0x11, 0x08,
  0x02, 0x21, 0x00, 0x48, 0x20, 0x05, 0x04, 0x00, 0xA0, 0x80, 0x14, 0x20,
  0x01, 0x84, 0x00, 0x20, 0x00, 0x78, 0x00, 0x61, 0x80, 0x60, 0x10, 0x10,
  0x02, 0x08, 0x00, 0x84, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x01, 0x02, 0x00, 0x80, 0xC0, 0x40, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x04, 0x04, 0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10,
  0x08, 0x20, 0x70, 0x3F, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x61, 0x80, 0x60, 0x10, 0x10, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x40, 0x02,
  0x10, 0x01, 0x02, 0x00, 0x80, 0xC0, 0x40, 0x0F, 0xE0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x07,
  0xF8, 0x04, 0x04, 0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x18, 0x1F,
  0xE0, 0x20, 0x80, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x40, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0x80, 0x18, 0x00,
  0x28, 0x03, 0x87, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x80, 0x60, 0x7F,
  0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x08, 0x00, 0x42, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x42, 0x00, 0x10, 0x40, 0x08, 0x10, 0x06, 0x02, 0x03, 0x00, 0x7F,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x01, 0x02, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x80, 0x10,
  0x03, 0x80, 0x30, 0x02, 0x80, 0x30, 0x04, 0x80, 0x30, 0x04, 0x80, 0x50,
  0x08, 0x80, 0x50, 0x08, 0x80, 0x90, 0x08, 0x80, 0x90, 0x10, 0x81, 0x10,
  0x10, 0x81, 0x10, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x40, 0x84, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88, 0x09,
  0x00, 0x90, 0x09, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x0A,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x02, 0x00,
  0x60, 0x40, 0x18, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x01, 0x04,
  0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x0A, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x10, 0x80,
  0x06, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x10, 0x01, 0x04, 0x00, 0x20, 0x80, 0x06, 0x00, 0x24, 0x01,
  0x10, 0x04, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08, 0x20, 0x21, 0x00, 0x84,
  0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFC, 0x00, 0x82, 0x10, 0x84, 0x21, 0x04, 0x21, 0x08, 0x42, 0x08,
  0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0xFC, 0x00, 0x00, 0x40, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x21, 0x00,
  0xC2, 0x01, 0x04, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x11, 0x00,
  0x2C, 0x00, 0x60, 0xFF, 0xF0, 0x84, 0x42, 0x30, 0x03, 0xE2, 0x08, 0x28,
  0x20, 0x30, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x06, 0x10, 0x14,
  0x20, 0x30, 0x60, 0xA0, 0x7E, 0x40, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x11, 0xF0, 0x48, 0x21,
  0x40, 0x46, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x05,
  0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x2C, 0x01, 0x28, 0x08,
  0xA0, 0x42, 0x7E, 0x00, 0x07, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x03, 0xF2, 0x02, 0x0D, 0x02, 0x02, 0x82, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x10,
  0x03, 0x08, 0x01, 0x04, 0x01, 0x81, 0x00, 0xC0, 0x80, 0xA0, 0x60, 0x90,
  0x1F, 0x90, 0x00, 0x07, 0xE0, 0x82, 0x10, 0x12, 0x01, 0x40, 0x14, 0x02,
  0x80, 0x68, 0x08, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x43, 0xF8, 0x00, 0x0F, 0x80, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03,
  0xF8, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF9, 0x02, 0x0D, 0x04,
  0x05, 0x08, 0x06, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x20,
  0x18, 0x20, 0x28, 0x30, 0x48, 0x1F, 0x90, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x80, 0x80, 0x7F, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x11, 0xF0, 0x48, 0x21, 0x40, 0x46, 0x01, 0x10, 0x04, 0xC0, 0x12,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x80, 0x0C, 0x30, 0x00,
  0x00, 0x01, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x0F, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x08, 0x80, 0x84, 0x08, 0x20, 0x81, 0x08,
  0x10, 0x80, 0x88, 0x04, 0x80, 0x2A, 0x02, 0x90, 0x18, 0x80, 0x82, 0x04,
  0x10, 0x20, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x00, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x00, 0x11, 0xF0, 0xF8, 0x58, 0x4C, 0x11,
  0x80, 0xA0, 0x46, 0x03, 0x01, 0x10, 0x08, 0x04, 0xC0, 0x20, 0x12, 0x00,
  0x80, 0x48, 0x04, 0x01, 0x20, 0x10, 0x08, 0x80, 0x40, 0x24, 0x01, 0x00,
  0x90, 0x08, 0x02, 0x40, 0x20, 0x09, 0x00, 0x80, 0x48, 0x02, 0x01, 0x20,
  0x08, 0x04, 0x80, 0x40, 0x12, 0x01, 0x00, 0x40, 0x11, 0xF0, 0x58, 0x21,
  0x40, 0x46, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x88, 0x02, 0x20, 0x09,
  0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x08,
  0x80, 0x22, 0x00, 0x80, 0x07, 0xE0, 0x40, 0x84, 0x04, 0x40, 0x14, 0x00,
  0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28,
  0x01, 0x40, 0x12, 0x00, 0x90, 0x08, 0x40, 0x81, 0xF8, 0x00, 0x04, 0x7C,
  0x04, 0x82, 0x05, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x30, 0x04, 0x28, 0x08, 0x28, 0x10, 0x27, 0xE0, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x03, 0xF2, 0x08, 0x34, 0x20, 0x28, 0x80, 0x62, 0x00, 0x44,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00,
  0xC8, 0x01, 0x10, 0x06, 0x10, 0x0C, 0x20, 0x28, 0x60, 0x90, 0x7E, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x11, 0xE2, 0xC0, 0x50, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x07, 0xF1, 0x81, 0x10, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x80, 0x87, 0xF0, 0x08, 0x04, 0x02, 0x02, 0x07,
  0xF8, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x03, 0xC0, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x09,
  0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0xC8, 0x06, 0x10, 0x18,
  0x40, 0xA0, 0xFC, 0x80, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x08, 0x81, 0x88, 0x10, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04,
  0x80, 0x50, 0x05, 0x00, 0x60, 0x02, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A,
  0x03, 0x01, 0x40, 0xA0, 0x48, 0x14, 0x09, 0x04, 0x81, 0x20, 0x90, 0x44,
  0x12, 0x08, 0x84, 0x22, 0x10, 0x84, 0x42, 0x20, 0x90, 0x44, 0x12, 0x09,
  0x02, 0x41, 0x20, 0x50, 0x28, 0x0A, 0x05, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x00, 0x08, 0x02, 0x10, 0x08, 0x10, 0x20, 0x20, 0x80, 0x43, 0x00,
  0x44, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x24,
  0x00, 0x84, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x10, 0x40, 0x21, 0x00, 0x60,
  0x02, 0x00, 0x40, 0x80, 0x20, 0x20, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0xE0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0xF0, 0x00, 0x7E, 0x06, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 24, 7, 1, -24 },
  { 19, 7, 9, 10, 4, -24 },
  { 27, 17, 24, 18, 1, -24 },
  { 78, 15, 28, 16, 1, -26 },
  { 131, 19, 25, 23, 2, -25 },
  { 191, 17, 25, 19, 1, -25 },
  { 245, 2, 9, 5, 4, -24 },
  { 248, 9, 29, 8, 1, -24 },
  { 281, 9, 29, 8, -2, -24 },
  { 314, 12, 13, 15, 4, -26 },
  { 334, 14, 16, 17, 2, -20 },
  { 362, 4, 8, 6, -1, -4 },
  { 366, 8, 1, 10, 1, -10 },
  { 367, 2, 2, 6, 1, -2 },
  { 368, 15, 24, 10, -2, -24 },
  { 413, 14, 25, 16, 2, -25 },
  { 457, 7, 24, 16, 5, -24 },
  { 478, 15, 25, 16, 0, -25 },
  { 525, 16, 25, 16, 0, -25 },
  { 575, 15, 24, 16, 0, -24 },
  { 620, 16, 24, 16, 0, -24 },
  { 668, 14, 25, 16, 2, -25 },
  { 712, 14, 24, 16, 3, -24 },
  { 754, 15, 25, 16, 1, -25 },
  { 801, 14, 25, 16, 1, -25 },
  { 845, 5, 18, 6, 1, -18 },
  { 857, 8, 22, 6, -2, -18 },
  { 879, 14, 15, 17, 2, -20 },
  { 906, 14, 8, 17, 2, -16 },
  { 920, 14, 15, 17, 2, -20 },
  { 947, 11, 25, 12, 2, -25 },
  { 982, 23, 27, 24, 1, -24 },
  { 1060, 16, 24, 16, -2, -24 },
  { 1108, 16, 24, 18, 1, -24 },
  { 1156, 17, 25, 17, 2, -25 },
  { 1210, 18, 24, 20, 1, -24 },
  { 1264, 16, 24, 16, 1, -24 },
  { 1312, 16, 24, 14, 1, -24 },
  { 1360, 18, 25, 21, 2, -25 },
  { 1417, 19, 24, 20, 1, -24 },
  { 1474, 11, 24, 8, -1, -24 },
  { 1507, 12, 30, 7, -5, -24 },
  { 1552, 18, 24, 16, 1, -24 },
  { 1606, 11, 24, 14, 1, -24 },
  { 1639, 24, 24, 25, 1, -24 },
  { 1711, 19, 24, 20, 1, -24 },
  { 1768, 18, 25, 21, 2, -25 },
  { 1825, 16, 24, 16, 1, -24 },
  { 1873, 18, 31, 21, 2, -25 },
  { 1943, 16, 24, 17, 1, -24 },
  { 1991, 16, 25, 15, 0, -25 },
  { 2041, 14, 24, 14, 3, -24 },
  { 2083, 18, 24, 20, 2, -24 },
  { 2137, 15, 24, 16, 3, -24 },
  { 2182, 24, 24, 25, 4, -24 },
  { 2254, 19, 24, 14, -2, -24 },
  { 2311, 14, 24, 14, 3, -24 },
  { 2353, 18, 24, 15, -1, -24 },
  { 2407, 12, 29, 10, 0, -24 },
  { 2451, 5, 24, 11, 3, -24 },
  { 2466, 12, 29, 10, -2, -24 },
  { 2510, 15, 13, 17, 1, -24 },
  { 2535, 12, 1, 11, -3, 3 },
  { 2537, 4, 5, 7, 5, -26 },
  { 2540, 15, 18, 16, 1, -18 },
  { 2574, 14, 26, 17, 1, -26 },
  { 2620, 12, 18, 13, 2, -18 },
  { 2647, 17, 26, 17, 1, -26 },
  { 2703, 12, 18, 15, 2, -18 },
  { 2730, 17, 34, 8, -4, -26 },
  { 2803, 16, 26, 17, 0, -18 },
  { 2855, 14, 26, 16, 1, -26 },
  { 2901, 6, 24, 6, 1, -24 },
  { 2919, 12, 32, 6, -5, -24 },
  { 2967, 13, 26, 13, 1, -26 },
  { 3010, 6, 26, 6, 1, -26 },
  { 3030, 22, 18, 25, 1, -18 },
  { 3080, 14, 18, 16, 1, -18 },
  { 3112, 13, 18, 17, 2, -18 },
  { 3142, 16, 26, 17, -1, -18 },
  { 3194, 15, 26, 17, 1, -18 },
  { 3243, 11, 18, 11, 1, -18 },
  { 3268, 12, 18, 13, 0, -18 },
  { 3295, 9, 22, 9, 1, -22 },
  { 3320, 14, 18, 16, 1, -18 },
  { 3352, 12, 18, 12, 2, -18 },
  { 3379, 19, 18, 20, 2, -18 },
  { 3422, 15, 18, 13, -1, -18 },
  { 3456, 18, 26, 12, -4, -18 },
  { 3515, 14, 18, 12, -1, -18 },
  { 3547, 12, 29, 11, 1, -24 },
  { 3591, 1, 34, 16, 8, -26 },
  { 3596, 12, 29, 11, -2, -24 },
  { 3640, 14, 2, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC34PT7B_H_
