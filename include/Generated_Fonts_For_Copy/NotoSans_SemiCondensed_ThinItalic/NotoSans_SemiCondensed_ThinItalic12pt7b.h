#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0xE0, 0x14, 0x52, 0x5E, 0x28, 0xAD,
  0x54, 0x50, 0x10, 0xF5, 0x14, 0x30, 0xA2, 0x8A, 0xF1, 0x00, 0x66, 0x9A,
  0xAC, 0xBF, 0xD3, 0x55, 0x9C, 0x18, 0x92, 0x8E, 0x21, 0x58, 0xE2, 0xF4,
  0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24,
  0x80, 0x27, 0x4D, 0xA0, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0, 0x80, 0x04,
  0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x32, 0x63, 0x18, 0xCA, 0x52, 0xE0,
  0x75, 0x5A, 0x80, 0x30, 0x42, 0x10, 0x88, 0x88, 0xF0, 0x38, 0x10, 0x42,
  0x30, 0x20, 0x82, 0xF0, 0x08, 0x46, 0x54, 0xA7, 0xE2, 0x10, 0x3C, 0x84,
  0x10, 0x38, 0x20, 0x82, 0xF0, 0x3A, 0x21, 0x4D, 0x4A, 0x52, 0xE0, 0xF8,
  0x44, 0x22, 0x11, 0x08, 0x80, 0x39, 0x14, 0x4A, 0x31, 0x28, 0xA2, 0x70,
  0x32, 0x52, 0x94, 0x9C, 0x22, 0xE0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x1B,
  0x20, 0x83, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00, 0xE4, 0x95, 0x20,
  0x80, 0x1C, 0xC6, 0x0D, 0xFA, 0xB9, 0x72, 0xDA, 0x80, 0xF0, 0x08, 0x21,
  0x45, 0x24, 0xF4, 0x51, 0x84, 0x38, 0x94, 0x51, 0x79, 0x14, 0x62, 0xF0,
  0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x38, 0x49, 0x0A, 0x14, 0x28,
  0x51, 0x44, 0xF0, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x20, 0xF0, 0x3C, 0x84,
  0x10, 0x79, 0x04, 0x20, 0x80, 0x3D, 0x08, 0x20, 0x9A, 0x18, 0xA2, 0xF8,
  0x22, 0x45, 0x0A, 0x17, 0xC8, 0x91, 0x42, 0x84, 0x24, 0xA4, 0x92, 0xC0,
  0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x30, 0x22, 0x49, 0x22, 0x86, 0x0A,
  0x14, 0x44, 0x88, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x20, 0x90, 0x58, 0x4C,
  0x65, 0x32, 0xA9, 0x55, 0x32, 0x92, 0x00, 0x22, 0x45, 0x4A, 0x95, 0x29,
  0x93, 0x42, 0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0xF0, 0x38, 0x94,
  0x51, 0x49, 0xC4, 0x20, 0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0xD0,
  0x81, 0x00, 0x38, 0x94, 0x51, 0x49, 0xC5, 0x22, 0x88, 0x3A, 0x10, 0x82,
  0x08, 0x21, 0xF0, 0xF9, 0x08, 0x84, 0x21, 0x08, 0x80, 0x45, 0x18, 0x61,
  0x86, 0x28, 0xA2, 0xF0, 0x8C, 0x63, 0x29, 0x52, 0x98, 0x80, 0x88, 0xC4,
  0x66, 0x53, 0x2A, 0xA5, 0x53, 0x31, 0x88, 0x88, 0x00, 0x22, 0x48, 0x50,
  0xC1, 0x02, 0x0A, 0x24, 0x88, 0x8C, 0x65, 0x44, 0x21, 0x08, 0x80, 0x3C,
  0x10, 0x84, 0x20, 0x84, 0x20, 0xF0, 0x32, 0x44, 0x44, 0x88, 0x88, 0xC0,
  0xAA, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x44, 0x21, 0x38, 0x10, 0x42,
  0x92, 0xC4, 0xF0, 0xC0, 0xFC, 0xA5, 0x29, 0x70, 0x21, 0x14, 0xD4, 0xA6,
  0x31, 0xF0, 0xF8, 0x88, 0x8E, 0x08, 0x5B, 0x28, 0xCA, 0x52, 0xE0, 0xF9,
  0xE8, 0x8E, 0x0C, 0x21, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x30, 0x7D,
  0x18, 0xA2, 0x89, 0xC0, 0x84, 0xE0, 0x21, 0x14, 0xD4, 0xA6, 0x31, 0x88,
  0x41, 0x5A, 0x80, 0x08, 0x00, 0x21, 0x08, 0x84, 0x21, 0x09, 0x80, 0x21,
  0x10, 0x95, 0x31, 0x92, 0x90, 0x25, 0x24, 0xA4, 0x80, 0x7F, 0x49, 0x49,
  0x89, 0x89, 0x91, 0x7A, 0x53, 0x18, 0xC4, 0xF9, 0x99, 0x9E, 0x7A, 0x53,
  0x18, 0xFA, 0x10, 0x80, 0xFC, 0x65, 0x29, 0x70, 0x44, 0x20, 0x74, 0x48,
  0x88, 0x74, 0x61, 0x1E, 0x4D, 0x25, 0x26, 0x99, 0x99, 0x9E, 0x9A, 0xAC,
  0x88, 0xA6, 0x9D, 0xA6, 0x92, 0x40, 0x4A, 0x88, 0xCA, 0x48, 0x44, 0xA2,
  0x8C, 0x20, 0x82, 0x10, 0x80, 0x71, 0x24, 0x8E, 0x19, 0x08, 0x42, 0x61,
  0x08, 0x44, 0x10, 0xFF, 0xF0, 0x20, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 2, 0, -9 },
  { 5, 3, 4, 3, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 10, 6, 0, -9 },
  { 22, 6, 9, 8, 1, -9 },
  { 29, 6, 9, 7, 0, -9 },
  { 36, 1, 4, 2, 1, -9 },
  { 37, 4, 11, 3, 0, -9 },
  { 43, 4, 11, 3, -1, -9 },
  { 49, 5, 4, 5, 1, -9 },
  { 52, 5, 6, 6, 1, -7 },
  { 56, 2, 3, 2, -1, -1 },
  { 57, 3, 1, 4, 0, -4 },
  { 58, 1, 1, 2, 0, -1 },
  { 59, 6, 9, 4, -1, -9 },
  { 66, 5, 9, 6, 1, -9 },
  { 72, 2, 9, 6, 2, -9 },
  { 75, 5, 9, 6, 0, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 5, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 5, 9, 6, 1, -9 },
  { 107, 5, 9, 6, 1, -9 },
  { 113, 6, 9, 6, 0, -9 },
  { 120, 5, 9, 6, 0, -9 },
  { 126, 2, 6, 2, 0, -6 },
  { 128, 3, 8, 2, -1, -6 },
  { 131, 5, 5, 6, 1, -7 },
  { 135, 5, 3, 6, 1, -6 },
  { 137, 5, 5, 6, 1, -7 },
  { 141, 3, 9, 4, 1, -9 },
  { 145, 7, 10, 9, 1, -9 },
  { 154, 6, 9, 6, -1, -9 },
  { 161, 6, 9, 6, 0, -9 },
  { 168, 6, 9, 6, 1, -9 },
  { 175, 7, 9, 7, 0, -9 },
  { 183, 6, 9, 6, 0, -9 },
  { 190, 6, 9, 5, 0, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 3, 9, 3, 0, -9 },
  { 216, 5, 11, 2, -2, -9 },
  { 223, 7, 9, 6, 0, -9 },
  { 231, 4, 9, 5, 0, -9 },
  { 236, 9, 9, 9, 0, -9 },
  { 247, 7, 9, 7, 0, -9 },
  { 255, 6, 9, 7, 1, -9 },
  { 262, 6, 9, 6, 0, -9 },
  { 269, 6, 11, 7, 1, -9 },
  { 278, 6, 9, 6, 0, -9 },
  { 285, 5, 9, 5, 0, -9 },
  { 291, 5, 9, 5, 1, -9 },
  { 297, 6, 9, 7, 1, -9 },
  { 304, 5, 9, 6, 1, -9 },
  { 310, 9, 9, 9, 1, -9 },
  { 321, 7, 9, 5, -1, -9 },
  { 329, 5, 9, 5, 1, -9 },
  { 335, 6, 9, 5, 0, -9 },
  { 342, 4, 11, 4, 0, -9 },
  { 348, 2, 9, 4, 1, -9 },
  { 351, 5, 11, 4, -1, -9 },
  { 358, 6, 5, 6, 0, -9 },
  { 362, 4, 1, 4, -1, 1 },
  { 363, 1, 2, 3, 2, -9 },
  { 364, 5, 6, 6, 1, -6 },
  { 368, 5, 9, 6, 0, -9 },
  { 374, 4, 6, 5, 1, -6 },
  { 377, 5, 9, 6, 1, -9 },
  { 383, 4, 6, 5, 1, -6 },
  { 386, 6, 12, 3, -2, -9 },
  { 395, 6, 9, 6, 0, -6 },
  { 402, 5, 9, 6, 0, -9 },
  { 408, 2, 9, 2, 0, -9 },
  { 411, 5, 12, 2, -2, -9 },
  { 419, 5, 9, 5, 0, -9 },
  { 425, 3, 9, 2, 0, -9 },
  { 429, 8, 6, 9, 0, -6 },
  { 435, 5, 6, 6, 0, -6 },
  { 439, 4, 6, 6, 1, -6 },
  { 442, 5, 9, 6, 0, -6 },
  { 448, 5, 9, 6, 1, -6 },
  { 454, 4, 6, 4, 0, -6 },
  { 457, 4, 6, 4, 0, -6 },
  { 460, 3, 8, 3, 0, -8 },
  { 463, 4, 6, 6, 1, -6 },
  { 466, 4, 6, 4, 1, -6 },
  { 469, 6, 6, 7, 1, -6 },
  { 474, 5, 6, 5, 0, -6 },
  { 478, 6, 9, 4, -1, -6 },
  { 485, 4, 6, 4, 0, -6 },
  { 488, 5, 11, 4, 0, -9 },
  { 495, 1, 12, 6, 2, -9 },
  { 497, 5, 11, 4, -1, -9 },
  { 504, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC12PT7B_H_
