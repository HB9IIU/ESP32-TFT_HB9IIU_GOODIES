#ifndef _NOTOSANS_SEMICONDENSED_THINITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THINITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x21, 0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84,
  0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x40,
  0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x01, 0x03, 0xFF,
  0xFF, 0x01, 0x02, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02,
  0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0xFF, 0xFF, 0x80,
  0x81, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00,
  0x10, 0x20, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x10, 0x84, 0x10,
  0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x84, 0x00, 0x22, 0x00, 0x09, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x58,
  0x00, 0x22, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x02,
  0x08, 0x01, 0x0C, 0x01, 0x04, 0x20, 0x8C, 0x0F, 0xF8, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x10, 0x84, 0x01, 0x0C,
  0x10, 0x08, 0x40, 0x80, 0x84, 0x04, 0x08, 0x20, 0x20, 0x41, 0x01, 0x04,
  0x10, 0x08, 0x40, 0x80, 0x82, 0x04, 0x04, 0x20, 0x20, 0x23, 0x01, 0x01,
  0x11, 0xE8, 0x11, 0x11, 0xC0, 0x99, 0x06, 0x08, 0x98, 0x38, 0xC8, 0x81,
  0x78, 0xC4, 0x08, 0x04, 0x40, 0x40, 0x42, 0x02, 0x02, 0x10, 0x10, 0x20,
  0x80, 0x82, 0x08, 0x0C, 0x10, 0x40, 0x41, 0x02, 0x02, 0x10, 0x10, 0x20,
  0x80, 0xC1, 0x08, 0x02, 0x10, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x30,
  0x40, 0x04, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0xC0, 0x10, 0x10, 0x02, 0x06, 0x00, 0x41, 0x80, 0x0C, 0x60, 0x00, 0x90,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x10, 0x00, 0x42, 0x00, 0x30, 0x20,
  0x24, 0x04, 0x09, 0x00, 0x41, 0x60, 0x0C, 0x48, 0x00, 0x89, 0x00, 0x0A,
  0x20, 0x01, 0x84, 0x00, 0x30, 0x80, 0x0E, 0x08, 0x03, 0x21, 0x80, 0x84,
  0x1F, 0xE0, 0x40, 0x24, 0xA4, 0x92, 0x90, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x0C,
  0x10, 0x31, 0x00, 0x68, 0x20, 0xFE, 0x06, 0x00, 0x48, 0x04, 0x40, 0xC1,
  0x0C, 0x08, 0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x08, 0x44, 0x23, 0x10, 0x88, 0xC0,
  0xFF, 0x80, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x04, 0x04, 0x02, 0x0C, 0x02, 0x08,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x10, 0x80, 0x20, 0x40, 0x60, 0x60, 0xC0, 0x3F, 0x00, 0x01,
  0x07, 0x09, 0x32, 0x62, 0x82, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x00, 0xFE, 0x01, 0x80, 0x80, 0x80, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xC0, 0x60, 0x60, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x08, 0x03, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x10, 0x00, 0x84,
  0x00, 0x61, 0x00, 0x10, 0xC0, 0x08, 0x20, 0x04, 0x08, 0x02, 0x02, 0x01,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x04, 0x08, 0x01, 0x06, 0x00,
  0x41, 0x00, 0x20, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x81,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x30, 0x01, 0xE7,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x20, 0x18, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x7C, 0x04, 0xC1,
  0x82, 0x80, 0x61, 0x80, 0x11, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x03, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x10, 0x20, 0x18, 0x08, 0x18, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x81, 0x80, 0x40,
  0x80, 0x10, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x02, 0x01, 0x81, 0x81, 0x80, 0x41, 0x80, 0x1B, 0x00, 0x0E, 0x00, 0x18,
  0x80, 0x10, 0x30, 0x30, 0x08, 0x30, 0x02, 0x10, 0x01, 0x10, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x20, 0x04,
  0x08, 0x0C, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0x83, 0x01, 0x80, 0xC1,
  0x80, 0x20, 0x80, 0x10, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x30, 0x00,
  0x98, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x10, 0x80, 0x18, 0x40,
  0x14, 0x10, 0x34, 0x07, 0xE2, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x1F, 0xE0, 0x00, 0x08, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x01, 0x80, 0xC0,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x1F, 0xC3, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x40, 0x20, 0x00, 0x30, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x04, 0x20, 0x00, 0x01, 0x10, 0x07, 0xA0, 0x90,
  0x0C, 0x20, 0x48, 0x08, 0x10, 0x28, 0x08, 0x08, 0x14, 0x08, 0x04, 0x0A,
  0x04, 0x04, 0x06, 0x04, 0x02, 0x07, 0x02, 0x01, 0x02, 0x83, 0x01, 0x81,
  0x41, 0x00, 0x80, 0xA0, 0x80, 0x40, 0x90, 0x40, 0x60, 0x48, 0x20, 0x30,
  0x44, 0x18, 0x28, 0x62, 0x06, 0x66, 0x61, 0x01, 0xC1, 0xC0, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x06,
  0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x40, 0x04, 0x10,
  0x02, 0x04, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x02, 0x03,
  0xFF, 0x81, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x08, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00, 0x06,
  0x00, 0x01, 0x03, 0xFE, 0x00, 0x40, 0x30, 0x08, 0x03, 0x03, 0x00, 0x20,
  0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x08, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x60, 0x3F, 0xF0, 0x04,
  0x01, 0x80, 0x80, 0x18, 0x10, 0x01, 0x06, 0x00, 0x20, 0x80, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x18, 0x40, 0x02, 0x18, 0x00, 0x42, 0x00, 0x18, 0x40,
  0x02, 0x08, 0x01, 0x81, 0x00, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x38, 0x0C, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x20, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x70, 0x02, 0x00, 0xC0,
  0x60, 0x06, 0x04, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x23, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x08, 0x40,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x06, 0x04, 0x01, 0x80, 0x40, 0x70, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x81, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0xE0, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1C,
  0x03, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x1F, 0xC8, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x01, 0x0C, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00,
  0x10, 0x10, 0x03, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x7F, 0xFF, 0x81, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00,
  0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x40, 0x03,
  0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x02, 0x30, 0x07, 0x00, 0x00, 0x02, 0x00, 0x18, 0x10, 0x01,
  0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00, 0x10,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x41, 0x00, 0x02, 0x10, 0x00,
  0x11, 0x00, 0x00, 0x98, 0x00, 0x09, 0x40, 0x00, 0x53, 0x00, 0x03, 0x08,
  0x00, 0x10, 0x40, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0x60, 0x02,
  0x01, 0x00, 0x10, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x0C,
  0x02, 0x00, 0x20, 0x10, 0x01, 0x01, 0x00, 0x04, 0x00, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x82, 0x80, 0x00, 0x50, 0x50, 0x00, 0x14, 0x0A, 0x00, 0x02, 0x81,
  0x40, 0x00, 0x90, 0x24, 0x00, 0x12, 0x08, 0x80, 0x04, 0x41, 0x10, 0x00,
  0x90, 0x22, 0x00, 0x22, 0x04, 0x40, 0x0C, 0x40, 0x88, 0x01, 0x08, 0x21,
  0x00, 0x41, 0x04, 0x10, 0x08, 0x40, 0x82, 0x02, 0x08, 0x10, 0x40, 0x41,
  0x06, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x30, 0x20, 0x40, 0x84, 0x04, 0x10, 0x09, 0x00, 0x82, 0x01, 0x20, 0x20,
  0x40, 0x28, 0x04, 0x08, 0x05, 0x00, 0x81, 0x00, 0xC0, 0x10, 0x40, 0x18,
  0x06, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x41, 0x40,
  0x01, 0x04, 0x80, 0x08, 0x12, 0x00, 0x20, 0x48, 0x00, 0x81, 0x10, 0x02,
  0x08, 0x40, 0x08, 0x21, 0x00, 0x40, 0x82, 0x01, 0x02, 0x08, 0x04, 0x08,
  0x20, 0x10, 0x40, 0x40, 0xC1, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x08,
  0x20, 0xC0, 0x20, 0x82, 0x00, 0x84, 0x08, 0x01, 0x10, 0x20, 0x04, 0x40,
  0x80, 0x11, 0x04, 0x00, 0x24, 0x10, 0x00, 0xA0, 0x40, 0x02, 0x81, 0x00,
  0x06, 0x04, 0x00, 0x18, 0x20, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x30, 0x18,
  0x06, 0x00, 0x40, 0xC0, 0x06, 0x08, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00,
  0x32, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8,
  0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x40, 0x02, 0x06, 0x00, 0x40,
  0x30, 0x18, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x80, 0xC0, 0x20, 0x18,
  0x18, 0x02, 0x04, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x04, 0x00,
  0x81, 0x00, 0xC0, 0x7F, 0xC0, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x30,
  0x18, 0x06, 0x00, 0x40, 0xC0, 0x06, 0x08, 0x00, 0x21, 0x00, 0x02, 0x20,
  0x00, 0x32, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0x40, 0x02, 0x06, 0x00,
  0x40, 0x30, 0x18, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xFC, 0x00, 0x81, 0xC0, 0x20, 0x18, 0x18, 0x02, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80,
  0x08, 0x20, 0x06, 0x08, 0x01, 0x04, 0x01, 0x81, 0x07, 0x80, 0x7F, 0x80,
  0x10, 0x20, 0x0C, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x01, 0x04, 0x00,
  0x42, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x40, 0x30, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x08, 0x03, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00,
  0x04, 0x40, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x01, 0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08,
  0x00, 0x20, 0x80, 0x04, 0x04, 0x00, 0x80, 0x60, 0x10, 0x01, 0xFE, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x20, 0x08, 0x10, 0x04, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x04, 0x20, 0x02, 0x20, 0x00, 0x90,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x00,
  0xA0, 0x04, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x12, 0x00,
  0x88, 0x02, 0x20, 0x10, 0x80, 0x22, 0x01, 0x04, 0x04, 0x20, 0x30, 0x40,
  0x42, 0x02, 0x04, 0x0C, 0x20, 0x20, 0x40, 0x82, 0x04, 0x04, 0x18, 0x20,
  0x40, 0x41, 0x02, 0x08, 0x04, 0x10, 0x20, 0x80, 0x42, 0x02, 0x10, 0x04,
  0x20, 0x21, 0x00, 0x44, 0x02, 0x10, 0x04, 0x40, 0x22, 0x00, 0x48, 0x02,
  0x20, 0x04, 0x80, 0x24, 0x00, 0x58, 0x02, 0x40, 0x05, 0x00, 0x28, 0x00,
  0x50, 0x02, 0x80, 0x06, 0x00, 0x28, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x08, 0x08, 0x00, 0x80, 0x40, 0x0C, 0x01, 0x00,
  0x40, 0x08, 0x04, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x08, 0x20, 0x00,
  0x42, 0x00, 0x02, 0x30, 0x00, 0x09, 0x00, 0x00, 0x50, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x0C,
  0x40, 0x00, 0x42, 0x00, 0x04, 0x10, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00,
  0x20, 0x10, 0x02, 0x00, 0xC0, 0x20, 0x02, 0x01, 0x00, 0x10, 0x10, 0x00,
  0x81, 0x00, 0x02, 0x00, 0x80, 0x03, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08,
  0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x40, 0x20, 0xC0,
  0x20, 0x80, 0x21, 0x00, 0x23, 0x00, 0x12, 0x00, 0x14, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0xF0, 0x20, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFC,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x82, 0x08,
  0x20, 0x41, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41,
  0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83, 0x01, 0xFE, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x02, 0x18, 0x02,
  0x08, 0x04, 0x08, 0x0C, 0x0C, 0x08, 0x04, 0x10, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xF8, 0x88, 0x44, 0x21,
  0x01, 0xE1, 0x06, 0x19, 0x08, 0x09, 0x10, 0x06, 0x30, 0x06, 0x20, 0x06,
  0x60, 0x06, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x28, 0x80, 0x30,
  0xC0, 0x50, 0x40, 0x90, 0x3F, 0x10, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x3E, 0x02, 0x61, 0x81, 0x60, 0x60, 0xE0, 0x10, 0xA0, 0x08,
  0x60, 0x06, 0x30, 0x01, 0x10, 0x00, 0x98, 0x00, 0xC8, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x09, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x30,
  0x02, 0x18, 0x03, 0x14, 0x03, 0x09, 0x03, 0x04, 0x7E, 0x00, 0x01, 0xFC,
  0x18, 0x20, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x08, 0x1F, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7C, 0x40, 0x61, 0x90,
  0x20, 0x14, 0x10, 0x05, 0x0C, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08, 0x02, 0x83,
  0x01, 0x20, 0x40, 0x90, 0x0F, 0xC4, 0x00, 0x01, 0xF0, 0x18, 0x60, 0xC0,
  0x86, 0x01, 0x30, 0x04, 0x80, 0x36, 0x00, 0x90, 0x06, 0x40, 0x33, 0x03,
  0x0F, 0xE0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x08, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x61, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x40, 0x61, 0x90, 0x20, 0x14, 0x10, 0x05, 0x0C, 0x00, 0xC2, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06,
  0x08, 0x02, 0x82, 0x01, 0x20, 0x40, 0x90, 0x0F, 0xC4, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x80, 0x60, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x7C, 0x09, 0x86, 0x0A, 0x03, 0x0C, 0x01, 0x1C, 0x01, 0x18, 0x01,
  0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x06, 0x0C, 0x10, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x03, 0x08, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x31, 0x00, 0x22, 0x00, 0x25, 0x00,
  0x29, 0x00, 0x31, 0x80, 0x60, 0x80, 0x40, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x02, 0x04, 0x08, 0x30,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x00, 0x08,
  0xF8, 0x1F, 0x02, 0x63, 0x18, 0x60, 0xA0, 0x6C, 0x08, 0x30, 0x0A, 0x01,
  0x18, 0x03, 0x00, 0x46, 0x00, 0x80, 0x11, 0x00, 0x20, 0x08, 0x40, 0x08,
  0x02, 0x30, 0x04, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00, 0x40, 0x08, 0x80,
  0x10, 0x04, 0x20, 0x08, 0x01, 0x10, 0x02, 0x00, 0x44, 0x00, 0x80, 0x11,
  0x00, 0x20, 0x04, 0x40, 0x08, 0x02, 0x10, 0x04, 0x00, 0x88, 0x01, 0x00,
  0x22, 0x00, 0x40, 0x08, 0x80, 0x10, 0x06, 0x00, 0x08, 0x7C, 0x09, 0x86,
  0x0A, 0x03, 0x0C, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x02,
  0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x60, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10, 0x80, 0x13, 0x00, 0x24,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x21,
  0x00, 0xC3, 0x03, 0x03, 0xF8, 0x00, 0x02, 0x1F, 0x00, 0x4C, 0x30, 0x0B,
  0x03, 0x01, 0xC0, 0x20, 0x50, 0x04, 0x0C, 0x00, 0xC1, 0x80, 0x08, 0x20,
  0x01, 0x04, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80,
  0x04, 0x30, 0x01, 0x86, 0x00, 0x20, 0x80, 0x04, 0x18, 0x01, 0x03, 0x00,
  0x60, 0xA0, 0x18, 0x12, 0x06, 0x02, 0x3F, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF1, 0x06, 0x19, 0x08, 0x05,
  0x10, 0x05, 0x30, 0x03, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08,
  0x80, 0x18, 0x80, 0x18, 0x80, 0x28, 0xC0, 0x48, 0x40, 0x90, 0x3F, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x08, 0x78, 0x4C, 0x02, 0x80, 0x18,
  0x01, 0x40, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x30, 0x30, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x20, 0x10, 0x7F, 0x80, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x1F, 0xF0, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x40, 0x1F, 0x00, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80,
  0x30, 0x80, 0x30, 0x80, 0x50, 0xC1, 0x90, 0x7F, 0x10, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40,
  0x41, 0x02, 0x04, 0x18, 0x10, 0x40, 0x43, 0x01, 0x08, 0x04, 0x60, 0x09,
  0x00, 0x28, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12,
  0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x08, 0x41, 0x10, 0x41, 0x08,
  0x41, 0x04, 0x21, 0x04, 0x11, 0x84, 0x20, 0x44, 0x10, 0x81, 0x10, 0x44,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x00, 0x08, 0x00, 0x82, 0x00,
  0x81, 0x00, 0xC0, 0x80, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x04, 0x40, 0x02,
  0x60, 0x01, 0x20, 0x00, 0x60, 0x00, 0x20, 0x00, 0x28, 0x00, 0x24, 0x00,
  0x32, 0x00, 0x10, 0x80, 0x10, 0x40, 0x10, 0x20, 0x18, 0x08, 0x18, 0x04,
  0x08, 0x03, 0x08, 0x00, 0x80, 0x02, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00,
  0x20, 0x10, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x02, 0x00, 0x08, 0x60, 0x00,
  0x84, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00,
  0x0A, 0x00, 0x00, 0xA0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xFF, 0xF0, 0x00, 0x1C, 0x01, 0x80, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x30, 0x01,
  0xC0, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x18,
  0x07, 0x80, 0x00, 0x7F, 0x01, 0xC0, 0xC3, 0x80, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 8, 1, -28 },
  { 26, 8, 10, 11, 4, -28 },
  { 36, 20, 28, 20, 1, -28 },
  { 106, 17, 32, 18, 1, -30 },
  { 174, 21, 28, 26, 3, -28 },
  { 248, 19, 28, 21, 1, -28 },
  { 315, 3, 10, 6, 4, -28 },
  { 319, 11, 34, 9, 1, -28 },
  { 366, 11, 34, 9, -3, -28 },
  { 413, 13, 15, 18, 5, -30 },
  { 438, 16, 18, 20, 2, -23 },
  { 474, 5, 9, 7, -2, -4 },
  { 480, 9, 1, 11, 1, -11 },
  { 482, 2, 2, 7, 1, -2 },
  { 483, 17, 28, 12, -2, -28 },
  { 543, 16, 28, 18, 2, -28 },
  { 599, 8, 28, 18, 6, -28 },
  { 627, 17, 28, 18, 0, -28 },
  { 687, 18, 28, 18, 0, -28 },
  { 750, 18, 28, 18, 0, -28 },
  { 813, 17, 28, 18, 1, -28 },
  { 873, 17, 28, 18, 2, -28 },
  { 933, 16, 28, 18, 3, -28 },
  { 989, 17, 28, 18, 1, -28 },
  { 1049, 17, 28, 18, 1, -28 },
  { 1109, 6, 21, 7, 1, -21 },
  { 1125, 9, 26, 7, -2, -21 },
  { 1155, 16, 16, 20, 2, -22 },
  { 1187, 16, 9, 20, 2, -18 },
  { 1205, 16, 16, 20, 2, -22 },
  { 1237, 12, 28, 13, 2, -28 },
  { 1279, 25, 32, 28, 2, -28 },
  { 1379, 18, 28, 18, -2, -28 },
  { 1442, 19, 28, 20, 1, -28 },
  { 1509, 19, 28, 20, 3, -28 },
  { 1576, 20, 28, 23, 1, -28 },
  { 1646, 18, 28, 18, 1, -28 },
  { 1709, 18, 28, 17, 1, -28 },
  { 1772, 20, 28, 24, 3, -28 },
  { 1842, 22, 28, 23, 1, -28 },
  { 1919, 12, 28, 9, -1, -28 },
  { 1961, 14, 35, 8, -6, -28 },
  { 2023, 21, 28, 18, 1, -28 },
  { 2097, 12, 28, 16, 1, -28 },
  { 2139, 27, 28, 28, 1, -28 },
  { 2234, 22, 28, 23, 1, -28 },
  { 2311, 20, 28, 24, 3, -28 },
  { 2381, 18, 28, 19, 1, -28 },
  { 2444, 20, 35, 24, 3, -28 },
  { 2532, 18, 28, 19, 1, -28 },
  { 2595, 18, 28, 17, 0, -28 },
  { 2658, 16, 28, 16, 4, -28 },
  { 2714, 20, 28, 23, 3, -28 },
  { 2784, 17, 28, 18, 4, -28 },
  { 2844, 28, 28, 29, 4, -28 },
  { 2942, 21, 28, 16, -2, -28 },
  { 3016, 16, 28, 16, 4, -28 },
  { 3072, 20, 28, 18, -1, -28 },
  { 3142, 14, 34, 11, 0, -28 },
  { 3202, 6, 28, 12, 4, -28 },
  { 3223, 15, 34, 11, -3, -28 },
  { 3287, 16, 16, 19, 2, -28 },
  { 3319, 13, 1, 13, -3, 4 },
  { 3321, 4, 6, 9, 6, -30 },
  { 3324, 16, 21, 19, 2, -21 },
  { 3366, 17, 30, 19, 1, -30 },
  { 3430, 14, 21, 15, 2, -21 },
  { 3467, 18, 30, 19, 2, -30 },
  { 3535, 14, 21, 17, 2, -21 },
  { 3572, 20, 39, 9, -5, -30 },
  { 3670, 18, 30, 19, 0, -21 },
  { 3738, 16, 30, 19, 1, -30 },
  { 3798, 7, 28, 7, 1, -28 },
  { 3823, 13, 37, 7, -5, -28 },
  { 3884, 16, 30, 15, 1, -30 },
  { 3944, 7, 30, 7, 1, -30 },
  { 3971, 26, 21, 29, 1, -21 },
  { 4040, 16, 21, 19, 1, -21 },
  { 4082, 15, 21, 19, 2, -21 },
  { 4122, 19, 30, 19, -1, -21 },
  { 4194, 16, 30, 19, 2, -21 },
  { 4254, 13, 21, 12, 1, -21 },
  { 4289, 14, 21, 14, 0, -21 },
  { 4326, 10, 26, 10, 1, -26 },
  { 4359, 16, 21, 19, 2, -21 },
  { 4401, 14, 21, 14, 2, -21 },
  { 4438, 22, 21, 23, 2, -21 },
  { 4496, 17, 21, 15, -1, -21 },
  { 4541, 20, 30, 14, -4, -21 },
  { 4616, 16, 21, 14, -1, -21 },
  { 4658, 14, 34, 13, 1, -28 },
  { 4718, 1, 39, 18, 9, -30 },
  { 4723, 13, 34, 12, -2, -28 },
  { 4779, 16, 3, 20, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ThinItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_THINITALIC39PT7B_H_
