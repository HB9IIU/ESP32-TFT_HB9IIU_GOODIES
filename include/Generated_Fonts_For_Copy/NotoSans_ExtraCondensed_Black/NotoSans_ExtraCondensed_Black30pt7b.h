#ifndef _NOTOSANS_EXTRACONDENSED_BLACK30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0x78,
  0xF7, 0x8F, 0x78, 0xF0, 0x0F, 0x38, 0x1E, 0xF0, 0x39, 0xE0, 0x73, 0xC0,
  0xE7, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xE0, 0x73,
  0xC0, 0xE7, 0x8F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x1E, 0xF0, 0x39, 0xE0,
  0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x07, 0x9C, 0x00, 0x03, 0x00, 0x18, 0x03,
  0xE0, 0x7F, 0xE7, 0xFF, 0x3F, 0xFB, 0xED, 0x9E, 0x60, 0xF3, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x83, 0x7A,
  0x1F, 0x9F, 0xFC, 0xFF, 0xC7, 0xFE, 0x0F, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0xFC, 0x07, 0x01, 0xFC, 0x1E, 0x07, 0xFC, 0x3C,
  0x0F, 0x78, 0x70, 0x1E, 0xF1, 0xE0, 0x39, 0xE3, 0x80, 0x73, 0xCF, 0x00,
  0xE7, 0x9E, 0x01, 0xEF, 0x79, 0xF3, 0xFE, 0xF7, 0xF3, 0xF9, 0xCF, 0xF7,
  0xF7, 0xBD, 0xE3, 0x0E, 0x79, 0xC0, 0x3C, 0xF3, 0x80, 0x79, 0xE7, 0x00,
  0xE3, 0xCE, 0x03, 0xC7, 0x9C, 0x07, 0x0F, 0x78, 0x1E, 0x0F, 0xF0, 0x3C,
  0x1F, 0xC0, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFC, 0xFC, 0xFF, 0x3E, 0x7F, 0xEF, 0xBE, 0xFF,
  0xEF, 0x9F, 0xF3, 0xE7, 0xFC, 0xF8, 0xFE, 0x3E, 0x3F, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xBD, 0xE0,
  0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC1,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x19, 0xE6, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0xC7, 0xF8,
  0x0F, 0xE0, 0x7F, 0x87, 0xEF, 0x8F, 0x3C, 0x1C, 0x60, 0x21, 0x00, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0xBC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF,
  0xFF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x00, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3E, 0xFB,
  0xE3, 0xDF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0x79, 0xF3, 0xEF, 0x9F, 0xFC, 0x7F, 0xC3, 0xFE,
  0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFB,
  0xDF, 0x33, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x03, 0xFC, 0x7F, 0xEF,
  0xFE, 0xFF, 0xF6, 0x1F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x03, 0xFE, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF,
  0x20, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x83,
  0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xFE, 0x1F, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFE, 0x3F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xF7, 0xC3, 0xDF, 0x1E,
  0x7C, 0x79, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xFC, 0x47,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0xC3, 0xF7, 0xFF, 0xBF, 0xF9,
  0xFF, 0xC7, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0xE3, 0xFF,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xFB, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF,
  0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFB, 0xEF, 0xDF, 0xFC, 0xFF,
  0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xDF, 0x7C,
  0x7B, 0xE3, 0xCF, 0xBE, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xFF,
  0x3E, 0xFB, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xE7,
  0xFE, 0x0F, 0xE0, 0x0F, 0x01, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0x7C,
  0xFB, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0x9F, 0x7C, 0x73, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x9F, 0xF8, 0xFF, 0x87,
  0xF8, 0x3F, 0x80, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x79, 0xFF, 0xDF, 0x78, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF7, 0xDE, 0x7B, 0xEF, 0xBE, 0xF0, 0x00, 0x18, 0x03, 0xC0,
  0x7E, 0x0F, 0xF1, 0xFF, 0x3F, 0xE3, 0xF8, 0x1F, 0x80, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xF9, 0xFF, 0x3F, 0xE1, 0xFC, 0x0F, 0x80,
  0x60, 0x02, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0xFF, 0xEF, 0xFE, 0x7F, 0xF6,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0x83,
  0xE0, 0x1E, 0x1E, 0x00, 0x79, 0xE3, 0xF9, 0xCE, 0x3F, 0xCF, 0x73, 0xFE,
  0x7F, 0x9E, 0x71, 0xFC, 0xE3, 0x8F, 0xEF, 0x1C, 0x7E, 0x78, 0xE3, 0xF3,
  0xC7, 0x3F, 0xDE, 0x79, 0xDE, 0x7B, 0xDE, 0xF3, 0xFF, 0xF3, 0x8F, 0x9F,
  0x1E, 0x10, 0x20, 0x78, 0x00, 0x03, 0xE0, 0x08, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0x9E, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3E, 0x0F, 0x9F, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0xF8, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0xBF, 0x09, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x87, 0xF8,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF9, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x8F, 0xFE, 0x3F, 0xFB, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xC0, 0x9F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x0F, 0xBE,
  0x1F, 0x7C, 0x3E, 0xFC, 0x7C, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF,
  0x80, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3F, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0x7F, 0xBF, 0x8F,
  0x00, 0xF8, 0x7F, 0xF1, 0xFB, 0xE3, 0xE7, 0xCF, 0xCF, 0x9F, 0x1F, 0x7E,
  0x3E, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0x7E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF9, 0xF1, 0xF3, 0xE3,
  0xF7, 0xC3, 0xEF, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0x79, 0xEF, 0xF7, 0x9E, 0xFF, 0x79, 0xEF, 0xFF, 0xDE, 0xFF,
  0xBF, 0xCF, 0xFB, 0xFC, 0xFF, 0xBF, 0xCF, 0xFB, 0xFC, 0xFF, 0x9F, 0x8F,
  0xF9, 0xF8, 0xFF, 0x9F, 0x8F, 0xF9, 0xF8, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0,
  0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x9F, 0xFF, 0x9F, 0xF7, 0x9F, 0xF7, 0xDF, 0xF3, 0xDF, 0xF3,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0x03, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC,
  0x7F, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F,
  0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xFC, 0xF9,
  0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x3E, 0xF8,
  0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xF3, 0xE3, 0xE7, 0xC7, 0xEF, 0x87, 0xE0,
  0x0F, 0x83, 0xFE, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0x86, 0xF8, 0x0F, 0x80,
  0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xFF, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x0F, 0x3E, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x3E, 0x1F, 0x78, 0x3E, 0x1F,
  0x7C, 0x7E, 0x1F, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E,
  0x3C, 0xFF, 0x3E, 0x3C, 0xFF, 0x3E, 0x3E, 0xFF, 0x3C, 0x3E, 0xFF, 0x7C,
  0x3E, 0xF7, 0x7C, 0x3E, 0xE7, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8,
  0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x7C, 0x7C, 0x7E, 0x7C,
  0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3E, 0xFC, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x3E, 0x1E,
  0x0F, 0x0F, 0x87, 0xFE, 0x7F, 0xF3, 0xFF, 0x31, 0xF0, 0x1F, 0x03, 0xF3,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7,
  0xEF, 0x7E, 0x70, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x9E, 0x3E, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xEF, 0xBF, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xCF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xBE, 0x00, 0x0F, 0x83, 0xFC, 0xFF,
  0xBF, 0xF7, 0xCD, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC2, 0xFF, 0xDF, 0xF9, 0xFF, 0x1F, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x73, 0xE7, 0xFF, 0x7F, 0x7B, 0xFF,
  0xFF, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFF, 0x3E, 0xFF, 0xF7, 0xFF, 0x9F, 0xBC, 0xF9, 0xE0, 0x0F, 0x81,
  0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0x3F, 0xF9, 0xFF, 0xC7, 0xFE,
  0x1F, 0xE0, 0x0F, 0x87, 0xF1, 0xFC, 0xFF, 0x3E, 0x0F, 0x83, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1E, 0x79, 0xFB, 0xDF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF, 0x3E, 0xF8, 0x07,
  0xC0, 0x3E, 0x83, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x87, 0xF0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE7, 0x9F, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xCF, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xE0,
  0x7B, 0xEF, 0xDE, 0x70, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x1E, 0x3E, 0x3F, 0x1E, 0x1C, 0x00,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0xFE, 0xFE, 0xFC, 0xF8,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x1F, 0xFC, 0x3E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xFB, 0xE3, 0xE7, 0xE7,
  0xC7, 0xCF, 0x8F, 0xDF, 0x0F, 0xBE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1,
  0xE1, 0xE7, 0xDF, 0x9F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x7F, 0xF3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7,
  0xC7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F,
  0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xF8, 0xF1, 0xE7, 0xDF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x78,
  0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xF7, 0xCF, 0xBF, 0xFD, 0xFF,
  0xC7, 0xFC, 0x1F, 0xC0, 0xF1, 0xC3, 0xEF, 0xCF, 0xFF, 0x3F, 0xFE, 0xFC,
  0xFB, 0xF3, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF,
  0x1F, 0xFC, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0xFC, 0xF9, 0xE3, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x79,
  0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF,
  0x3E, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0xE3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFE, 0xF1, 0xBE, 0x0F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFC, 0x1F,
  0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3F, 0xCF, 0xF1, 0xFC, 0x3F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7,
  0xFE, 0x3F, 0xF1, 0xF7, 0xCF, 0xBF, 0xFD, 0xFF, 0xEF, 0xEF, 0x3F, 0x78,
  0xF8, 0x3F, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0x9F, 0x0F,
  0x3E, 0x1F, 0x7C, 0x3E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0xFC, 0x7F, 0xE3,
  0xF1, 0xF7, 0x8F, 0xC7, 0xDF, 0x3F, 0x1E, 0x7C, 0xFE, 0xF9, 0xF7, 0xFB,
  0xE7, 0xDF, 0xEF, 0x8F, 0x7F, 0xBC, 0x3D, 0xFE, 0xF0, 0xF7, 0x3B, 0xC3,
  0xDC, 0xEF, 0x0F, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x7D, 0xF3, 0xE7, 0xCF,
  0x8F, 0xBE, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0x81, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xE7, 0xCF, 0x9F, 0x3E, 0xFC,
  0x7C, 0xF8, 0x3F, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0x9F,
  0x0F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC1,
  0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xFC, 0xFE, 0x3F, 0x0F, 0xE3, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF1, 0xFC, 0xFF, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x00, 0x7E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 12, 7, 15, 1, -21 },
  { 28, 15, 21, 16, 1, -21 },
  { 68, 13, 25, 15, 1, -23 },
  { 109, 23, 22, 25, 1, -22 },
  { 173, 18, 22, 19, 1, -22 },
  { 223, 5, 7, 8, 1, -21 },
  { 228, 9, 27, 10, 1, -22 },
  { 259, 8, 27, 10, 0, -22 },
  { 286, 14, 14, 14, 0, -23 },
  { 311, 13, 15, 15, 1, -18 },
  { 336, 6, 8, 8, 1, -4 },
  { 342, 8, 4, 10, 1, -10 },
  { 346, 6, 5, 8, 1, -5 },
  { 350, 13, 22, 13, 0, -22 },
  { 386, 13, 22, 15, 1, -22 },
  { 422, 11, 21, 15, 1, -21 },
  { 451, 12, 22, 15, 1, -22 },
  { 484, 13, 22, 15, 1, -22 },
  { 520, 14, 21, 15, 0, -21 },
  { 557, 13, 21, 15, 1, -21 },
  { 592, 13, 22, 15, 1, -22 },
  { 628, 13, 21, 15, 1, -21 },
  { 663, 13, 22, 15, 1, -22 },
  { 699, 13, 22, 15, 1, -22 },
  { 735, 6, 17, 8, 1, -17 },
  { 748, 6, 21, 8, 1, -17 },
  { 764, 13, 15, 15, 1, -18 },
  { 789, 13, 11, 15, 1, -16 },
  { 807, 13, 15, 15, 1, -18 },
  { 832, 12, 22, 12, 0, -22 },
  { 865, 21, 24, 23, 1, -22 },
  { 928, 17, 21, 17, 0, -21 },
  { 973, 13, 21, 17, 2, -21 },
  { 1008, 13, 22, 15, 1, -22 },
  { 1044, 14, 21, 18, 2, -21 },
  { 1081, 10, 21, 13, 2, -21 },
  { 1108, 10, 21, 13, 2, -21 },
  { 1135, 15, 22, 18, 1, -22 },
  { 1177, 15, 21, 18, 2, -21 },
  { 1217, 9, 21, 11, 1, -21 },
  { 1241, 9, 28, 9, -2, -21 },
  { 1273, 15, 21, 17, 2, -21 },
  { 1313, 10, 21, 13, 2, -21 },
  { 1340, 20, 21, 24, 2, -21 },
  { 1393, 16, 21, 20, 2, -21 },
  { 1435, 16, 22, 19, 1, -22 },
  { 1479, 13, 21, 16, 2, -21 },
  { 1514, 16, 27, 19, 1, -22 },
  { 1568, 15, 21, 16, 2, -21 },
  { 1608, 12, 22, 14, 1, -22 },
  { 1641, 12, 21, 14, 1, -21 },
  { 1673, 14, 21, 18, 2, -21 },
  { 1710, 17, 21, 17, 0, -21 },
  { 1755, 24, 21, 24, 0, -21 },
  { 1818, 16, 21, 16, 0, -21 },
  { 1860, 16, 21, 16, 0, -21 },
  { 1902, 13, 21, 14, 1, -21 },
  { 1937, 8, 27, 9, 1, -22 },
  { 1964, 13, 22, 13, 0, -22 },
  { 2000, 7, 27, 9, 1, -22 },
  { 2024, 16, 14, 16, 0, -21 },
  { 2052, 15, 4, 15, 0, 2 },
  { 2060, 8, 5, 10, 1, -23 },
  { 2065, 12, 17, 15, 1, -17 },
  { 2091, 14, 23, 16, 1, -23 },
  { 2132, 11, 17, 13, 1, -17 },
  { 2156, 13, 23, 16, 1, -23 },
  { 2194, 13, 17, 14, 1, -17 },
  { 2222, 10, 23, 10, 0, -23 },
  { 2251, 13, 24, 16, 1, -17 },
  { 2290, 13, 23, 16, 1, -23 },
  { 2328, 6, 23, 8, 1, -23 },
  { 2346, 8, 30, 8, -1, -23 },
  { 2376, 15, 23, 16, 1, -23 },
  { 2420, 5, 23, 8, 1, -23 },
  { 2435, 21, 17, 24, 1, -17 },
  { 2480, 13, 17, 16, 1, -17 },
  { 2508, 13, 17, 15, 1, -17 },
  { 2536, 14, 24, 16, 1, -17 },
  { 2578, 13, 24, 16, 1, -17 },
  { 2617, 9, 17, 11, 2, -17 },
  { 2637, 10, 17, 12, 1, -17 },
  { 2659, 10, 20, 11, 0, -20 },
  { 2684, 13, 17, 16, 1, -17 },
  { 2712, 15, 17, 15, 0, -17 },
  { 2744, 22, 17, 22, 0, -17 },
  { 2791, 14, 17, 14, 0, -17 },
  { 2821, 15, 24, 15, 0, -17 },
  { 2866, 11, 17, 12, 0, -17 },
  { 2890, 10, 27, 11, 0, -22 },
  { 2924, 4, 30, 13, 4, -23 },
  { 2939, 10, 27, 11, 1, -22 },
  { 2973, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Black30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK30PT7B_H_
