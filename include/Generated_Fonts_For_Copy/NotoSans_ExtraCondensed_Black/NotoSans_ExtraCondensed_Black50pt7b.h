#ifndef _NOTOSANS_EXTRACONDENSED_BLACK50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF3, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xE0, 0x80, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3E,
  0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x3F, 0x9C, 0x79, 0xFC, 0xE0, 0x8F, 0xE7, 0x00, 0x7F,
  0x38, 0x03, 0xFD, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x77, 0xF0, 0x03, 0x9F, 0xC0, 0x1C, 0xFF,
  0x00, 0xE7, 0xE6, 0x07, 0x3F, 0x3C, 0x3B, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x01,
  0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x7F, 0x03, 0xF0, 0x00,
  0xFE, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x1F, 0x80, 0x00, 0xFE,
  0x3F, 0x3F, 0x07, 0xC0, 0x7E, 0x7F, 0x3F, 0x1F, 0xF0, 0x7F, 0x7E, 0x3F,
  0x3F, 0xF8, 0x7F, 0xFE, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7F, 0xFC,
  0x1F, 0xFC, 0xFC, 0x7F, 0xFE, 0x1F, 0xF8, 0xFC, 0xFE, 0x7E, 0x07, 0xE0,
  0xFC, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFC,
  0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00,
  0x07, 0xF0, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x7F, 0x00, 0x07, 0xE0,
  0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x7E,
  0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC7, 0xFC, 0x1F, 0xFF, 0x0F, 0xF8, 0x7F,
  0xFF, 0x1F, 0xE1, 0xFF, 0xFE, 0x3F, 0xC3, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xF8, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x87, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xBF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xC3, 0xF0, 0xE7, 0xCF,
  0xCF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xDF, 0xE1, 0xFF, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xE1,
  0xF0, 0x07, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xDF,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x3F, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFB, 0xFE, 0x7F, 0x8F, 0xF7, 0xFC, 0x7F, 0xBF, 0xC3, 0xFD,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0x7F, 0xBF, 0xCF, 0xCF, 0xF1, 0xE3, 0xFC, 0x30, 0xFF, 0x08, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xE3, 0xFE, 0x3C, 0x0F, 0xF8, 0xC0, 0x7F, 0xC2, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0x87, 0xFE, 0x18, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xF7, 0xFC, 0x0F, 0xEF, 0xF8, 0x1F, 0x9F, 0xF0,
  0x7F, 0x3F, 0xE0, 0xFC, 0x7F, 0xC3, 0xF8, 0xFF, 0x87, 0xE1, 0xFF, 0x1F,
  0xC3, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFD, 0x00, 0x3F, 0xEF, 0x03, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0xE0, 0x7F, 0x9F, 0xC3, 0xF9, 0xFF,
  0x1F, 0xDF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF7, 0xF8,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFE, 0xFF, 0x9F, 0xF1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE,
  0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC,
  0xFF, 0x9F, 0xE1, 0xFF, 0x7F, 0x83, 0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xDF, 0xC0, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF,
  0x7F, 0xC7, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xEF, 0xF0, 0xFF, 0xBF, 0xC1, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x1F,
  0xE7, 0xF9, 0xFE, 0xFF, 0xFF, 0xE7, 0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F,
  0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xDF, 0xE7, 0xF8, 0xFC, 0x0C, 0x00, 0x0F,
  0x87, 0xF8, 0xFF, 0x1F, 0xE7, 0xFE, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF9, 0xE0, 0xFF, 0x30, 0x1F, 0xE4, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x3F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFE,
  0x3F, 0x3F, 0x07, 0xFF, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8, 0xFC, 0xF8, 0x7F,
  0xFF, 0x0F, 0xBF, 0x0F, 0xC7, 0xE1, 0xF7, 0xE3, 0xF8, 0xFC, 0x3F, 0xFC,
  0x7E, 0x1F, 0x87, 0xFF, 0x8F, 0xC3, 0xF0, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x87, 0xE1, 0xF8, 0x7D, 0xF0, 0xFC, 0x3F,
  0x0F, 0xBE, 0x1F, 0x87, 0xE1, 0xF7, 0xE3, 0xF0, 0xFC, 0x7E, 0xFC, 0x7E,
  0x3F, 0x8F, 0x9F, 0x8F, 0xEF, 0xFB, 0xF3, 0xF0, 0xFF, 0xFF, 0xFC, 0x7E,
  0x1F, 0xFD, 0xFF, 0x87, 0xE1, 0xFF, 0x3F, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xC7,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xBF,
  0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0x87, 0xFE, 0xFF, 0x07, 0xFD, 0xFE, 0x0F, 0xFB,
  0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE1, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xBF, 0xC0,
  0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFC,
  0x3E, 0x3F, 0xE0, 0x11, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x02, 0x3F, 0xF0, 0x38, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xF0, 0x3C, 0x3F, 0xF0, 0x04, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80,
  0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xFC, 0x0F, 0xF3, 0xFF,
  0x07, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x43, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F,
  0xE7, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3,
  0xFE, 0x07, 0xFB, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF9, 0xFE, 0x07,
  0xFC, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0,
  0x3F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0x1F, 0xBF, 0xFF,
  0xDF, 0xCF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFB, 0xFF, 0xFC, 0xFE, 0xFC, 0xFF,
  0xFF, 0x3F, 0xBF, 0x3F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xEF, 0xF3, 0xFF, 0xFC, 0xFF, 0x7F,
  0xFF, 0x9F, 0xEF, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0x0F, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0xFF,
  0x1F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF,
  0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01,
  0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFE, 0x7F, 0xF8, 0xFF, 0x0F, 0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC1, 0xFF,
  0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F,
  0xE1, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC7, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F, 0x81, 0xFF,
  0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xC0, 0xE7, 0xF8, 0x04, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFE,
  0xFF, 0x83, 0xFE, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xBF, 0xE0,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0,
  0x7F, 0x8F, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFF, 0x8F, 0xF8, 0x1F, 0xE3,
  0xF7, 0xE7, 0xF8, 0x0F, 0xF3, 0xFB, 0xF3, 0xFC, 0x07, 0xF9, 0xFD, 0xF9,
  0xFE, 0x01, 0xFC, 0xFE, 0xFC, 0xFF, 0x00, 0xFF, 0x7E, 0x7E, 0x7F, 0x80,
  0x7F, 0xBF, 0x3F, 0x3F, 0xC0, 0x3F, 0xDF, 0x8F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7,
  0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF,
  0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0,
  0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xF9,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0xFF,
  0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xC0,
  0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3E, 0x3F, 0xE1, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xDF, 0xCF, 0xFC, 0x7E,
  0x3F, 0xC3, 0xF0, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x3E, 0x07, 0xF9, 0xFF, 0x0F, 0xF7, 0xFF, 0x1F, 0xEF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xFB, 0xFE, 0x0F,
  0xF7, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xDF, 0xF0, 0x7F, 0xBF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xDF, 0xF0, 0x7F, 0xBF, 0xF1, 0xFF, 0x7F,
  0xF7, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFB,
  0xFF, 0x8F, 0xF3, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFE, 0x0C, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x2F, 0xF8,
  0x0D, 0xFF, 0xCF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x7C, 0x3F, 0xC7, 0xFC, 0xFF, 0x3F, 0xFB, 0xFC, 0xFF, 0xEF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFE, 0xFF, 0x1F,
  0xF9, 0xFC, 0x3F, 0x87, 0xF0, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x02, 0x3F, 0xE0, 0x71, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF,
  0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xE1,
  0xFC, 0x7F, 0xCF, 0xF1, 0xFF, 0xBF, 0xCF, 0xFE, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xEF, 0xF1, 0xFF, 0x3F,
  0xC3, 0xF8, 0xFF, 0x01, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x90,
  0x01, 0xFE, 0x78, 0x0F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF8, 0xFF, 0x7F, 0xF3,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF0, 0x1E, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x1C, 0x00, 0x00, 0x0F, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x01, 0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF,
  0xE7, 0xFC, 0x1F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x87,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x9F, 0xE0, 0xFF, 0xBF,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF0, 0xFF, 0x8F, 0xF0, 0xFF, 0x8F,
  0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x83,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC7, 0xFE,
  0x3F, 0xE3, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x8F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF,
  0x87, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x7F, 0x87, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFE, 0x1F, 0x81,
  0xFC, 0x7F, 0xC3, 0xFD, 0xFF, 0xC7, 0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x83, 0xFD, 0xFF,
  0x07, 0xFB, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFB, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xEF, 0xFC, 0x7F, 0xDF, 0xFD, 0xFF,
  0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x7F, 0xF9, 0xFE, 0xFF, 0xE3,
  0xFC, 0xFF, 0x87, 0xFC, 0xFE, 0x0F, 0xF8, 0x20, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x7F, 0xCF, 0xF1, 0xFF, 0xBF,
  0xCF, 0xFE, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xEF, 0xF1, 0xFF, 0x3F, 0xC3, 0xF8, 0xFF, 0x01, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xF9, 0xF3, 0xFC, 0x08, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1, 0xFF, 0x9F, 0xC3, 0xFC, 0x3F, 0x00,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F,
  0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0x9F,
  0xE1, 0xFF, 0x83, 0xFC, 0xFF, 0x0F, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xFC, 0x3F, 0x87, 0xF8,
  0xFF, 0xE3, 0xFC, 0x3F, 0xCF, 0xDF, 0x1F, 0xE1, 0xFE, 0x7E, 0xFC, 0xFF,
  0x0F, 0xF3, 0xF7, 0xE7, 0xF0, 0x3F, 0x9F, 0xBF, 0x3F, 0x81, 0xFC, 0xFD,
  0xF9, 0xFC, 0x0F, 0xEF, 0xEF, 0xDF, 0xE0, 0x7F, 0x7E, 0x7E, 0xFF, 0x03,
  0xFF, 0xF3, 0xF7, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x7F,
  0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xC7, 0xFC,
  0x3F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xE7, 0xF8,
  0x3F, 0xC7, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83, 0xFE, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFF,
  0x7F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xE3, 0xF8,
  0x0F, 0xF7, 0xF8, 0x0F, 0xF7, 0xF8, 0x0F, 0xF7, 0xF0, 0x07, 0xF7, 0xF0,
  0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x23, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x02, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Black50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 37, 14, 2, -36 },
  { 43, 20, 13, 24, 2, -36 },
  { 76, 26, 36, 27, 1, -36 },
  { 193, 21, 41, 25, 2, -38 },
  { 301, 40, 36, 42, 1, -36 },
  { 481, 31, 37, 32, 1, -36 },
  { 625, 9, 13, 13, 2, -36 },
  { 640, 14, 45, 16, 2, -37 },
  { 719, 14, 45, 16, 0, -37 },
  { 798, 22, 22, 24, 1, -38 },
  { 859, 21, 24, 25, 2, -30 },
  { 922, 10, 14, 14, 2, -7 },
  { 940, 14, 7, 16, 1, -17 },
  { 953, 9, 10, 14, 2, -9 },
  { 965, 21, 37, 21, 0, -36 },
  { 1063, 21, 37, 25, 2, -36 },
  { 1161, 18, 36, 25, 2, -36 },
  { 1242, 21, 36, 25, 1, -36 },
  { 1337, 22, 37, 25, 1, -36 },
  { 1439, 23, 36, 25, 1, -36 },
  { 1543, 21, 37, 25, 2, -36 },
  { 1641, 21, 37, 25, 2, -36 },
  { 1739, 21, 36, 25, 2, -36 },
  { 1834, 22, 37, 25, 1, -36 },
  { 1936, 22, 37, 25, 1, -36 },
  { 2038, 10, 29, 14, 2, -28 },
  { 2075, 11, 35, 14, 1, -28 },
  { 2124, 22, 24, 25, 1, -30 },
  { 2190, 21, 17, 25, 2, -26 },
  { 2235, 22, 24, 25, 2, -30 },
  { 2301, 19, 37, 20, 0, -36 },
  { 2389, 35, 40, 38, 2, -36 },
  { 2564, 29, 36, 29, 0, -36 },
  { 2695, 23, 36, 28, 3, -36 },
  { 2799, 22, 37, 25, 2, -36 },
  { 2901, 24, 36, 29, 3, -36 },
  { 3009, 17, 36, 22, 3, -36 },
  { 3086, 17, 36, 22, 3, -36 },
  { 3163, 25, 37, 30, 2, -36 },
  { 3279, 25, 36, 30, 3, -36 },
  { 3392, 15, 36, 18, 1, -36 },
  { 3460, 15, 47, 15, -3, -36 },
  { 3549, 25, 36, 28, 3, -36 },
  { 3662, 18, 36, 21, 3, -36 },
  { 3743, 34, 36, 40, 3, -36 },
  { 3896, 27, 36, 33, 3, -36 },
  { 4018, 27, 37, 31, 2, -36 },
  { 4143, 22, 36, 26, 3, -36 },
  { 4242, 27, 45, 31, 2, -36 },
  { 4394, 25, 36, 27, 3, -36 },
  { 4507, 20, 37, 23, 1, -36 },
  { 4600, 21, 36, 23, 1, -36 },
  { 4695, 24, 37, 29, 3, -36 },
  { 4806, 28, 36, 28, 0, -36 },
  { 4932, 41, 36, 41, 0, -36 },
  { 5117, 26, 36, 26, 0, -36 },
  { 5234, 26, 36, 26, 0, -36 },
  { 5351, 22, 36, 24, 1, -36 },
  { 5450, 12, 45, 15, 2, -37 },
  { 5518, 21, 37, 21, 0, -36 },
  { 5616, 12, 45, 15, 1, -37 },
  { 5684, 27, 24, 27, 0, -36 },
  { 5765, 25, 6, 25, 0, 3 },
  { 5784, 13, 8, 17, 2, -38 },
  { 5797, 21, 29, 25, 1, -28 },
  { 5874, 23, 39, 26, 2, -38 },
  { 5987, 19, 29, 22, 2, -28 },
  { 6056, 22, 39, 26, 2, -38 },
  { 6164, 21, 29, 24, 2, -28 },
  { 6241, 17, 38, 16, 0, -38 },
  { 6322, 22, 40, 26, 2, -28 },
  { 6432, 22, 38, 26, 2, -38 },
  { 6537, 9, 39, 13, 2, -39 },
  { 6581, 13, 51, 13, -2, -39 },
  { 6664, 24, 38, 26, 2, -38 },
  { 6778, 9, 38, 13, 2, -38 },
  { 6821, 35, 28, 39, 2, -28 },
  { 6944, 22, 28, 26, 2, -28 },
  { 7021, 22, 29, 26, 2, -28 },
  { 7101, 23, 40, 26, 2, -28 },
  { 7216, 22, 40, 26, 2, -28 },
  { 7326, 15, 28, 19, 3, -28 },
  { 7379, 18, 29, 20, 1, -28 },
  { 7445, 17, 34, 18, 0, -33 },
  { 7518, 22, 29, 26, 2, -28 },
  { 7598, 24, 28, 25, 0, -28 },
  { 7682, 37, 28, 37, 0, -28 },
  { 7812, 24, 28, 24, 0, -28 },
  { 7896, 24, 40, 25, 0, -28 },
  { 8016, 18, 28, 20, 1, -28 },
  { 8079, 16, 44, 18, 1, -36 },
  { 8167, 7, 50, 21, 7, -39 },
  { 8211, 17, 44, 18, 1, -36 },
  { 8305, 23, 9, 25, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Black50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK50PT7B_H_
