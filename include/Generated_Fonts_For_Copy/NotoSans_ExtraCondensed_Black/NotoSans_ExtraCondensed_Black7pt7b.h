#ifndef _NOTOSANS_EXTRACONDENSED_BLACK7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0xB4, 0x6F, 0x6F, 0x60, 0x79, 0xDE, 0xD3, 0x4E, 0xCD,
  0x6C, 0x63, 0x1D, 0x6F, 0x80, 0xC0, 0x7A, 0xD0, 0x95, 0x60, 0xEB, 0x80,
  0x5D, 0x00, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x76, 0xD6, 0x7C, 0x92, 0xF5,
  0xAE, 0xE5, 0x9E, 0x6E, 0xF2, 0x7B, 0x9E, 0x73, 0xD6, 0xE5, 0xA4, 0x75,
  0xDE, 0x77, 0x9E, 0xC3, 0xC3, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7, 0x00,
  0xE5, 0x04, 0x75, 0xF7, 0x74, 0x18, 0x66, 0x6F, 0x90, 0xEF, 0xEF, 0xE0,
  0x7B, 0x66, 0xEF, 0xDF, 0xE0, 0xFB, 0xEE, 0xFB, 0xEC, 0x7C, 0xFD, 0x70,
  0xDD, 0xFD, 0xD0, 0xD5, 0xC0, 0xFF, 0xF8, 0xFE, 0xEE, 0xF0, 0xDB, 0x6E,
  0xDE, 0xFF, 0xFE, 0x80, 0xDD, 0xFF, 0xD0, 0x7D, 0xDD, 0x70, 0xFF, 0xEC,
  0x7D, 0xDD, 0x73, 0xEE, 0xEE, 0xF0, 0xF1, 0x9E, 0xE9, 0x24, 0xDD, 0xDD,
  0x60, 0x9F, 0x66, 0x60, 0xAE, 0xEF, 0x9E, 0x58, 0xB6, 0x46, 0xB0, 0xB6,
  0x64, 0x40, 0xE5, 0x6E, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46, 0xB0,
  0xF0, 0xC0, 0xEE, 0xF0, 0x97, 0xDE, 0x72, 0x30, 0x2E, 0xD6, 0x77, 0x30,
  0x7F, 0xC0, 0x76, 0xBA, 0x80, 0x97, 0xDA, 0xEA, 0x80, 0xEA, 0xA8, 0x8B,
  0xAE, 0xB0, 0xF8, 0xFF, 0x6B, 0x50, 0xFE, 0xD0, 0x76, 0xB0, 0xBE, 0xF9,
  0x00, 0x76, 0xB2, 0x40, 0xBA, 0x40, 0xF9, 0xE0, 0x7F, 0x40, 0xB6, 0xB0,
  0xB5, 0xA0, 0xAD, 0x56, 0xA0, 0xAD, 0xD0, 0xBD, 0xA5, 0x80, 0xE9, 0x70,
  0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Black7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 6, 5, 6, 0, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 1, 2, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 3, 3, 3, 0, -5 },
  { 24, 3, 3, 4, 0, -4 },
  { 26, 2, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 2, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 3, 5, 3, 0, -5 },
  { 49, 3, 5, 3, 0, -5 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 2, 5, 2, 0, -4 },
  { 54, 3, 3, 4, 0, -4 },
  { 56, 3, 3, 4, 0, -4 },
  { 58, 3, 3, 4, 0, -4 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 5, 6, 5, 0, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 3, 0, -5 },
  { 79, 3, 5, 3, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 2, 5, 2, 0, -5 },
  { 89, 2, 7, 2, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 3, 5, 3, 0, -5 },
  { 96, 5, 5, 6, 0, -5 },
  { 100, 4, 5, 5, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 3, 5, 4, 0, -5 },
  { 108, 4, 6, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 6, 5, 6, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 3, 5, 3, 0, -5 },
  { 136, 2, 6, 2, 0, -5 },
  { 138, 3, 5, 3, 0, -5 },
  { 140, 2, 6, 2, 0, -5 },
  { 142, 4, 3, 4, 0, -5 },
  { 144, 4, 1, 4, 0, 0 },
  { 145, 2, 1, 2, 0, -5 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 3, 5, 4, 0, -5 },
  { 150, 3, 4, 3, 0, -4 },
  { 152, 3, 5, 4, 0, -5 },
  { 154, 3, 4, 3, 0, -4 },
  { 156, 2, 5, 2, 0, -5 },
  { 158, 3, 6, 4, 0, -4 },
  { 161, 3, 5, 4, 0, -5 },
  { 163, 2, 5, 2, 0, -5 },
  { 165, 2, 7, 2, 0, -5 },
  { 167, 4, 5, 4, 0, -5 },
  { 170, 1, 5, 2, 0, -5 },
  { 171, 5, 4, 6, 0, -4 },
  { 174, 3, 4, 4, 0, -4 },
  { 176, 3, 4, 4, 0, -4 },
  { 178, 3, 6, 4, 0, -4 },
  { 181, 3, 6, 4, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 2, 5, 2, 0, -5 },
  { 190, 3, 4, 4, 0, -4 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 5, 4, 5, 0, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 3, 6, 3, 0, -4 },
  { 202, 3, 4, 3, 0, -4 },
  { 204, 2, 6, 3, 0, -5 },
  { 206, 1, 7, 3, 1, -5 },
  { 207, 2, 6, 3, 0, -5 },
  { 209, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Black7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK7PT7B_H_
