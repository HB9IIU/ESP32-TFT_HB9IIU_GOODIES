#ifndef _NOTOSANS_EXTRACONDENSED_BLACK43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x10, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xBF, 0x0F, 0xC0, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x87, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0xFF, 0xE1, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x7E, 0xE3, 0xBF, 0x70, 0x1F, 0xB8,
  0x0F, 0xDC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0E, 0xFC, 0x07, 0x3E,
  0x03, 0x9F, 0xC1, 0xCF, 0xF8, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xE0,
  0x03, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xF8, 0x1F,
  0x00, 0x3F, 0x3E, 0x07, 0xC0, 0x0F, 0xCF, 0x83, 0xE0, 0x03, 0xE3, 0xF0,
  0xF8, 0x00, 0xF8, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x0F, 0x8F,
  0xC7, 0xC0, 0x03, 0xE3, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0xF8, 0x7C, 0x3F,
  0x3E, 0x7C, 0x7F, 0x87, 0xFF, 0x9F, 0x3F, 0xF1, 0xFF, 0xCF, 0xCF, 0xFE,
  0x3F, 0xF3, 0xE7, 0xFF, 0x87, 0xF8, 0xF9, 0xF3, 0xF0, 0xFC, 0x7C, 0x7C,
  0xFC, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0xC7, 0xC0, 0x03, 0xE3,
  0xF1, 0xF0, 0x00, 0xF8, 0xFC, 0x7C, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x1F,
  0x07, 0xC7, 0xC0, 0x0F, 0xC1, 0xF3, 0xF0, 0x03, 0xE0, 0x7F, 0xF8, 0x00,
  0xF8, 0x0F, 0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF9,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xF0, 0xFF, 0xF1, 0xFC, 0x3F, 0xFE,
  0x3F, 0x8F, 0xFF, 0xEF, 0xF1, 0xFD, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0x8F,
  0xE3, 0xFF, 0xF1, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0x87, 0xF0, 0x7F,
  0xE0, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0x83, 0xFF, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x03,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x04, 0x1F, 0x04, 0xE3, 0xE7, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xEF, 0xC3, 0xF9, 0xFC, 0x3F,
  0x1F, 0x03, 0xC3, 0xC0, 0x18, 0x30, 0x01, 0x04, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x9F, 0xCF, 0xE7, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xF3,
  0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xF7,
  0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF,
  0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x8F, 0xF7, 0xF1, 0xFE, 0xFE, 0x3F, 0x9F,
  0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFB, 0xF7, 0xF3, 0xCF, 0xE3, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xC7, 0xF8,
  0xE0, 0xFF, 0x10, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC3, 0xFC, 0x40, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFB, 0xF8, 0x1F, 0xBF,
  0x81, 0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xE3, 0xF8, 0x7E, 0x3F, 0x87, 0xC3,
  0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x90, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x3F, 0x07, 0xEF, 0xF8, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8,
  0x7F, 0x7F, 0x9F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F,
  0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0x8F, 0xE7, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xCF, 0xF3, 0xF8,
  0xFE, 0xFF, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xDF, 0xEF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xBF, 0x8F, 0xF7, 0xE0, 0x78, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x1E, 0x1F, 0x9F,
  0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xFB, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xE1, 0xFE, 0x40, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x3F, 0x07, 0xFC, 0xF8, 0x7C, 0x3F, 0xFC, 0xF8, 0xF8, 0xFF,
  0xF9, 0xF3, 0xE1, 0xFF, 0xF3, 0xE7, 0xC7, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F,
  0x87, 0x9F, 0x3F, 0x1F, 0x0F, 0x3E, 0x7C, 0x3E, 0x1F, 0xFC, 0xF8, 0x7C,
  0x3D, 0xF1, 0xF0, 0xF8, 0x7B, 0xE3, 0xE1, 0xF1, 0xF7, 0xC7, 0xC3, 0xE3,
  0xE7, 0xCF, 0xC7, 0xC7, 0xCF, 0x8F, 0x9F, 0x9F, 0x1F, 0x1F, 0xFF, 0xFE,
  0x3E, 0x3F, 0xFF, 0xF8, 0x7E, 0x3F, 0xCF, 0xE0, 0x7C, 0x1F, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x01,
  0xFE, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0xD0, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x7F, 0x1F,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xF0, 0xE3, 0xFC, 0x04, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x02, 0x7F, 0xC1, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xC3, 0xFC, 0xFE, 0x0F, 0xF7,
  0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFE, 0x7F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x83, 0x8F, 0xF8, 0x04, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xEF, 0xF0, 0x7F, 0x7F, 0xC3, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x8F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFF, 0x1F, 0xF0, 0x38, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF,
  0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE7,
  0xF8, 0x7F, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7,
  0xF0, 0xFF, 0x3F, 0x87, 0xF9, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07,
  0xFB, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xDF,
  0x8F, 0xFF, 0xFE, 0xFC, 0x7D, 0xFF, 0xF7, 0xE3, 0xEF, 0xFF, 0x9F, 0x3F,
  0x7F, 0xFC, 0xFD, 0xFB, 0xFF, 0xE7, 0xEF, 0x9F, 0xFF, 0x3F, 0x7C, 0xFF,
  0xF8, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x3F, 0xFE, 0x3F, 0xF1, 0xFF, 0xF1,
  0xFF, 0x8F, 0xFF, 0x87, 0xFC, 0x7F, 0xFC, 0x3F, 0xE3, 0xFF, 0xE1, 0xFE,
  0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xC1, 0xFC, 0x3F,
  0xFE, 0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xBF, 0x9F,
  0xFF, 0x7F, 0x3F, 0xFE, 0x7F, 0x7F, 0xFC, 0xFE, 0xFF, 0xF8, 0xFD, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xC1,
  0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x3F, 0xC1, 0xFE, 0x7F,
  0xC7, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xEF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F,
  0x3F, 0xC1, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFB, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x3F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC,
  0x0F, 0xEF, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE,
  0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFD, 0xFE, 0x06, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xEF, 0xE0,
  0xFF, 0x7F, 0x8F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0x03, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0x9F, 0xC1, 0xFF, 0x0F, 0xF3,
  0xF8, 0x3F, 0xE1, 0xFC, 0x3F, 0x07, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x87,
  0xF0, 0xFE, 0x3F, 0xF0, 0xFE, 0x1F, 0xC7, 0xFE, 0x1F, 0xC3, 0xF8, 0xFB,
  0xE7, 0xF8, 0x3F, 0x1F, 0x7C, 0xFE, 0x07, 0xE3, 0xEF, 0x9F, 0xC0, 0xFE,
  0xFD, 0xF3, 0xF8, 0x1F, 0xDF, 0xBE, 0x7F, 0x03, 0xFB, 0xF7, 0xCF, 0xE0,
  0x7F, 0x7E, 0xFD, 0xF8, 0x07, 0xEF, 0x8F, 0xFF, 0x00, 0xFD, 0xF1, 0xFF,
  0xE0, 0x1F, 0xBE, 0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8,
  0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xF9,
  0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFB, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F,
  0xE1, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07,
  0xEF, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xCF, 0xF0, 0x81, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xF7, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFB, 0xF3, 0xFE, 0x7C, 0x7E, 0x1F, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC7, 0xC3, 0xFB, 0xFC,
  0x7F, 0x7F, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x7F, 0xFF, 0xDF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xE7, 0xF8, 0xFC, 0x7E, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF1, 0xFE, 0x08, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0x3F, 0xC1, 0x9F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xF9, 0xFC, 0x7F, 0x9F, 0x8F, 0xFB,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8, 0xFF, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F,
  0xBF, 0xDF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xBF,
  0x0F, 0xE3, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x11, 0xFE, 0x0E,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xC7, 0xE3, 0xFC, 0xFC, 0x7F, 0xDF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xEF, 0xC7, 0xFB, 0xF8, 0x7E, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xB8, 0x0F, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xCF, 0xC3, 0xFB,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFE, 0xFE,
  0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x7F, 0x0F, 0xE3, 0xF3,
  0xFE, 0x7F, 0xCF, 0xDF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x3F, 0xFF, 0xC7, 0xF8,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0x1F,
  0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF,
  0xE1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8,
  0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x1F,
  0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0,
  0x7F, 0xFC, 0x7E, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0xDF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFC, 0x7E,
  0x1F, 0x9F, 0xE3, 0xFB, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xBF, 0xC7, 0xF3, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC7, 0xE3, 0xFC, 0xFC,
  0x7F, 0xDF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB,
  0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF,
  0xE1, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xEF, 0xC7,
  0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0xFC, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xF1, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0,
  0x7F, 0xF9, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xDF, 0xEF, 0x3F, 0x82, 0x7F,
  0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xF9, 0xF8, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xDF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x3F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFC, 0x1F, 0xE1, 0xFD, 0xFC, 0x7F, 0xC3, 0xFB, 0xF8, 0xFF,
  0x87, 0xF7, 0xF1, 0xFF, 0x8F, 0xEF, 0xE3, 0xFF, 0x1F, 0x8F, 0xC7, 0xFE,
  0x3F, 0x1F, 0x8F, 0xFC, 0xFE, 0x3F, 0xBE, 0xF9, 0xFC, 0x7F, 0x7D, 0xF3,
  0xF0, 0xFE, 0xFB, 0xF7, 0xE0, 0xFD, 0xF7, 0xEF, 0xC1, 0xFB, 0xE7, 0xDF,
  0x83, 0xF7, 0xCF, 0xBF, 0x07, 0xEF, 0x9F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x0F, 0xF7, 0xF0, 0xFE,
  0x7F, 0x8F, 0xE3, 0xF9, 0xFE, 0x3F, 0xDF, 0xC1, 0xFD, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xDF, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0xE7,
  0xF8, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xDF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0,
  0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x2F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x1F, 0xF4, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Black43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 17, 11, 21, 2, -31 },
  { 57, 22, 31, 23, 1, -31 },
  { 143, 17, 36, 21, 2, -33 },
  { 220, 34, 31, 36, 1, -31 },
  { 352, 27, 31, 28, 1, -31 },
  { 457, 7, 11, 11, 2, -31 },
  { 467, 12, 39, 14, 2, -32 },
  { 526, 12, 39, 14, 0, -32 },
  { 585, 19, 20, 20, 1, -33 },
  { 633, 19, 21, 22, 1, -26 },
  { 683, 9, 12, 12, 1, -6 },
  { 697, 12, 7, 14, 1, -15 },
  { 708, 8, 9, 12, 2, -8 },
  { 717, 18, 31, 18, 0, -31 },
  { 787, 19, 31, 21, 1, -31 },
  { 861, 15, 31, 21, 2, -31 },
  { 920, 18, 31, 21, 1, -31 },
  { 990, 18, 31, 21, 1, -31 },
  { 1060, 20, 31, 21, 1, -31 },
  { 1138, 17, 31, 21, 2, -31 },
  { 1204, 19, 31, 21, 1, -31 },
  { 1278, 18, 31, 21, 2, -31 },
  { 1348, 19, 31, 21, 1, -31 },
  { 1422, 19, 31, 21, 1, -31 },
  { 1496, 8, 25, 12, 2, -24 },
  { 1521, 9, 30, 12, 1, -24 },
  { 1555, 19, 21, 22, 1, -26 },
  { 1605, 19, 15, 22, 1, -23 },
  { 1641, 19, 21, 22, 1, -26 },
  { 1691, 17, 32, 17, 0, -31 },
  { 1759, 31, 34, 33, 1, -31 },
  { 1891, 25, 31, 25, 0, -31 },
  { 1988, 19, 31, 24, 3, -31 },
  { 2062, 19, 31, 22, 2, -31 },
  { 2136, 21, 31, 25, 3, -31 },
  { 2218, 14, 31, 19, 3, -31 },
  { 2273, 14, 31, 19, 3, -31 },
  { 2328, 21, 31, 26, 2, -31 },
  { 2410, 21, 31, 26, 3, -31 },
  { 2492, 13, 31, 15, 1, -31 },
  { 2543, 13, 41, 12, -3, -31 },
  { 2610, 21, 31, 24, 3, -31 },
  { 2692, 15, 31, 18, 3, -31 },
  { 2751, 29, 31, 35, 3, -31 },
  { 2864, 23, 31, 28, 3, -31 },
  { 2954, 23, 31, 27, 2, -31 },
  { 3044, 18, 31, 22, 3, -31 },
  { 3114, 23, 38, 27, 2, -31 },
  { 3224, 21, 31, 23, 3, -31 },
  { 3306, 17, 31, 20, 1, -31 },
  { 3372, 18, 31, 20, 1, -31 },
  { 3442, 21, 31, 25, 2, -31 },
  { 3524, 24, 31, 24, 0, -31 },
  { 3617, 35, 31, 35, 0, -31 },
  { 3753, 22, 31, 22, 0, -31 },
  { 3839, 23, 31, 23, 0, -31 },
  { 3929, 18, 31, 20, 1, -31 },
  { 3999, 10, 39, 13, 2, -32 },
  { 4048, 18, 31, 18, 0, -31 },
  { 4118, 10, 39, 13, 1, -32 },
  { 4167, 23, 21, 23, 0, -31 },
  { 4228, 22, 5, 22, 0, 3 },
  { 4242, 11, 7, 15, 2, -33 },
  { 4252, 18, 24, 21, 1, -24 },
  { 4306, 19, 33, 23, 2, -33 },
  { 4385, 17, 24, 19, 1, -24 },
  { 4436, 19, 33, 23, 1, -33 },
  { 4515, 19, 24, 21, 1, -24 },
  { 4572, 15, 33, 14, 0, -33 },
  { 4634, 19, 34, 23, 1, -24 },
  { 4715, 19, 33, 23, 2, -33 },
  { 4794, 7, 33, 11, 2, -33 },
  { 4823, 11, 43, 11, -2, -33 },
  { 4883, 21, 33, 22, 2, -33 },
  { 4970, 7, 33, 11, 2, -33 },
  { 4999, 30, 24, 34, 2, -24 },
  { 5089, 19, 24, 23, 2, -24 },
  { 5146, 20, 24, 22, 1, -24 },
  { 5206, 19, 34, 23, 2, -24 },
  { 5287, 19, 34, 23, 1, -24 },
  { 5368, 14, 24, 16, 2, -24 },
  { 5410, 15, 24, 17, 1, -24 },
  { 5455, 14, 29, 15, 0, -29 },
  { 5506, 19, 24, 23, 2, -24 },
  { 5563, 21, 24, 21, 0, -24 },
  { 5626, 31, 24, 32, 0, -24 },
  { 5719, 20, 24, 20, 0, -24 },
  { 5779, 21, 34, 21, 0, -24 },
  { 5869, 15, 24, 17, 1, -24 },
  { 5914, 14, 38, 16, 1, -31 },
  { 5981, 6, 43, 18, 6, -33 },
  { 6014, 14, 38, 16, 1, -31 },
  { 6081, 19, 8, 22, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Black43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK43PT7B_H_
