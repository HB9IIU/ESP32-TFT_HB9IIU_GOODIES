#ifndef _NOTOSANS_EXTRACONDENSED_BLACK17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xEF, 0x9B, 0x36, 0x60, 0x1B, 0x0D,
  0x86, 0xCF, 0xF7, 0xF9, 0xB0, 0xD9, 0xFF, 0xFF, 0x9B, 0x0D, 0x8D, 0x80,
  0x10, 0x73, 0xF6, 0xED, 0x1E, 0x1E, 0x1E, 0x1F, 0x2F, 0xF7, 0xE1, 0x02,
  0x00, 0x78, 0xE1, 0xE3, 0x0E, 0xDC, 0x3B, 0x60, 0xED, 0x81, 0xED, 0xE7,
  0xB7, 0xC1, 0x9B, 0x06, 0xEC, 0x19, 0xB0, 0xC7, 0x83, 0x0E, 0x3E, 0x07,
  0xE1, 0xDC, 0x1B, 0x83, 0xE0, 0x79, 0xDF, 0xF3, 0x7E, 0xE7, 0xDE, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFB, 0x60, 0x7B, 0x39, 0xCE, 0x63, 0x18, 0xC7, 0x39,
  0xC6, 0x38, 0xE0, 0xE3, 0x9C, 0x63, 0x9C, 0xE7, 0x39, 0xCC, 0x67, 0x33,
  0x80, 0x18, 0x18, 0x7E, 0xFF, 0x3C, 0x7E, 0x66, 0x24, 0x30, 0x60, 0xC7,
  0xFF, 0xE6, 0x0C, 0x18, 0xFF, 0x60, 0xFF, 0xFE, 0xFF, 0x80, 0x0E, 0x1C,
  0x30, 0xE1, 0x83, 0x0E, 0x18, 0x70, 0xC1, 0x87, 0x00, 0x79, 0xFB, 0xB7,
  0x7C, 0xF9, 0xF3, 0xE7, 0xEF, 0xDB, 0xF3, 0xC0, 0x1C, 0xF7, 0xFF, 0xDC,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x7C, 0xFE, 0x6E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0xFF, 0xFF, 0xFD, 0xFA, 0x70, 0x61, 0xCF, 0x1F, 0x0F,
  0x0F, 0x3F, 0xF7, 0xC0, 0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x6E, 0x6E, 0xFF,
  0xFF, 0xFF, 0x0E, 0x0E, 0xFD, 0xFB, 0x87, 0x0F, 0x9F, 0x97, 0x87, 0x0F,
  0x3F, 0xF7, 0xC0, 0x3C, 0xFB, 0x86, 0x0D, 0xDF, 0xBB, 0xE7, 0xCF, 0xDF,
  0xF3, 0xC0, 0xFF, 0xFC, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC7,
  0x80, 0x7D, 0xFB, 0xBF, 0x6F, 0xCF, 0x3F, 0x77, 0xCF, 0x9F, 0xFB, 0xE0,
  0x79, 0xFB, 0xBE, 0x7C, 0xFF, 0xFF, 0xB7, 0x0C, 0x3B, 0xE7, 0x80, 0x5F,
  0xA0, 0x07, 0xFC, 0x5F, 0xA0, 0x00, 0xFF, 0x60, 0x03, 0x0F, 0x3E, 0xF8,
  0xF8, 0x3F, 0x07, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xE1,
  0xF0, 0xF3, 0xFF, 0x38, 0x40, 0x7D, 0xF9, 0x38, 0x71, 0xC7, 0x0C, 0x18,
  0x00, 0x61, 0xE1, 0x80, 0x1F, 0x8F, 0x39, 0x81, 0xE7, 0xBD, 0xB7, 0xB6,
  0x76, 0xCE, 0xDB, 0xDF, 0xF9, 0xBB, 0x80, 0x38, 0xC3, 0xF8, 0x1E, 0x07,
  0x83, 0xE0, 0xFC, 0x37, 0x0D, 0xC7, 0x31, 0xFE, 0x7F, 0x9F, 0xEE, 0x3B,
  0x87, 0xFC, 0xFE, 0xEF, 0xE7, 0xEE, 0xFC, 0xFE, 0xE7, 0xE7, 0xEF, 0xFE,
  0xFC, 0x3E, 0xFF, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE5, 0xF9, 0xF0,
  0xFC, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFE, 0xFC,
  0xFF, 0xFE, 0x38, 0xFF, 0xFF, 0xF8, 0xE3, 0x8F, 0xFF, 0xFF, 0xFE, 0x38,
  0xE3, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0x3F, 0x7F, 0xF1, 0xE0, 0xE0, 0xEF,
  0xEF, 0xE7, 0xE7, 0xF7, 0x7F, 0x3F, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xCF, 0xFF, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF,
  0xDC, 0xE7, 0xF3, 0xBB, 0x9D, 0xCF, 0xC7, 0xE3, 0xF1, 0xFC, 0xEE, 0x77,
  0x39, 0xDC, 0xF0, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF,
  0xF0, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xBF, 0xFF, 0x7E, 0xF7,
  0xEF, 0x7E, 0xF7, 0xEE, 0x7E, 0x67, 0xF3, 0xF9, 0xFC, 0xFF, 0x7F, 0xBF,
  0xFF, 0xF7, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0x70, 0x3E, 0x3F, 0xB9, 0xDC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0x9F, 0xC7, 0xC0, 0xFD, 0xFF,
  0xBF, 0x7E, 0xFF, 0xFF, 0xFE, 0xE1, 0xC3, 0x87, 0x00, 0x3E, 0x3F, 0xB9,
  0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0x9F, 0xC7, 0xC0, 0xE0,
  0x38, 0x1E, 0xFC, 0xFE, 0xEE, 0xEE, 0xEE, 0xFE, 0xFC, 0xFC, 0xEE, 0xEE,
  0xE7, 0xE7, 0x3E, 0xFD, 0xDB, 0x87, 0x8F, 0x8F, 0x87, 0x8F, 0xFF, 0xFB,
  0xE0, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7E,
  0x7E, 0xE3, 0xF8, 0xE7, 0x39, 0xCE, 0x73, 0x1D, 0xC3, 0x70, 0xFC, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0xE3, 0x1F, 0x9C, 0x66, 0x7B, 0x99, 0xEE, 0x77,
  0xB9, 0xDE, 0xE7, 0xFB, 0x9F, 0x6C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0xE7, 0x3B, 0x9D, 0x87, 0xC3, 0xE0, 0xE0, 0xF0, 0x7C, 0x3E, 0x3B,
  0x9D, 0xDC, 0x70, 0xE3, 0xBB, 0x9D, 0xCE, 0xC3, 0xE1, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF,
  0xF0, 0xE0, 0xC1, 0xC3, 0x83, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x0C, 0x0E, 0x07, 0x87,
  0xC3, 0x63, 0x99, 0x8D, 0xC7, 0xFF, 0xFF, 0xC0, 0xE7, 0x30, 0x18, 0x7E,
  0x3E, 0x07, 0x3F, 0x7F, 0xE7, 0xE7, 0x7F, 0x77, 0xE1, 0xC3, 0x87, 0x4F,
  0xFF, 0xFB, 0xF3, 0xE7, 0xCF, 0xBF, 0xFD, 0xC0, 0x11, 0xFF, 0xF8, 0xC3,
  0x0C, 0x39, 0xFD, 0xF0, 0x0E, 0x1C, 0x39, 0x7F, 0xFF, 0xFB, 0xE7, 0xCF,
  0x9F, 0xBF, 0xF7, 0x60, 0x10, 0xFB, 0xF6, 0x7F, 0xFF, 0xF0, 0x71, 0xFC,
  0xF8, 0x3D, 0xF7, 0x1C, 0xFB, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x21,
  0xEF, 0xFF, 0x7C, 0xF9, 0xF3, 0xF7, 0xFE, 0xFC, 0x3C, 0x7F, 0xDF, 0x00,
  0xE1, 0xC3, 0x87, 0x4D, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xE0,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x39, 0xCC, 0x03, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE1, 0xEE, 0xEE, 0xFC, 0xF8,
  0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x08, 0xCD,
  0xFE, 0xFF, 0xEE, 0xE7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E,
  0xE7, 0x09, 0xBF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDC, 0x10, 0xFB,
  0xFF, 0x7C, 0xF9, 0xF3, 0xF7, 0xFC, 0xF8, 0x09, 0xBB, 0xFF, 0x7E, 0x7C,
  0xF9, 0xF7, 0xFF, 0xFB, 0x87, 0x0E, 0x1C, 0x00, 0x21, 0xEF, 0xFF, 0x7C,
  0xF9, 0xF3, 0xF7, 0xFE, 0xFC, 0x38, 0x70, 0xE1, 0xC0, 0x0E, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x00, 0x11, 0xFF, 0xF8, 0x79, 0xF1, 0xE3, 0xFF, 0xE0,
  0x31, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x75, 0xF3, 0xC0, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xFF, 0x76, 0xE7, 0x67, 0x66, 0x76, 0x7E, 0x3E, 0x3C,
  0x3C, 0x1C, 0xE7, 0x3E, 0xF7, 0x6F, 0x76, 0xF7, 0x7D, 0xE7, 0xDE, 0x3D,
  0xE3, 0x9E, 0x39, 0xE0, 0xE7, 0x7E, 0x7E, 0x3C, 0x3C, 0x3C, 0x7E, 0x7E,
  0xE7, 0xE7, 0x67, 0x76, 0x76, 0x3E, 0x3E, 0x3C, 0x3C, 0x1C, 0x18, 0x38,
  0x78, 0x70, 0xFF, 0xF1, 0xCE, 0x39, 0xC7, 0x3F, 0xFC, 0x3C, 0xF3, 0x8E,
  0x38, 0xEF, 0x3C, 0x70, 0xE3, 0x8E, 0x38, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF3, 0xC3, 0x0C, 0x30, 0xC3, 0xC7, 0x38, 0xC3,
  0x0C, 0x73, 0xCE, 0x00, 0x21, 0xFF, 0xFF, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_Black17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 7, 4, 8, 1, -12 },
  { 10, 9, 12, 9, 0, -12 },
  { 24, 7, 14, 8, 1, -13 },
  { 37, 14, 12, 14, 0, -12 },
  { 58, 11, 12, 11, 0, -12 },
  { 75, 3, 4, 4, 1, -12 },
  { 77, 5, 15, 6, 1, -12 },
  { 87, 5, 15, 6, 0, -12 },
  { 97, 8, 8, 8, 0, -13 },
  { 105, 7, 8, 9, 1, -10 },
  { 112, 3, 4, 5, 1, -2 },
  { 114, 5, 3, 6, 0, -6 },
  { 116, 3, 3, 5, 1, -3 },
  { 118, 7, 12, 7, 0, -12 },
  { 129, 7, 12, 8, 1, -12 },
  { 140, 6, 12, 8, 1, -12 },
  { 149, 8, 12, 8, 0, -12 },
  { 161, 7, 12, 8, 1, -12 },
  { 172, 8, 12, 8, 0, -12 },
  { 184, 7, 12, 8, 1, -12 },
  { 195, 7, 12, 8, 1, -12 },
  { 206, 7, 12, 8, 1, -12 },
  { 217, 7, 12, 8, 1, -12 },
  { 228, 7, 12, 8, 1, -12 },
  { 239, 3, 10, 5, 1, -10 },
  { 243, 3, 12, 5, 1, -10 },
  { 248, 8, 8, 9, 0, -10 },
  { 256, 7, 6, 9, 1, -9 },
  { 262, 7, 8, 9, 1, -10 },
  { 269, 7, 12, 7, 0, -12 },
  { 280, 11, 13, 13, 1, -12 },
  { 298, 10, 12, 10, 0, -12 },
  { 313, 8, 12, 9, 1, -12 },
  { 325, 7, 12, 9, 1, -12 },
  { 336, 8, 12, 10, 1, -12 },
  { 348, 6, 12, 8, 1, -12 },
  { 357, 6, 12, 7, 1, -12 },
  { 366, 8, 12, 10, 1, -12 },
  { 378, 8, 12, 10, 1, -12 },
  { 390, 6, 12, 6, 0, -12 },
  { 399, 5, 16, 5, -1, -12 },
  { 409, 9, 12, 9, 1, -12 },
  { 423, 6, 12, 7, 1, -12 },
  { 432, 12, 12, 14, 1, -12 },
  { 450, 9, 12, 11, 1, -12 },
  { 464, 9, 12, 11, 1, -12 },
  { 478, 7, 12, 9, 1, -12 },
  { 489, 9, 15, 11, 1, -12 },
  { 506, 8, 12, 9, 1, -12 },
  { 518, 7, 12, 8, 0, -12 },
  { 529, 8, 12, 8, 0, -12 },
  { 541, 8, 12, 10, 1, -12 },
  { 553, 10, 12, 10, 0, -12 },
  { 568, 14, 12, 14, 0, -12 },
  { 589, 9, 12, 9, 0, -12 },
  { 603, 9, 12, 9, 0, -12 },
  { 617, 8, 12, 8, 0, -12 },
  { 629, 4, 15, 5, 1, -12 },
  { 637, 7, 12, 7, 0, -12 },
  { 648, 4, 15, 5, 0, -12 },
  { 656, 9, 8, 9, 0, -12 },
  { 665, 9, 2, 9, 0, 1 },
  { 668, 4, 3, 6, 1, -13 },
  { 670, 8, 10, 8, 0, -10 },
  { 680, 7, 13, 9, 1, -13 },
  { 692, 6, 10, 7, 1, -10 },
  { 700, 7, 13, 9, 1, -13 },
  { 712, 7, 10, 8, 1, -10 },
  { 721, 6, 13, 6, 0, -13 },
  { 731, 7, 14, 9, 1, -10 },
  { 744, 7, 13, 9, 1, -13 },
  { 756, 3, 13, 5, 1, -13 },
  { 761, 5, 17, 5, -1, -13 },
  { 772, 8, 13, 9, 1, -13 },
  { 785, 3, 13, 4, 1, -13 },
  { 790, 12, 10, 13, 1, -10 },
  { 805, 7, 10, 9, 1, -10 },
  { 814, 7, 10, 9, 1, -10 },
  { 823, 7, 14, 9, 1, -10 },
  { 836, 7, 14, 9, 1, -10 },
  { 849, 5, 10, 6, 1, -10 },
  { 856, 6, 10, 7, 0, -10 },
  { 864, 6, 11, 6, 0, -11 },
  { 873, 7, 9, 9, 1, -9 },
  { 881, 8, 9, 8, 0, -9 },
  { 890, 12, 9, 13, 0, -9 },
  { 904, 8, 9, 8, 0, -9 },
  { 913, 8, 13, 8, 0, -9 },
  { 926, 6, 9, 7, 0, -9 },
  { 933, 6, 15, 6, 0, -12 },
  { 945, 3, 17, 7, 2, -13 },
  { 952, 6, 15, 6, 0, -12 },
  { 964, 8, 4, 9, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Black17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK17PT7B_H_
