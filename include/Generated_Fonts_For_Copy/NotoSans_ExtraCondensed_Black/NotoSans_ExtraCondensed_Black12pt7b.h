#ifndef _NOTOSANS_EXTRACONDENSED_BLACK12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black12pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0x83, 0x60, 0xFA, 0xD6, 0xB0, 0x3C, 0xB2, 0x9F, 0x2B,
  0xFF, 0xDE, 0x58, 0x2F, 0xBA, 0xF3, 0xBF, 0x62, 0x63, 0x1C, 0x8D, 0x63,
  0x50, 0x7F, 0x9A, 0xF0, 0xAC, 0x6F, 0x11, 0x80, 0x30, 0x78, 0x6C, 0x78,
  0x76, 0x7E, 0xDE, 0xFE, 0x7F, 0xE9, 0x20, 0x7B, 0x69, 0x26, 0xD9, 0x80,
  0xCD, 0xB6, 0x5B, 0x6F, 0x00, 0x33, 0xEF, 0xDC, 0x58, 0x30, 0xCF, 0xFF,
  0x30, 0xC0, 0x6D, 0x60, 0xFF, 0xF0, 0x18, 0xC4, 0x62, 0x31, 0x88, 0xC0,
  0x31, 0xE7, 0xB6, 0xCF, 0x25, 0x9E, 0x78, 0x19, 0xDF, 0xB1, 0x8C, 0x63,
  0x18, 0x37, 0xD6, 0x31, 0x99, 0x9F, 0xF8, 0x77, 0xD6, 0x37, 0x1C, 0x7F,
  0xF8, 0x18, 0xE3, 0x9E, 0x5B, 0x6F, 0xC6, 0x18, 0xFF, 0xCE, 0xF3, 0x3F,
  0xF0, 0x19, 0xE6, 0x16, 0xFB, 0x3C, 0xDE, 0x78, 0xFF, 0xF1, 0x86, 0x18,
  0xC3, 0x0C, 0x60, 0x31, 0xE5, 0x9E, 0x31, 0xEC, 0xFE, 0x78, 0x31, 0xED,
  0xB3, 0xFD, 0xA1, 0x9E, 0x70, 0xB8, 0x3C, 0x4D, 0x00, 0xDA, 0xC0, 0x0C,
  0xEE, 0x1E, 0x1C, 0x10, 0xFC, 0x0F, 0xFF, 0xC1, 0xC1, 0xDE, 0xE2, 0x00,
  0x67, 0xA6, 0x67, 0x30, 0x0C, 0x60, 0x1C, 0x1B, 0x9A, 0x4B, 0xFD, 0x7E,
  0xAF, 0x7C, 0x94, 0x62, 0x0F, 0x00, 0x38, 0x70, 0xA3, 0x66, 0xCD, 0x9F,
  0x67, 0xC6, 0xE7, 0xF7, 0xBF, 0x6F, 0x7F, 0xF0, 0x19, 0xF6, 0x58, 0xE3,
  0x86, 0x1F, 0x3C, 0xE3, 0xED, 0xB7, 0xDF, 0x7D, 0xBE, 0xF0, 0xFF, 0xCC,
  0xFC, 0xCF, 0xF0, 0xFF, 0xCC, 0xFF, 0xCC, 0xC0, 0x1C, 0xF9, 0x93, 0x0E,
  0xED, 0xD9, 0xBF, 0x3E, 0xCF, 0x3C, 0xF3, 0xFF, 0x3C, 0xF3, 0xCC, 0xFF,
  0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xEC, 0xCF, 0x6F,
  0xBC, 0xF3, 0xCD, 0xB6, 0xDC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xEF, 0xFF, 0xFB, 0xFB, 0xDB, 0xDB, 0xCF, 0xBE, 0xFB, 0xFF, 0xFD,
  0xF7, 0xCC, 0x18, 0xF9, 0xBB, 0x3E, 0x6C, 0xD9, 0xBE, 0x3C, 0xE7, 0xF7,
  0xBF, 0xFB, 0x18, 0xC0, 0x18, 0xF9, 0xBB, 0x3E, 0x6C, 0xD9, 0xBE, 0x3C,
  0x18, 0x38, 0xE3, 0xED, 0xB6, 0xFB, 0xCF, 0x36, 0xDC, 0x33, 0xF3, 0xC7,
  0x1C, 0x7F, 0xF0, 0xFF, 0xCC, 0x63, 0x18, 0xC6, 0x30, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7F, 0x70, 0xC7, 0x99, 0xB3, 0x66, 0xCD, 0x0E, 0x1C, 0x38, 0xCC,
  0xF3, 0x3C, 0xD9, 0x76, 0x7D, 0x9F, 0xE7, 0x79, 0xDC, 0x33, 0x00, 0xCD,
  0xF7, 0x9E, 0x30, 0xE7, 0x9F, 0xCC, 0xCF, 0x36, 0x9E, 0x38, 0xC3, 0x0C,
  0x30, 0xFF, 0xC6, 0x63, 0x31, 0x9F, 0xF8, 0xFF, 0x6D, 0xB6, 0xDB, 0x80,
  0xC6, 0x18, 0xC2, 0x18, 0xC2, 0x18, 0xFD, 0xB6, 0xDB, 0x6F, 0x80, 0x10,
  0xC3, 0x9E, 0x6F, 0x30, 0xFC, 0xE3, 0x33, 0xC6, 0xFD, 0xED, 0xA0, 0xC6,
  0x3D, 0xFD, 0xEF, 0x7F, 0xB0, 0x33, 0xD9, 0x8C, 0x3D, 0xE0, 0x0C, 0x36,
  0xDF, 0xCF, 0x3C, 0xDF, 0x7C, 0x33, 0xF3, 0xFC, 0x35, 0xE0, 0x77, 0x7F,
  0x66, 0x66, 0x60, 0x2D, 0xFC, 0xF3, 0xCD, 0xF7, 0xC3, 0x79, 0xC0, 0xC6,
  0x2D, 0xFD, 0xEF, 0x7B, 0xD8, 0xEF, 0xFF, 0xC0, 0x69, 0xB6, 0xDB, 0x6F,
  0x60, 0xC6, 0x37, 0xFF, 0x7B, 0xDB, 0xD8, 0xFF, 0xFF, 0xC0, 0xB6, 0xFF,
  0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xB7, 0xF7, 0xBD, 0xEF, 0x60, 0x31, 0xE4,
  0xF3, 0xCD, 0xE7, 0x80, 0xB7, 0xF7, 0xBD, 0xFF, 0xD8, 0xC6, 0x00, 0x2D,
  0xFC, 0xF3, 0xCD, 0xF7, 0xC3, 0x0C, 0x30, 0xBF, 0x6D, 0xB0, 0x7F, 0xC7,
  0x3F, 0xF0, 0x67, 0xF6, 0x66, 0x77, 0xDE, 0xF7, 0xBD, 0xFF, 0xE0, 0xCF,
  0x35, 0x9E, 0x79, 0xC3, 0x00, 0xDD, 0xEE, 0xD7, 0xCA, 0xE7, 0x73, 0xB9,
  0xD8, 0xDD, 0xE7, 0x8C, 0x79, 0xED, 0xC0, 0xCF, 0x37, 0x9E, 0x78, 0xC3,
  0x0C, 0x61, 0x80, 0xF7, 0x8C, 0xC6, 0x7F, 0xE0, 0x37, 0x66, 0x6E, 0x66,
  0x67, 0x30, 0xFF, 0xF0, 0xCE, 0x66, 0x63, 0x76, 0x6E, 0xE0, 0xFE, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_Black12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 5, 4, 6, 0, -9 },
  { 8, 6, 9, 7, 0, -9 },
  { 15, 4, 10, 6, 1, -9 },
  { 20, 10, 9, 10, 0, -9 },
  { 32, 8, 9, 8, 0, -9 },
  { 41, 3, 4, 3, 0, -9 },
  { 43, 3, 11, 4, 1, -9 },
  { 48, 3, 11, 4, 0, -9 },
  { 53, 6, 5, 6, 0, -9 },
  { 57, 6, 6, 6, 0, -7 },
  { 62, 3, 4, 3, 0, -2 },
  { 64, 4, 2, 4, 0, -4 },
  { 65, 2, 2, 3, 1, -2 },
  { 66, 5, 9, 5, 0, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 5, 9, 6, 0, -9 },
  { 85, 5, 9, 6, 0, -9 },
  { 91, 5, 9, 6, 0, -9 },
  { 97, 6, 9, 6, 0, -9 },
  { 104, 4, 9, 6, 1, -9 },
  { 109, 6, 9, 6, 0, -9 },
  { 116, 6, 9, 6, 0, -9 },
  { 123, 6, 9, 6, 0, -9 },
  { 130, 6, 9, 6, 0, -9 },
  { 137, 2, 7, 3, 1, -7 },
  { 139, 3, 9, 3, 0, -7 },
  { 143, 6, 6, 6, 0, -7 },
  { 148, 6, 4, 6, 0, -6 },
  { 151, 6, 6, 6, 0, -7 },
  { 156, 5, 9, 5, 0, -9 },
  { 162, 9, 10, 9, 0, -9 },
  { 174, 7, 9, 7, 0, -9 },
  { 182, 5, 9, 7, 1, -9 },
  { 188, 6, 9, 6, 0, -9 },
  { 195, 6, 9, 7, 1, -9 },
  { 202, 4, 9, 5, 1, -9 },
  { 207, 4, 9, 5, 1, -9 },
  { 212, 7, 9, 7, 0, -9 },
  { 220, 6, 9, 7, 1, -9 },
  { 227, 4, 9, 4, 0, -9 },
  { 232, 4, 12, 3, -1, -9 },
  { 238, 6, 9, 7, 1, -9 },
  { 245, 4, 9, 5, 1, -9 },
  { 250, 8, 9, 10, 1, -9 },
  { 259, 6, 9, 8, 1, -9 },
  { 266, 7, 9, 7, 0, -9 },
  { 274, 5, 9, 6, 1, -9 },
  { 280, 7, 11, 7, 0, -9 },
  { 290, 6, 9, 7, 1, -9 },
  { 297, 5, 9, 5, 0, -9 },
  { 303, 5, 9, 6, 0, -9 },
  { 309, 5, 9, 7, 1, -9 },
  { 315, 7, 9, 7, 0, -9 },
  { 323, 10, 9, 10, 0, -9 },
  { 335, 6, 9, 6, 0, -9 },
  { 342, 6, 9, 6, 0, -9 },
  { 349, 5, 9, 6, 0, -9 },
  { 355, 3, 11, 4, 0, -9 },
  { 360, 5, 9, 5, 0, -9 },
  { 366, 3, 11, 4, 0, -9 },
  { 371, 6, 6, 6, 0, -9 },
  { 376, 6, 1, 6, 0, 1 },
  { 377, 4, 2, 4, 0, -9 },
  { 378, 5, 7, 6, 0, -7 },
  { 383, 5, 9, 6, 1, -9 },
  { 389, 5, 7, 5, 0, -7 },
  { 394, 6, 9, 6, 0, -9 },
  { 401, 5, 7, 6, 0, -7 },
  { 406, 4, 9, 4, 0, -9 },
  { 411, 6, 10, 6, 0, -7 },
  { 419, 5, 9, 6, 1, -9 },
  { 425, 2, 9, 3, 1, -9 },
  { 428, 3, 12, 3, 0, -9 },
  { 433, 5, 9, 6, 1, -9 },
  { 439, 2, 9, 3, 1, -9 },
  { 442, 8, 7, 9, 1, -7 },
  { 449, 5, 7, 6, 1, -7 },
  { 454, 6, 7, 6, 0, -7 },
  { 460, 5, 10, 6, 1, -7 },
  { 467, 6, 10, 6, 0, -7 },
  { 475, 3, 7, 5, 1, -7 },
  { 478, 4, 7, 5, 0, -7 },
  { 482, 4, 8, 4, 0, -8 },
  { 486, 5, 7, 6, 1, -7 },
  { 491, 6, 7, 6, 0, -7 },
  { 497, 9, 7, 9, 0, -7 },
  { 505, 6, 7, 6, 0, -7 },
  { 511, 6, 10, 6, 0, -7 },
  { 519, 5, 7, 5, 0, -7 },
  { 524, 4, 11, 4, 0, -9 },
  { 530, 1, 12, 5, 2, -9 },
  { 532, 4, 11, 4, 0, -9 },
  { 538, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Black12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK12PT7B_H_
