#ifndef _NOTOSANS_EXTRACONDENSED_BLACK33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x00, 0x00, 0xE3, 0xEF, 0xDF, 0x9F, 0x3E, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x78, 0x78, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x73, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x7C, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0xBE, 0xE2, 0xFB, 0x81, 0xEE, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0E,
  0xF4, 0x3B, 0xDC, 0xFF, 0x7F, 0xF9, 0xFF, 0xC7, 0xFE, 0x03, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x07,
  0xF8, 0x1E, 0x03, 0xFF, 0x0F, 0x00, 0xF3, 0xC3, 0xC0, 0x3C, 0xF0, 0xF0,
  0x0F, 0x3C, 0x78, 0x03, 0xCF, 0x1E, 0x00, 0xF3, 0xCF, 0x00, 0x3C, 0xF3,
  0xC2, 0x0F, 0x3C, 0xF3, 0xF3, 0xFF, 0x79, 0xFC, 0x7F, 0x9E, 0xFF, 0x8F,
  0xCF, 0x3D, 0xE1, 0xE3, 0xCF, 0x3C, 0x01, 0xE7, 0xCF, 0x00, 0x79, 0xF3,
  0xC0, 0x1E, 0x7C, 0xF0, 0x0F, 0x0F, 0x3C, 0x03, 0xC3, 0xCF, 0x01, 0xE0,
  0xF7, 0x80, 0x78, 0x3F, 0xE0, 0x1E, 0x07, 0xF0, 0x0F, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0x3E, 0x3F, 0xE7, 0xE7, 0xFF, 0x7E, 0xFF, 0xFF,
  0xEF, 0x9F, 0xFC, 0xF8, 0xFF, 0xCF, 0x87, 0xF8, 0xFC, 0x7F, 0x8F, 0xEF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF,
  0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x78, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x87, 0xC3,
  0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1F, 0x8F, 0x8F, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0x1E, 0x27,
  0xBF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0x7F,
  0xE1, 0xF3, 0xE3, 0xE7, 0x81, 0x86, 0x01, 0x08, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0xBE, 0x7C, 0xF9, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0xF9, 0xF7, 0xF7, 0xCF, 0x80, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7F,
  0xF9, 0xF3, 0xE7, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7D, 0xF3, 0xF7,
  0xCF, 0xDF, 0xFE, 0x7F, 0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0x01, 0xF0,
  0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xFF, 0xFF, 0x7D, 0xF3,
  0x9F, 0x11, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80,
  0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9, 0xC7, 0xE2, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x7F,
  0xF8, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x07,
  0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF7, 0xE3, 0xEF, 0xC7, 0x9F, 0x9F, 0x3F,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0xEF, 0xFF, 0x31, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0xEF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF0, 0x01, 0xF8,
  0x1F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0xC3, 0xEF, 0xCF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xF7, 0xCF, 0xDF, 0xBF, 0x7F, 0xF8, 0xFF,
  0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7F, 0xFD, 0xF3, 0xF7, 0xC7, 0xDF, 0x3F,
  0x7E, 0xF8, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF,
  0xBF, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF,
  0xE3, 0xFF, 0x87, 0xF8, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7F,
  0xFB, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFD, 0xFF, 0xF3, 0xF7, 0xC7, 0x9F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x91, 0xFE, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x23, 0xEF,
  0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xEF,
  0x80, 0x10, 0xF9, 0xFB, 0xF7, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xBE, 0x7C, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x78, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0x3F, 0xC0,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x01,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x60, 0x00, 0x0F, 0x83, 0xFF, 0x3F, 0xFD, 0xFF, 0xE7, 0xFF,
  0xB0, 0xFD, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7E, 0x1F, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F,
  0x8F, 0x0F, 0xCF, 0x3C, 0x7F, 0xCF, 0x79, 0xFF, 0x9E, 0xE3, 0xCF, 0x3F,
  0xCF, 0x9E, 0x7F, 0x9E, 0x3C, 0xFF, 0x3C, 0x79, 0xFE, 0x78, 0xF3, 0xFC,
  0xF1, 0xE7, 0xF9, 0xE3, 0xCF, 0xF3, 0xCF, 0x9D, 0xE3, 0xFF, 0xF9, 0xE7,
  0xF7, 0xE3, 0xC7, 0xC7, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x18, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0xFC,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7D,
  0xFB, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0xBF, 0x3F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFE, 0x7F, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE3,
  0xFF, 0xC7, 0xE1, 0x9F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x11, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03,
  0xFC, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFC,
  0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7E, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x11, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0xC7, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xEB, 0xFB, 0xFE, 0xFF, 0x3F, 0xCF, 0xE0, 0xFC, 0x1F, 0xFE, 0x1F, 0xBF,
  0x1F, 0xDF, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xE3, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F,
  0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xEF, 0x3F, 0xFF, 0xDF, 0x7F, 0xFF, 0xBE, 0xF7, 0xFF,
  0x7D, 0xEF, 0xFE, 0x7F, 0xDF, 0xFC, 0xFF, 0xBF, 0xF9, 0xFE, 0x7F, 0xF3,
  0xFC, 0xFF, 0xE3, 0xF9, 0xFF, 0xC7, 0xE3, 0xFF, 0x8F, 0xC7, 0xFF, 0x1F,
  0x8F, 0xFE, 0x1F, 0x1F, 0xFC, 0x3C, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xBE, 0xFF, 0xEF, 0x9F, 0xFB, 0xF7,
  0xFE, 0x7D, 0xFF, 0x9F, 0x7F, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x9F, 0xC7, 0xE7, 0xE1, 0xFD, 0xF8, 0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0x8F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x9F, 0xC7, 0xE7, 0xE1, 0xFD, 0xF8, 0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xFD, 0xF8, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0x7C, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3F, 0x0F, 0xC1, 0xFF,
  0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x3B, 0xF0, 0x5F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFC, 0x07, 0xFF, 0x03, 0xF7, 0xC0,
  0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0x9F, 0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E,
  0x3F, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x07,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F,
  0x83, 0xE7, 0xC3, 0xF0, 0xFC, 0xF8, 0x7F, 0x1F, 0x9F, 0x0F, 0xE3, 0xF3,
  0xF1, 0xFC, 0x7C, 0x3E, 0x7F, 0x8F, 0x87, 0xCF, 0xF1, 0xF0, 0xF9, 0xEE,
  0x7E, 0x1F, 0x3D, 0xEF, 0xC3, 0xE7, 0xBD, 0xF0, 0x7E, 0xF7, 0xBE, 0x07,
  0xFE, 0xF7, 0xC0, 0xFF, 0x9E, 0xF8, 0x1F, 0xF3, 0xDF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0xFC, 0x3F, 0x3E,
  0x1F, 0x9F, 0x8F, 0xC7, 0xC7, 0xC3, 0xF7, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F,
  0xDF, 0x87, 0xEF, 0xC3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE3, 0xE3, 0xF1, 0xF9,
  0xF0, 0xFC, 0xF8, 0x3E, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0xC0,
  0xFB, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x03, 0x00, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF8, 0xC3, 0xF0, 0x0F, 0xC0, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFD, 0xF3, 0xE3, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x8C, 0x3E, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xF3, 0xE0,
  0x03, 0x00, 0x7F, 0xCF, 0xFC, 0x7F, 0xE7, 0xFF, 0x3F, 0x13, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x09, 0xF9,
  0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0x1F, 0x8F, 0xBF, 0x3F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xF7, 0xCF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x9F, 0xDF, 0x1F, 0x3E, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F,
  0xFE, 0x7F, 0xF9, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xC1, 0x9F, 0xFE, 0x3F, 0xF8,
  0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xF2, 0x7E,
  0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x00, 0x04, 0x00, 0x3E, 0x7C, 0xFE, 0xFB, 0xFF, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xDF, 0xBF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFC, 0x7D, 0xF8, 0x03, 0xF0, 0x07, 0xC8, 0x0F, 0x9F, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x88, 0x3E, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFC, 0x27, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3F, 0xF8, 0xFD, 0xF1, 0xF3,
  0xE7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xF7, 0xC7, 0xCF, 0xCF, 0x9F, 0x9F, 0x1F, 0xBE, 0x3F,
  0x7C, 0x3F, 0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x63, 0xCF,
  0xCF, 0xEF, 0x7F, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFB,
  0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF,
  0x8F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F,
  0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xC0, 0x00, 0x83, 0xCF, 0xCF, 0x7F, 0xBF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xC0, 0x03,
  0x00, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0xBF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF,
  0x8F, 0xDF, 0xBF, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x00,
  0x83, 0xCF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xF3, 0xFF, 0x8F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFB, 0xEF, 0xCF, 0xBE, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x04,
  0x00, 0x3E, 0x7C, 0xFE, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x9F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xDF, 0xBF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFC, 0x7D, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x80, 0x04, 0x07, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0xBF, 0x07,
  0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE4, 0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0,
  0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7C, 0xF8, 0xF0, 0xFC, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C,
  0x1E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x7E, 0x1F, 0x7C,
  0x7F, 0x1F, 0x7C, 0x7F, 0x3F, 0x7C, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C,
  0xFF, 0x3E, 0x3E, 0xFF, 0x3E, 0x3E, 0xFF, 0xBE, 0x3E, 0xF7, 0xFC, 0x3F,
  0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF0, 0xFC, 0x7E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7E, 0x7C, 0x7C, 0x7E,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC3, 0xF9, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFC, 0x3F, 0x87, 0xF0,
  0x7E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x1F, 0xE7, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1,
  0x00, 0x00, 0x1C, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xA0, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 24, 9, 1, -24 },
  { 22, 14, 9, 16, 1, -24 },
  { 38, 17, 24, 18, 1, -24 },
  { 89, 14, 27, 16, 1, -25 },
  { 137, 26, 24, 28, 1, -24 },
  { 215, 20, 24, 21, 1, -24 },
  { 275, 6, 9, 8, 1, -24 },
  { 282, 10, 29, 11, 1, -24 },
  { 319, 9, 29, 11, 0, -24 },
  { 352, 15, 15, 16, 0, -25 },
  { 381, 14, 16, 17, 1, -20 },
  { 409, 7, 10, 9, 1, -5 },
  { 418, 9, 5, 11, 1, -11 },
  { 424, 7, 6, 9, 1, -6 },
  { 430, 14, 24, 14, 0, -24 },
  { 472, 14, 24, 16, 1, -24 },
  { 514, 12, 24, 16, 1, -24 },
  { 550, 14, 24, 16, 1, -24 },
  { 592, 14, 24, 16, 1, -24 },
  { 634, 15, 24, 16, 1, -24 },
  { 679, 13, 24, 16, 2, -24 },
  { 718, 14, 24, 16, 1, -24 },
  { 760, 14, 24, 16, 1, -24 },
  { 802, 14, 24, 16, 1, -24 },
  { 844, 14, 24, 16, 1, -24 },
  { 886, 6, 19, 9, 2, -19 },
  { 901, 7, 24, 9, 1, -19 },
  { 922, 14, 16, 17, 1, -20 },
  { 950, 14, 11, 17, 1, -17 },
  { 970, 15, 16, 17, 1, -20 },
  { 1000, 13, 24, 13, 0, -24 },
  { 1039, 23, 26, 25, 1, -24 },
  { 1114, 19, 24, 19, 0, -24 },
  { 1171, 15, 24, 18, 2, -24 },
  { 1216, 15, 24, 17, 1, -24 },
  { 1261, 16, 24, 19, 2, -24 },
  { 1309, 11, 24, 15, 2, -24 },
  { 1342, 11, 24, 14, 2, -24 },
  { 1375, 17, 24, 20, 1, -24 },
  { 1426, 16, 24, 20, 2, -24 },
  { 1474, 10, 24, 12, 1, -24 },
  { 1504, 10, 31, 10, -2, -24 },
  { 1543, 17, 24, 18, 2, -24 },
  { 1594, 12, 24, 14, 2, -24 },
  { 1630, 23, 24, 27, 2, -24 },
  { 1699, 18, 24, 22, 2, -24 },
  { 1753, 18, 24, 21, 1, -24 },
  { 1807, 14, 24, 17, 2, -24 },
  { 1849, 18, 30, 21, 1, -24 },
  { 1917, 16, 24, 18, 2, -24 },
  { 1965, 13, 24, 15, 1, -24 },
  { 2004, 14, 24, 15, 1, -24 },
  { 2046, 16, 24, 19, 2, -24 },
  { 2094, 18, 24, 18, 0, -24 },
  { 2148, 27, 24, 27, 0, -24 },
  { 2229, 17, 24, 17, 0, -24 },
  { 2280, 17, 24, 17, 0, -24 },
  { 2331, 14, 24, 16, 1, -24 },
  { 2373, 8, 30, 10, 1, -24 },
  { 2403, 14, 24, 14, 0, -24 },
  { 2445, 8, 30, 10, 1, -24 },
  { 2475, 18, 16, 18, 0, -24 },
  { 2511, 17, 4, 17, 0, 2 },
  { 2520, 9, 5, 11, 1, -25 },
  { 2526, 14, 19, 16, 1, -19 },
  { 2560, 14, 25, 17, 2, -25 },
  { 2604, 13, 19, 14, 1, -19 },
  { 2635, 15, 25, 17, 1, -25 },
  { 2682, 14, 19, 16, 1, -19 },
  { 2716, 11, 25, 11, 0, -25 },
  { 2751, 15, 27, 17, 1, -19 },
  { 2802, 14, 25, 17, 2, -25 },
  { 2846, 5, 26, 9, 2, -26 },
  { 2863, 8, 34, 9, -1, -26 },
  { 2897, 15, 25, 17, 2, -25 },
  { 2944, 5, 25, 9, 2, -25 },
  { 2960, 22, 19, 26, 2, -19 },
  { 3013, 14, 19, 17, 2, -19 },
  { 3047, 15, 19, 17, 1, -19 },
  { 3083, 14, 27, 17, 2, -19 },
  { 3131, 15, 27, 17, 1, -19 },
  { 3182, 10, 19, 12, 2, -19 },
  { 3206, 11, 19, 13, 1, -19 },
  { 3233, 11, 22, 12, 0, -22 },
  { 3264, 14, 18, 17, 2, -18 },
  { 3296, 16, 18, 16, 0, -18 },
  { 3332, 24, 18, 24, 0, -18 },
  { 3386, 16, 18, 16, 0, -18 },
  { 3422, 16, 26, 16, 0, -18 },
  { 3474, 12, 18, 13, 1, -18 },
  { 3501, 11, 30, 12, 0, -24 },
  { 3543, 4, 33, 14, 5, -25 },
  { 3560, 11, 30, 12, 1, -24 },
  { 3602, 15, 7, 17, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Black33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK33PT7B_H_
