#ifndef _NOTOSANS_EXTRACONDENSED_BLACK16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB0, 0xDF, 0x00, 0xDF, 0x7C, 0xF3, 0x1B, 0x0B, 0x0D,
  0x8F, 0xF3, 0x61, 0xB3, 0xFD, 0xFE, 0x2C, 0x36, 0x1B, 0x00, 0x31, 0xFF,
  0xFD, 0xF3, 0xC7, 0xCF, 0xBF, 0xFF, 0x8C, 0x30, 0x30, 0x03, 0xC6, 0x1E,
  0x61, 0xB3, 0x0D, 0xB0, 0x3D, 0xB9, 0xEF, 0xE6, 0xDB, 0x06, 0xD8, 0x66,
  0xC3, 0x3E, 0x38, 0xE0, 0x08, 0x0F, 0x87, 0x61, 0xD8, 0x3E, 0x0F, 0x07,
  0xDD, 0xBE, 0xEF, 0xB9, 0xE7, 0xF9, 0xF7, 0xFF, 0x36, 0x6E, 0xCC, 0xCC,
  0xCC, 0xEE, 0x67, 0x30, 0xE3, 0x1C, 0x63, 0x18, 0xE7, 0x31, 0x8C, 0xE7,
  0x33, 0x00, 0x19, 0x37, 0xFF, 0xF3, 0xCD, 0xC9, 0x00, 0x30, 0xC3, 0x3F,
  0xFC, 0xC3, 0x0C, 0x76, 0x6E, 0xFF, 0xFE, 0xDF, 0x00, 0x0E, 0x18, 0x30,
  0xE1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x87, 0x00, 0x31, 0xEF, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFF, 0xDE, 0x3B, 0xFF, 0xB5, 0x8C, 0x63, 0x18, 0xC6,
  0x10, 0xFB, 0xFA, 0x70, 0xE1, 0xC7, 0x1C, 0x38, 0xE3, 0xFF, 0xF0, 0x19,
  0xF9, 0xF8, 0x70, 0xE7, 0x8F, 0x07, 0x0F, 0x1F, 0xFF, 0xE0, 0x0E, 0x1E,
  0x3E, 0x3E, 0x6E, 0x6E, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E, 0xFF, 0xFC, 0x30,
  0xFB, 0xF1, 0xC3, 0x9F, 0xFF, 0x80, 0x1D, 0xFF, 0xF8, 0xDB, 0xFF, 0xF3,
  0xCF, 0xBF, 0xDE, 0xFF, 0xF1, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0xCE, 0x00,
  0x18, 0xFD, 0xFB, 0x37, 0xE7, 0x8F, 0x3F, 0x67, 0xCD, 0xF9, 0xE0, 0x18,
  0xF9, 0xFB, 0x3E, 0x6C, 0xDF, 0xBB, 0x06, 0x1D, 0xF3, 0xC0, 0xDF, 0x00,
  0x37, 0xE0, 0x67, 0x60, 0x00, 0x07, 0x66, 0xE0, 0x02, 0x0C, 0x7B, 0xCF,
  0x07, 0xC3, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x81, 0x83, 0xC1, 0xE1, 0xFF,
  0x38, 0x40, 0x33, 0xFF, 0xE3, 0x1C, 0xE3, 0x0C, 0x00, 0xC7, 0x0C, 0x0C,
  0x07, 0xF1, 0x87, 0x67, 0x6D, 0xF7, 0xB6, 0xEC, 0xDD, 0x9B, 0xDF, 0xDB,
  0xBB, 0x00, 0x38, 0xC3, 0xF8, 0x1E, 0x1F, 0x0D, 0x86, 0xC3, 0x73, 0xB9,
  0xFC, 0xFE, 0x7F, 0xF1, 0xF8, 0xE0, 0xFD, 0xFF, 0xBF, 0x7F, 0xDF, 0xBB,
  0xF7, 0xEF, 0xFF, 0xF0, 0x18, 0xFF, 0xF7, 0x0E, 0x18, 0x30, 0x70, 0xE1,
  0xC9, 0xF1, 0xE0, 0xFC, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xE6, 0xEE,
  0xFC, 0xF8, 0xFF, 0xF9, 0xCF, 0xFF, 0x9C, 0xE7, 0xFE, 0xFF, 0xF9, 0xCF,
  0xFF, 0xFC, 0xE7, 0x38, 0x0C, 0x7F, 0x7E, 0xE0, 0xE0, 0xCF, 0xCF, 0xEF,
  0xE7, 0xE7, 0x7F, 0x3F, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x77, 0xFE, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x7B, 0x00, 0xE7, 0xEE, 0xEC, 0xFC,
  0xF8, 0xFC, 0xFC, 0xEC, 0xEE, 0xEE, 0xE7, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xFD, 0xFD, 0xBF, 0xB7,
  0xF7, 0xFE, 0xF7, 0xCE, 0xF9, 0xDF, 0x3B, 0x80, 0xE3, 0xF9, 0xFC, 0xFF,
  0x7D, 0xBE, 0xFF, 0x3F, 0x9F, 0xCF, 0xE3, 0xF1, 0xE0, 0x18, 0x7E, 0xFF,
  0xE7, 0xE7, 0xC7, 0xC7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0xFD, 0xFF, 0xBF,
  0x7E, 0xFF, 0xBF, 0x70, 0xE1, 0xC3, 0x80, 0x18, 0x7E, 0xFF, 0xE7, 0xE7,
  0xC7, 0xC7, 0xE7, 0xE7, 0xE7, 0x7E, 0x3C, 0x0E, 0x07, 0x07, 0xFC, 0xFE,
  0xEE, 0xEE, 0xFE, 0xFC, 0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0x18, 0xFD, 0xF3,
  0x17, 0x0F, 0x0F, 0x0F, 0x0F, 0x9F, 0xF3, 0xC0, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xEE, 0xFE, 0x7C, 0xE3, 0xF1, 0x98, 0xCE, 0xE7, 0x73, 0xB0,
  0xD8, 0x6C, 0x3E, 0x1E, 0x07, 0x00, 0xE7, 0x3F, 0x39, 0xD9, 0xCC, 0xCE,
  0x66, 0xD7, 0x3E, 0xF9, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xEF, 0x0E, 0x38,
  0xE7, 0x7E, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x7E, 0x67, 0xE7, 0xE7,
  0x67, 0x76, 0x3E, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFC,
  0x38, 0xE1, 0xC7, 0x0C, 0x38, 0x61, 0xFF, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x0E, 0x0C, 0x18,
  0x38, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x18,
  0x0E, 0x0F, 0x06, 0xC7, 0x63, 0x3B, 0x8E, 0xFF, 0xFF, 0xE7, 0x3C, 0xFD,
  0x38, 0xF7, 0xFC, 0xFB, 0xBF, 0x76, 0xC1, 0x83, 0x06, 0xEF, 0xDD, 0xF3,
  0xE7, 0xCF, 0xDF, 0xF6, 0xE0, 0x7F, 0xEE, 0xB0, 0xC3, 0x0E, 0x7E, 0x78,
  0x0E, 0x1C, 0x3B, 0x7F, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0xFB, 0xF0, 0x7B,
  0xFC, 0xF3, 0xFF, 0x0C, 0x7F, 0x7C, 0x3D, 0xE7, 0x1E, 0xF9, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x6F, 0xFF, 0xBE, 0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0x1A,
  0x77, 0xE7, 0x00, 0xC1, 0x83, 0x06, 0xEF, 0xDD, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x70, 0xF3, 0xFF, 0xFF, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xFE, 0xC1, 0x83, 0x06, 0x7C, 0xDB, 0xB6, 0x7C, 0xFD, 0xBB, 0x3E, 0x70,
  0xFF, 0xFF, 0xFF, 0xDD, 0xDF, 0xFF, 0xBB, 0xE7, 0x7C, 0xEF, 0x9D, 0xF3,
  0xBE, 0x77, 0xCE, 0xE0, 0xDD, 0xFB, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCE,
  0x79, 0xFB, 0xB6, 0x7C, 0xF9, 0xF3, 0x7E, 0x78, 0xDD, 0xFB, 0xBE, 0x7C,
  0xF9, 0xFB, 0xFE, 0xDD, 0x83, 0x06, 0x0C, 0x00, 0x6F, 0xFF, 0xBE, 0x7C,
  0xF9, 0xF3, 0xFF, 0x7E, 0x1C, 0x38, 0x70, 0xE0, 0xDF, 0xFF, 0xCC, 0x63,
  0x18, 0xC0, 0x79, 0xFE, 0x5C, 0x78, 0xF9, 0xFF, 0xF8, 0x33, 0x9F, 0xF7,
  0x39, 0xCE, 0x73, 0xCE, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFB, 0xFF, 0x76,
  0xE7, 0xE6, 0x66, 0x6E, 0x7E, 0x3C, 0x3C, 0x3C, 0x38, 0xEE, 0x7E, 0xF6,
  0x6F, 0x66, 0xF6, 0x6F, 0xE6, 0xBE, 0x7B, 0xC3, 0x9C, 0x39, 0xC0, 0xE6,
  0x6E, 0x7C, 0x3C, 0x38, 0x3C, 0x7C, 0x6E, 0xE7, 0xE7, 0xE6, 0x66, 0x7E,
  0x7E, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0xB8, 0x70, 0x60, 0xFF, 0xF1, 0xCE,
  0x39, 0xC6, 0x3F, 0xFC, 0x0C, 0xF3, 0x8C, 0x30, 0xC7, 0x38, 0xF0, 0xC3,
  0x0C, 0x38, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC7, 0x0C, 0x30,
  0xC3, 0x87, 0x3C, 0xC3, 0x0C, 0x73, 0xCC, 0x00, 0x79, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_Black16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 6, 13, 8, 1, -12 },
  { 32, 13, 12, 13, 0, -12 },
  { 52, 10, 12, 10, 0, -12 },
  { 67, 2, 4, 4, 1, -11 },
  { 68, 4, 15, 5, 1, -12 },
  { 76, 5, 15, 5, 0, -12 },
  { 86, 7, 7, 8, 0, -12 },
  { 93, 6, 8, 8, 1, -10 },
  { 99, 4, 4, 4, 0, -2 },
  { 101, 5, 3, 5, 0, -6 },
  { 103, 3, 3, 4, 1, -3 },
  { 105, 7, 12, 7, 0, -12 },
  { 116, 6, 12, 8, 1, -12 },
  { 125, 5, 11, 8, 1, -11 },
  { 132, 7, 12, 8, 0, -12 },
  { 143, 7, 12, 8, 0, -12 },
  { 154, 8, 11, 8, 0, -11 },
  { 165, 6, 11, 8, 1, -11 },
  { 174, 6, 12, 8, 1, -12 },
  { 183, 6, 11, 8, 1, -11 },
  { 192, 7, 12, 8, 0, -12 },
  { 203, 7, 12, 8, 0, -12 },
  { 214, 3, 9, 4, 1, -9 },
  { 218, 4, 11, 4, 0, -9 },
  { 224, 7, 8, 8, 0, -10 },
  { 231, 6, 5, 8, 1, -8 },
  { 235, 7, 8, 8, 1, -10 },
  { 242, 6, 12, 6, 0, -12 },
  { 251, 11, 13, 12, 1, -12 },
  { 269, 9, 11, 9, 0, -11 },
  { 282, 7, 11, 9, 1, -11 },
  { 292, 7, 12, 8, 1, -12 },
  { 303, 8, 11, 9, 1, -11 },
  { 314, 5, 11, 7, 1, -11 },
  { 321, 5, 11, 7, 1, -11 },
  { 328, 8, 12, 9, 1, -12 },
  { 340, 8, 11, 10, 1, -11 },
  { 351, 5, 11, 6, 0, -11 },
  { 358, 5, 15, 5, -1, -11 },
  { 368, 8, 11, 9, 1, -11 },
  { 379, 6, 11, 7, 1, -11 },
  { 388, 11, 11, 13, 1, -11 },
  { 404, 9, 11, 11, 1, -11 },
  { 417, 8, 12, 10, 1, -12 },
  { 429, 7, 11, 8, 1, -11 },
  { 439, 8, 15, 10, 1, -12 },
  { 454, 8, 11, 9, 1, -11 },
  { 465, 7, 12, 7, 0, -12 },
  { 476, 7, 11, 7, 0, -11 },
  { 486, 8, 11, 9, 1, -11 },
  { 497, 9, 11, 9, 0, -11 },
  { 510, 13, 11, 13, 0, -11 },
  { 528, 8, 11, 8, 0, -11 },
  { 539, 8, 11, 8, 0, -11 },
  { 550, 7, 11, 8, 0, -11 },
  { 560, 4, 15, 5, 1, -12 },
  { 568, 7, 12, 7, 0, -12 },
  { 579, 4, 15, 5, 0, -12 },
  { 587, 9, 7, 9, 0, -11 },
  { 595, 8, 2, 8, 0, 1 },
  { 597, 4, 2, 5, 1, -12 },
  { 598, 7, 9, 8, 0, -9 },
  { 606, 7, 12, 8, 1, -12 },
  { 617, 6, 9, 7, 1, -9 },
  { 624, 7, 12, 8, 1, -12 },
  { 635, 6, 9, 8, 1, -9 },
  { 642, 6, 12, 5, 0, -12 },
  { 651, 7, 13, 8, 1, -9 },
  { 663, 7, 12, 8, 1, -12 },
  { 674, 2, 12, 4, 1, -12 },
  { 677, 4, 16, 4, -1, -12 },
  { 685, 7, 12, 8, 1, -12 },
  { 696, 2, 12, 4, 1, -12 },
  { 699, 11, 9, 13, 1, -9 },
  { 712, 7, 9, 8, 1, -9 },
  { 720, 7, 9, 8, 1, -9 },
  { 728, 7, 13, 8, 1, -9 },
  { 740, 7, 13, 8, 1, -9 },
  { 752, 5, 9, 6, 1, -9 },
  { 758, 6, 9, 6, 0, -9 },
  { 765, 5, 11, 6, 0, -11 },
  { 772, 7, 9, 8, 1, -9 },
  { 780, 8, 9, 8, 0, -9 },
  { 789, 12, 9, 12, 0, -9 },
  { 803, 8, 9, 8, 0, -9 },
  { 812, 8, 13, 8, 0, -9 },
  { 825, 6, 9, 6, 0, -9 },
  { 832, 6, 15, 6, 0, -12 },
  { 844, 2, 16, 7, 2, -12 },
  { 848, 6, 15, 6, 0, -12 },
  { 860, 8, 3, 8, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Black16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK16PT7B_H_
