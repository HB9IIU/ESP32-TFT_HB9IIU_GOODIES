#ifndef _NOTOSANS_EXTRACONDENSED_BLACK47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x7F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0x3F, 0x02, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF7, 0xF0, 0xFE,
  0xFE, 0x1F, 0xCF, 0xC3, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xF1, 0xF8,
  0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF1, 0xF0,
  0x03, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xE3, 0xE0,
  0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xE0,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFB, 0xC6, 0x7E, 0x78, 0x0F, 0xCF,
  0x01, 0xFD, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xF7, 0xE0, 0x1E, 0xFF, 0x03, 0xDF, 0xF8, 0x7B,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0x7E, 0x03, 0xE0, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x1F,
  0x8F, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0xFC,
  0x00, 0x3F, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x3F, 0x07, 0x81, 0xF1, 0xF9, 0xF8, 0xFF,
  0x0F, 0xDF, 0x8F, 0x8F, 0xFC, 0x7F, 0xFC, 0xFC, 0xFF, 0xF1, 0xFF, 0xE7,
  0xC7, 0xFF, 0x8F, 0xFE, 0x7E, 0x7F, 0xFC, 0x3F, 0xE3, 0xF3, 0xF3, 0xF0,
  0x7C, 0x3F, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xF8, 0xFC, 0x00, 0x0F, 0x8F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF1, 0xF8, 0x00,
  0x7E, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x7C, 0x7E, 0x00, 0x1F, 0x03, 0xF3,
  0xF0, 0x01, 0xF8, 0x1F, 0x9F, 0x80, 0x0F, 0x80, 0xFF, 0xF8, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF1, 0xFE, 0x0F, 0xFF, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF,
  0xE7, 0xF8, 0xFF, 0xFF, 0xBF, 0xC7, 0xFB, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF,
  0xE3, 0xFC, 0x7F, 0xFF, 0x1F, 0xE1, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0x87,
  0xF8, 0x3F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x9F, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xDF, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x30, 0xFC, 0x31, 0xF7, 0xEF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0x9F,
  0xE3, 0xFC, 0x7F, 0x07, 0xC3, 0xE0, 0x1E, 0x0E, 0x00, 0x20, 0x60, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC,
  0xFE, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFC,
  0xFF, 0x1F, 0xEF, 0xF1, 0xFE, 0xFF, 0x1F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F,
  0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0xFF,
  0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x1F, 0xEF, 0xF1, 0xFE, 0x7F, 0x1F, 0xE7,
  0xFB, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xE7, 0xF9, 0xF3, 0xFC, 0x71,
  0xFE, 0x10, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xE1, 0xFE, 0x38, 0x1F, 0xE1, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xC1, 0xFE, 0x10, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x01, 0xF9,
  0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F, 0x07, 0xE1, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x3F, 0xBF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xF3, 0xFD, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xBF, 0x83,
  0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF,
  0xE3, 0xFC, 0x7F, 0xBF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFF, 0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x3F,
  0x8F, 0xE3, 0xFC, 0x7F, 0x9F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFD, 0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF1,
  0xFE, 0x7F, 0x8F, 0xF3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFC, 0x3F, 0xEF, 0xF1, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0x07,
  0xF3, 0xF8, 0x0F, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x40, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x1F, 0x83, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F,
  0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFC, 0xE0, 0xFF, 0x20, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x60, 0x7E, 0x3E, 0x07, 0xFE, 0x3E, 0x7E, 0x1F, 0xFF, 0x3F,
  0x7C, 0x3F, 0xFF, 0x3F, 0x7C, 0x3F, 0xFF, 0x1F, 0xFC, 0x7F, 0x3F, 0x1F,
  0xFC, 0x7E, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F,
  0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F,
  0xF8, 0xFC, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF8, 0xFC, 0x7E, 0x3F,
  0xF8, 0xFC, 0x7F, 0x3E, 0xF8, 0x7F, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFC, 0x3F, 0xEF, 0xF8, 0x7E, 0x1F, 0xC7, 0xF0, 0x7E, 0x07, 0x01, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0,
  0x0F, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC,
  0x07, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x9F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFC, 0x1C, 0x7F, 0xC0,
  0x23, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x9F, 0xF8, 0x0C,
  0x7F, 0xF7, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0x9F, 0xFC, 0xFF, 0x0F, 0xF9, 0xFE, 0x0F, 0xFB,
  0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xC0,
  0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x07, 0xFD, 0xFE, 0x1F, 0xF3, 0xFC, 0x7F,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xF0,
  0x18, 0x7F, 0xE0, 0x08, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xE0, 0xFF, 0x3F, 0xFB,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xFA, 0x3F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0x10, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x03,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE,
  0xFE, 0x7F, 0x7F, 0xFE, 0xFE, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0xFF, 0xFE,
  0x7E, 0x7E, 0xFF, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xFE,
  0x3F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFE,
  0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFB,
  0xF8, 0xFF, 0xFD, 0xFC, 0x7F, 0xFE, 0xFF, 0x3F, 0xFF, 0x3F, 0x9F, 0xFF,
  0x9F, 0xEF, 0xFF, 0xC7, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0x9F,
  0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0x9F,
  0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x8F,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0x9F, 0xE0, 0xFF,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x07,
  0xFD, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFE, 0x3E, 0x7F,
  0x81, 0x9F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x01,
  0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x80, 0xFE, 0x7F, 0x01,
  0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F,
  0x9F, 0xE0, 0xFF, 0xC1, 0xFE, 0x3F, 0x83, 0xFF, 0x07, 0xF8, 0xFE, 0x0F,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC7, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0x9F, 0xE0,
  0x7F, 0xBF, 0x3E, 0x7F, 0x81, 0xFE, 0xFC, 0xFD, 0xFE, 0x03, 0xFB, 0xF3,
  0xF7, 0xF0, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x3F, 0xBF, 0x3F, 0x7F, 0x00,
  0xFE, 0xFC, 0xFD, 0xFC, 0x03, 0xFB, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x87,
  0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFE,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF,
  0x03, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8,
  0x07, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0C, 0x0F, 0xF0, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0x7F, 0x3F, 0xF3, 0xF1, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xCF,
  0xE1, 0xFE, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF7, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0x9F, 0xF1, 0xFC, 0x7F, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFC, 0x39, 0xFE,
  0x02, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x0D, 0xFF, 0x0F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F,
  0xE7, 0xF1, 0xFF, 0xBF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xCF, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0,
  0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xE7,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x87, 0xF7, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x27, 0xF8, 0x06, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF6,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF1,
  0xF8, 0x7F, 0xDF, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0x3F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xF8, 0x3F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE,
  0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0x7F, 0x0F, 0xF3, 0xF8, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x90, 0x03, 0xFC, 0xF8, 0x7F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xCF, 0xE1, 0xFE, 0xFF, 0x8F, 0xEF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF7, 0xFC, 0x7F, 0xBF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF0, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0x9F,
  0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x83, 0xFD, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3,
  0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x3F,
  0xF3, 0xFF, 0x3F, 0xBF, 0xFB, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0x83, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFE, 0x1F, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF,
  0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x83,
  0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xC0, 0xFC, 0x3F, 0x87, 0xF3, 0xFE, 0x3F,
  0xBF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F,
  0xDF, 0xF1, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0x9F, 0xE1,
  0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F,
  0x03, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0xFE, 0x3F, 0x87, 0xF3, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0x7F, 0xC7, 0xF9, 0xFC, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x7F, 0xDF, 0xC7, 0xFE,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0x3F, 0xEF,
  0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F,
  0x07, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0x0F, 0xF3, 0xF8, 0x3F,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x3F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0x0E, 0xFF, 0x02,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFE,
  0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE3, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0x7F, 0x1F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC0, 0xFF,
  0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xC7,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x07, 0xF7, 0xF0,
  0xFF, 0xC3, 0xFD, 0xFC, 0x3F, 0xF0, 0xFF, 0x7F, 0x8F, 0xFC, 0x3F, 0x9F,
  0xE3, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE,
  0x3F, 0x9F, 0xFE, 0x7F, 0x8F, 0xE7, 0xEF, 0x9F, 0xC3, 0xFD, 0xFB, 0xE7,
  0xF0, 0x7F, 0x7E, 0xFD, 0xFC, 0x1F, 0xDF, 0xBF, 0x7F, 0x07, 0xF7, 0xCF,
  0xDF, 0xC1, 0xFD, 0xF3, 0xF7, 0xE0, 0x7F, 0xFC, 0xFD, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x87, 0xFD, 0xFE, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F,
  0x87, 0xFB, 0xFE, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFE,
  0x07, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x87,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x80,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xF8, 0x07, 0xFE, 0x80, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 35, 13, 2, -34 },
  { 41, 19, 13, 23, 2, -34 },
  { 72, 24, 34, 26, 1, -34 },
  { 174, 19, 39, 23, 2, -36 },
  { 267, 37, 34, 39, 1, -34 },
  { 425, 29, 34, 30, 1, -34 },
  { 549, 8, 13, 12, 2, -34 },
  { 562, 13, 42, 15, 2, -35 },
  { 631, 13, 42, 15, 0, -35 },
  { 700, 21, 21, 22, 1, -36 },
  { 756, 20, 23, 24, 2, -28 },
  { 814, 10, 14, 13, 1, -7 },
  { 832, 13, 7, 15, 1, -16 },
  { 844, 9, 9, 13, 2, -8 },
  { 855, 20, 34, 20, 0, -34 },
  { 940, 20, 34, 23, 2, -34 },
  { 1025, 17, 34, 23, 2, -34 },
  { 1098, 20, 34, 23, 1, -34 },
  { 1183, 20, 34, 23, 1, -34 },
  { 1268, 22, 34, 23, 1, -34 },
  { 1362, 19, 34, 23, 2, -34 },
  { 1443, 21, 34, 23, 1, -34 },
  { 1533, 20, 34, 23, 2, -34 },
  { 1618, 21, 34, 23, 1, -34 },
  { 1708, 21, 34, 23, 1, -34 },
  { 1798, 9, 27, 13, 2, -26 },
  { 1829, 10, 33, 13, 1, -26 },
  { 1871, 21, 24, 24, 1, -29 },
  { 1934, 20, 17, 24, 2, -25 },
  { 1977, 20, 24, 24, 2, -29 },
  { 2037, 18, 35, 19, 0, -34 },
  { 2116, 32, 38, 36, 2, -34 },
  { 2268, 27, 34, 27, 0, -34 },
  { 2383, 21, 34, 26, 3, -34 },
  { 2473, 21, 34, 24, 2, -34 },
  { 2563, 23, 34, 28, 3, -34 },
  { 2661, 16, 34, 21, 3, -34 },
  { 2729, 16, 34, 20, 3, -34 },
  { 2797, 24, 34, 28, 2, -34 },
  { 2899, 23, 34, 29, 3, -34 },
  { 2997, 14, 34, 17, 1, -34 },
  { 3057, 14, 45, 14, -3, -34 },
  { 3136, 24, 34, 26, 3, -34 },
  { 3238, 17, 34, 20, 3, -34 },
  { 3311, 32, 34, 38, 3, -34 },
  { 3447, 25, 34, 31, 3, -34 },
  { 3554, 25, 34, 29, 2, -34 },
  { 3661, 20, 34, 24, 3, -34 },
  { 3746, 25, 42, 29, 2, -34 },
  { 3878, 23, 34, 26, 3, -34 },
  { 3976, 19, 34, 21, 1, -34 },
  { 4057, 20, 34, 22, 1, -34 },
  { 4142, 22, 34, 28, 3, -34 },
  { 4236, 26, 34, 26, 0, -34 },
  { 4347, 38, 34, 38, 0, -34 },
  { 4509, 25, 34, 24, 0, -34 },
  { 4616, 25, 34, 25, 0, -34 },
  { 4723, 20, 34, 22, 1, -34 },
  { 4808, 11, 43, 14, 2, -35 },
  { 4868, 20, 34, 20, 0, -34 },
  { 4953, 11, 43, 14, 1, -35 },
  { 5013, 25, 23, 25, 0, -34 },
  { 5085, 24, 6, 24, 0, 3 },
  { 5103, 12, 8, 16, 2, -36 },
  { 5115, 20, 26, 23, 1, -26 },
  { 5180, 21, 36, 25, 2, -36 },
  { 5275, 18, 26, 20, 1, -26 },
  { 5334, 21, 36, 25, 1, -36 },
  { 5429, 20, 26, 23, 1, -26 },
  { 5494, 16, 36, 15, 0, -36 },
  { 5566, 21, 37, 25, 1, -26 },
  { 5664, 21, 36, 25, 2, -36 },
  { 5759, 8, 36, 12, 2, -36 },
  { 5795, 12, 47, 12, -2, -36 },
  { 5866, 23, 36, 24, 2, -36 },
  { 5970, 8, 36, 12, 2, -36 },
  { 6006, 33, 26, 37, 2, -26 },
  { 6114, 21, 26, 25, 2, -26 },
  { 6183, 22, 26, 24, 1, -26 },
  { 6255, 21, 37, 25, 2, -26 },
  { 6353, 21, 37, 25, 1, -26 },
  { 6451, 15, 26, 18, 2, -26 },
  { 6500, 16, 26, 19, 1, -26 },
  { 6552, 16, 31, 17, 0, -31 },
  { 6614, 21, 26, 25, 2, -26 },
  { 6683, 23, 26, 23, 0, -26 },
  { 6758, 34, 26, 35, 0, -26 },
  { 6869, 22, 26, 22, 0, -26 },
  { 6941, 23, 37, 23, 0, -26 },
  { 7048, 17, 26, 19, 1, -26 },
  { 7104, 15, 42, 17, 1, -34 },
  { 7183, 6, 47, 20, 7, -36 },
  { 7219, 16, 42, 17, 1, -34 },
  { 7303, 21, 9, 24, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Black47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK47PT7B_H_
