#ifndef _NOTOSANS_EXTRACONDENSED_BLACK60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xFB, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF1, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF9, 0xFE,
  0x06, 0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xF8, 0xFF, 0xEF,
  0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC,
  0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F,
  0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xBC, 0xFC, 0xFF, 0x3C, 0x1C, 0xFF, 0x3C, 0x04,
  0xFF, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0xBC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3D, 0xFF, 0x00, 0x3C, 0xFF,
  0x00, 0x3C, 0xFF, 0x00, 0x3C, 0xFF, 0x80, 0x3C, 0xFF, 0xE0, 0x3C, 0xFF,
  0xF8, 0x3D, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x9F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0xC0, 0x7F, 0x9F, 0xE3, 0xF8, 0x7F, 0xF0,
  0x7F, 0x9F, 0xE7, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0x8F, 0xE3, 0xFD, 0xFE, 0x0F, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE,
  0x03, 0xFC, 0x1F, 0xC7, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFD, 0xFE,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xC7,
  0xFE, 0x07, 0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x0B, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF1, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x0F, 0xE0, 0x63, 0xE1, 0xFC, 0x3C, 0x7F, 0x3F, 0xBF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xBF, 0xE0, 0x7F, 0xE7, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0x07, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x38, 0x0E, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE,
  0x07, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF7,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x7F,
  0xE1, 0xFF, 0x9F, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x07, 0xFE,
  0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFC, 0x1F, 0xFB,
  0xFF, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0x9F, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F,
  0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0xC3, 0xFF,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF,
  0xCF, 0xF3, 0xFF, 0x1F, 0x8F, 0xFC, 0x3C, 0x3F, 0xF0, 0x60, 0xFF, 0xC0,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0x8F,
  0xC0, 0xFF, 0xE1, 0xE0, 0x1F, 0xF8, 0x30, 0x07, 0xFE, 0x04, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0x0E, 0x01, 0xFF, 0x84, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xBF, 0xF0, 0x07, 0xFB, 0xFF, 0x00, 0x7F, 0xBF, 0xF0, 0x0F,
  0xF3, 0xFF, 0x00, 0xFF, 0x3F, 0xF0, 0x1F, 0xE3, 0xFF, 0x01, 0xFE, 0x3F,
  0xF0, 0x3F, 0xC3, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x07,
  0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3E, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x08, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xFC, 0x3F, 0xEF,
  0xFF, 0x8F, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x7F,
  0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE1, 0xFF, 0x9F, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xF9, 0xFF, 0x07,
  0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8, 0x7F, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFB, 0xFF, 0x87, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF3, 0xFF, 0x3F, 0xF8, 0x7F, 0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x07, 0xFE,
  0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0xE0, 0xFF, 0xEF,
  0xF8, 0x1F, 0xE3, 0xFE, 0x00, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0xF1, 0xFF,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0xFE, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xFC,
  0x3F, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE3, 0xFE,
  0x1F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0x0F, 0xFE, 0x78, 0x0F, 0xFC, 0x40, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x70, 0x0F, 0xF0, 0x7F, 0x01, 0xFF,
  0xE1, 0xFC, 0x3F, 0xC0, 0xFF, 0xFE, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0x8F,
  0xE3, 0xF8, 0x3F, 0xFF, 0xE3, 0xF9, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x7F,
  0x0F, 0xF8, 0xFE, 0x1F, 0xDF, 0xC3, 0xFC, 0x3F, 0x87, 0xF7, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xFF, 0x87, 0xF0, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x1F, 0xE1, 0xFF,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0x87,
  0xF0, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0x07,
  0xF0, 0x7E, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xBF, 0x87, 0xF8, 0xFF, 0x8F,
  0xCF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0x07, 0xFF, 0xBF, 0xFE, 0x1F, 0xC1, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x3F,
  0xF0, 0xFF, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB,
  0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81,
  0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0x83, 0xFF,
  0x80, 0x70, 0xFF, 0xE0, 0x02, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x47, 0xFF, 0x80, 0x38, 0xFF,
  0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0x3F, 0xF0, 0x7F,
  0xF9, 0xFF, 0x81, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x3F, 0xFB,
  0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x01,
  0xFF, 0xDF, 0xF8, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0xE7, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x00, 0xE0,
  0xFF, 0xF0, 0x00, 0x41, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0x9F, 0xFC, 0x03,
  0xFF, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFA, 0x1F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF,
  0xBF, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xC7,
  0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF,
  0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFC, 0x7F, 0xBF, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xFF,
  0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0xFF, 0x3F,
  0xEF, 0xF3, 0xFF, 0xFF, 0x9F, 0xF7, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0xBF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFB,
  0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0x87, 0xFD,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x9F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F,
  0xF9, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xEF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xEF,
  0xFC, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0,
  0x7F, 0xEF, 0xFC, 0x3F, 0xFB, 0xFF, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x1F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xFE, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0x83,
  0xFF, 0x8F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x07, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8,
  0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE3,
  0xFF, 0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xF7, 0xFE,
  0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7C,
  0xFF, 0xC0, 0x18, 0xFF, 0xC0, 0x04, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F,
  0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFC, 0x03,
  0xFE, 0x1F, 0xDF, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xEF, 0xE3, 0xFF, 0x00,
  0xFF, 0x8F, 0xF7, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFB, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFD, 0xFE, 0x7F, 0xC0, 0x1F, 0xF9, 0xFC, 0xFF, 0x3F, 0xE0,
  0x07, 0xFD, 0xFE, 0x7F, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x1F, 0xDF, 0xF8,
  0x01, 0xFF, 0x7F, 0x8F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xC7, 0xF7, 0xFC,
  0x00, 0x7F, 0xDF, 0xE3, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xE1, 0xFD, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80,
  0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0x80,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xE3, 0xFF, 0x7F, 0xE0,
  0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xDF, 0xF8, 0x7F, 0xF7, 0xFE, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF7, 0xFC, 0xFF, 0xF8,
  0xFF, 0x1F, 0xFE, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x0C, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x1E, 0x01, 0xFF, 0x8F, 0xF0, 0x3F, 0xF3,
  0xFF, 0x07, 0xFE, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC3,
  0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF,
  0xF8, 0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF,
  0xC0, 0x7F, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xDF, 0xFF, 0x0F, 0xF1, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xE0, 0x61, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x02, 0x7F,
  0xE0, 0x0C, 0xFF, 0xE0, 0x79, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xF0,
  0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0xE7, 0xFC, 0x7F, 0xFD, 0xFF, 0x1F,
  0xFF, 0x7F, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x7F, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0xFF, 0x0F, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0x3F, 0xF0,
  0x03, 0x9F, 0xFE, 0x0F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFE, 0x20, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0xFF, 0xE3, 0xFC, 0x7F, 0xFC, 0xFF, 0x1F, 0xFF, 0x7F, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xDF, 0xF8, 0x7F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFC,
  0x7F, 0xFD, 0xFF, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x04, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF6, 0x00,
  0x0F, 0xFD, 0xF0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC3,
  0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0xE3, 0xFE, 0xFF, 0xF8, 0xFF,
  0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x08, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x40, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x01,
  0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD,
  0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC,
  0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x07, 0xFC, 0x3F, 0xC7, 0xFF, 0x87, 0xFF, 0x9F, 0xE7, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x00,
  0x03, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x7F, 0xF0, 0x7F,
  0xCF, 0xFF, 0x0F, 0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xF3, 0xFF, 0x9F, 0xFC, 0x3F, 0xFB, 0xFF,
  0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF,
  0xBF, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFD,
  0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xE0,
  0xFF, 0xDF, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xC7, 0xFE, 0xFF,
  0xF0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0xFF, 0xE3, 0xFC, 0x7F, 0xFC, 0xFF, 0x1F, 0xFF, 0x7F, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xDF, 0xF8, 0x7F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFC,
  0x7F, 0xFD, 0xFF, 0x0F, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x04, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x7F, 0xC1, 0xE7, 0xFE, 0x03, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x40, 0x0F, 0xFB, 0xC0, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x58, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xDF, 0xF3, 0xFF, 0xF7, 0xFC,
  0x7F, 0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F,
  0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x87,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F,
  0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0xFF,
  0xF0, 0x3F, 0xE7, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0xFF, 0xF0,
  0x7F, 0xE7, 0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFF, 0x1F, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF,
  0x3F, 0xFF, 0xCF, 0xF8, 0x1F, 0xF3, 0xF9, 0xFC, 0xFF, 0x81, 0xFF, 0x3F,
  0x9F, 0xCF, 0xF8, 0x1F, 0xF3, 0xF9, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0x9F,
  0xCF, 0xF8, 0x0F, 0xFB, 0xF9, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xCF,
  0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x0F, 0xFD, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF,
  0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F,
  0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x47, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE8, 0x00, 0x3F, 0xF2, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 44, 16, 3, -43 },
  { 62, 25, 16, 29, 2, -43 },
  { 112, 31, 43, 33, 1, -43 },
  { 279, 24, 49, 30, 3, -46 },
  { 426, 48, 43, 50, 1, -43 },
  { 684, 38, 44, 39, 1, -43 },
  { 893, 11, 16, 15, 2, -43 },
  { 915, 16, 53, 20, 3, -44 },
  { 1021, 17, 53, 20, 0, -44 },
  { 1134, 27, 27, 29, 1, -46 },
  { 1226, 26, 29, 30, 2, -36 },
  { 1321, 12, 17, 16, 2, -9 },
  { 1347, 16, 9, 20, 2, -21 },
  { 1365, 11, 12, 16, 3, -11 },
  { 1382, 25, 44, 26, 0, -43 },
  { 1520, 26, 44, 30, 2, -43 },
  { 1663, 22, 43, 30, 2, -43 },
  { 1782, 26, 43, 30, 1, -43 },
  { 1922, 25, 44, 30, 2, -43 },
  { 2060, 28, 43, 30, 1, -43 },
  { 2211, 24, 44, 30, 3, -43 },
  { 2343, 26, 44, 30, 2, -43 },
  { 2486, 26, 43, 30, 2, -43 },
  { 2626, 26, 44, 30, 2, -43 },
  { 2769, 26, 44, 30, 2, -43 },
  { 2912, 11, 35, 17, 3, -34 },
  { 2961, 12, 42, 17, 2, -34 },
  { 3024, 26, 30, 30, 2, -37 },
  { 3122, 26, 22, 30, 2, -32 },
  { 3194, 26, 30, 30, 2, -37 },
  { 3292, 23, 44, 24, 0, -43 },
  { 3419, 42, 48, 46, 2, -43 },
  { 3671, 34, 43, 34, 0, -43 },
  { 3854, 27, 43, 33, 4, -43 },
  { 4000, 27, 44, 30, 2, -43 },
  { 4149, 29, 43, 35, 4, -43 },
  { 4305, 20, 43, 27, 4, -43 },
  { 4413, 20, 43, 26, 4, -43 },
  { 4521, 31, 44, 36, 2, -43 },
  { 4692, 29, 43, 37, 4, -43 },
  { 4848, 19, 43, 21, 1, -43 },
  { 4951, 18, 56, 17, -4, -43 },
  { 5077, 30, 43, 33, 4, -43 },
  { 5239, 21, 43, 26, 4, -43 },
  { 5352, 41, 43, 48, 4, -43 },
  { 5573, 32, 43, 39, 4, -43 },
  { 5745, 33, 45, 37, 2, -44 },
  { 5931, 26, 43, 31, 4, -43 },
  { 6071, 33, 54, 37, 2, -44 },
  { 6294, 29, 43, 33, 4, -43 },
  { 6450, 24, 44, 27, 2, -43 },
  { 6582, 26, 43, 28, 1, -43 },
  { 6722, 29, 44, 35, 3, -43 },
  { 6882, 34, 43, 34, 0, -43 },
  { 7065, 49, 43, 49, 0, -43 },
  { 7329, 31, 43, 31, 0, -43 },
  { 7496, 32, 43, 32, 0, -43 },
  { 7668, 26, 43, 28, 1, -43 },
  { 7808, 15, 54, 18, 2, -44 },
  { 7910, 25, 44, 26, 0, -43 },
  { 8048, 15, 54, 18, 1, -44 },
  { 8150, 32, 28, 32, 0, -43 },
  { 8262, 30, 7, 30, 0, 4 },
  { 8289, 16, 10, 20, 2, -46 },
  { 8309, 26, 35, 30, 1, -34 },
  { 8423, 27, 47, 31, 3, -46 },
  { 8582, 23, 35, 26, 2, -34 },
  { 8683, 26, 47, 31, 2, -46 },
  { 8836, 25, 35, 29, 2, -34 },
  { 8946, 21, 46, 20, 0, -46 },
  { 9067, 26, 48, 31, 2, -34 },
  { 9223, 26, 46, 32, 3, -46 },
  { 9373, 10, 47, 16, 3, -47 },
  { 9432, 15, 61, 16, -2, -47 },
  { 9547, 29, 46, 31, 3, -46 },
  { 9714, 10, 46, 16, 3, -46 },
  { 9772, 41, 34, 47, 3, -34 },
  { 9947, 26, 34, 32, 3, -34 },
  { 10058, 27, 35, 31, 2, -34 },
  { 10177, 27, 48, 31, 3, -34 },
  { 10339, 26, 48, 31, 2, -34 },
  { 10495, 19, 34, 23, 3, -34 },
  { 10576, 21, 35, 24, 1, -34 },
  { 10668, 20, 41, 21, 0, -40 },
  { 10771, 26, 34, 32, 3, -33 },
  { 10882, 29, 33, 29, 0, -33 },
  { 11002, 44, 33, 44, 0, -33 },
  { 11184, 28, 33, 29, 0, -33 },
  { 11300, 29, 47, 29, 0, -33 },
  { 11471, 22, 33, 24, 1, -33 },
  { 11562, 20, 53, 22, 1, -43 },
  { 11695, 9, 60, 25, 8, -46 },
  { 11763, 20, 53, 22, 1, -43 },
  { 11896, 26, 12, 30, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Black60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK60PT7B_H_
