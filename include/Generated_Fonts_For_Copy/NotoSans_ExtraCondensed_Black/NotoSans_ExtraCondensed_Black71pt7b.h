#ifndef _NOTOSANS_EXTRACONDENSED_BLACK71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8,
  0x1F, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFD, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0x7F, 0xF8, 0x3F, 0xFB,
  0xFF, 0xC1, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF,
  0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x07,
  0xFF, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xBE,
  0x3F, 0x1F, 0xF9, 0xF0, 0x38, 0xFF, 0xCF, 0x80, 0x47, 0xFC, 0x7C, 0x00,
  0x3F, 0xE3, 0xE0, 0x01, 0xFF, 0x9F, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xEF, 0xFE, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0xF8, 0xFF, 0x80, 0x07, 0xC7,
  0xFE, 0x00, 0x3E, 0x3F, 0xE8, 0x01, 0xF1, 0xFF, 0x70, 0x0F, 0x8F, 0xFB,
  0xE0, 0x7C, 0xFF, 0xDF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x87, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x87,
  0xFC, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x87, 0xFC, 0x7F, 0xC1, 0xFF, 0xC0,
  0x7F, 0x8F, 0xF8, 0x7F, 0x87, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0x87,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xC3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x0F, 0xF0, 0x1C, 0x3E, 0x0F, 0xF0,
  0x7C, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x9F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x9F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xDF, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x07, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F,
  0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x01,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xF8, 0x0F,
  0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xE0, 0x7F,
  0xF3, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0x07, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xBF, 0xF9, 0xFF, 0xCF, 0xF8, 0xFF, 0xE3, 0xF8, 0x7F, 0xF0, 0xF8, 0x3F,
  0xF8, 0x3C, 0x1F, 0xFC, 0x0C, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0x0F, 0x80, 0x7F, 0xFC,
  0x1C, 0x00, 0xFF, 0xF0, 0x60, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xF8, 0x0F, 0xFF, 0x83, 0x80, 0x1F, 0xFE, 0x08, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0xF8, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x3F, 0xEF, 0xFE,
  0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x1F, 0xF1, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x18,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFE, 0x7F, 0xFE, 0x0F, 0xFD, 0xFF, 0xFE,
  0x1F, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xEF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xEF, 0xFF,
  0x03, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xCF,
  0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xF8, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x07,
  0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xBF, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xE3,
  0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xE7, 0xFE, 0x03,
  0xFF, 0x1F, 0xFC, 0x01, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x30, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x7F,
  0xE1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0x80,
  0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF9,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xE1, 0xE0, 0x0F, 0xFF, 0x18,
  0x00, 0xFF, 0xF1, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x78, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE3, 0xFE, 0x1F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xE3,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0xFF,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF7, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xDF, 0xE1, 0xFF, 0x03, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFE, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF1, 0xFE, 0x0F,
  0xF8, 0xFF, 0xE3, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xE3,
  0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xBF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFC, 0x1F, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x01, 0xFF,
  0xF7, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x07,
  0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xC0, 0xFF, 0xFD, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xE1, 0xFF, 0xF8, 0x03,
  0xC3, 0xFF, 0xE0, 0x01, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0x1F, 0xFF, 0x80,
  0x0E, 0x3F, 0xFF, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF8, 0x3F, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F,
  0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xF0,
  0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xF8, 0x03,
  0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0x03, 0xFF,
  0xF8, 0x00, 0x70, 0x3F, 0xFF, 0x00, 0x01, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF,
  0xC0, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF,
  0x3F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0x80,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F,
  0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x03, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xC1, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F,
  0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xE7,
  0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF, 0xF8,
  0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xE7, 0xFC, 0x7F, 0xFF, 0xFE,
  0x3F, 0xF7, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFB, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xDF, 0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF,
  0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F, 0xFE,
  0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFE, 0x00,
  0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xE7,
  0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0x7F,
  0xF8, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x01,
  0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFE,
  0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xFF,
  0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0,
  0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFC, 0x03,
  0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFE,
  0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0x80, 0x7C, 0xFF, 0xF8, 0x01, 0xCF, 0xFF, 0x80, 0x04, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFE,
  0x7F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFD, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE1,
  0xFF, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xDF, 0xF0, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0xFF,
  0x1F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x3F, 0xC7, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xCF, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF3, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xCF, 0xF8, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFB, 0xFE, 0x3F,
  0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0x8F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF,
  0xBF, 0xE1, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xF8,
  0x00, 0x1F, 0xFB, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x8F,
  0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xFC,
  0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00,
  0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF9,
  0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC3, 0xFF, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0x3F, 0xFF, 0xCF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xF1, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0x00,
  0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0xC3,
  0xFF, 0xBF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0x7F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0x80, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0xFF,
  0xF7, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0x87, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0x87, 0xFE, 0x7F, 0xFE, 0x0F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1E, 0x3F, 0xFE, 0x00, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x17, 0xFF,
  0x80, 0x04, 0xFF, 0xF8, 0x03, 0x9F, 0xFF, 0x83, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x7E, 0x0F, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0x03,
  0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0x7F,
  0xF8, 0x1F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F,
  0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE3, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x09,
  0xFF, 0xE0, 0x00, 0x43, 0xFF, 0xC0, 0x0F, 0x0F, 0xFF, 0xF7, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xE2, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x07, 0xFF,
  0xE7, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF8,
  0x1F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8,
  0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xEF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF,
  0x0F, 0xFF, 0x00, 0x38, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x20, 0x00, 0x1F, 0xFE, 0x38, 0x00,
  0x1F, 0xFE, 0x3F, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFF, 0xC3, 0xFF, 0x3F, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xC3, 0xFE,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF,
  0x3F, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x9F, 0xFC, 0x07, 0xFF,
  0x8F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF9, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE,
  0x7F, 0xF0, 0x0F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xDF, 0xFC, 0x01, 0xFF,
  0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE3, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x7F, 0xFE, 0x0F, 0xFC,
  0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1,
  0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x03,
  0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xDF,
  0xFF, 0x07, 0xFF, 0xBF, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xF8, 0x3F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xE0, 0x78, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC7, 0xFF,
  0x07, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF,
  0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xCF, 0xFF,
  0x01, 0xFF, 0x0F, 0xFF, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0x0B,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0x3C, 0xFF,
  0xE0, 0x08, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0x07, 0xFF, 0xC7, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFB, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0x3F,
  0xF0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xC7, 0xFD, 0xFE,
  0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xF9,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0x9F, 0xF3, 0xFF, 0x00, 0xFF, 0xEF,
  0xF9, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0xFF, 0x9F, 0xF3, 0xFF, 0x00, 0xFF,
  0xEF, 0xF9, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0x9F, 0xF7, 0xFF, 0x00,
  0x7F, 0xEF, 0xF8, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x0F, 0xF7, 0xFE,
  0x00, 0x7F, 0xEF, 0xF0, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x3F, 0xFB, 0xFF,
  0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F,
  0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x21, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x03, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0xC0, 0x01, 0xFF,
  0xFC, 0x80, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 52, 19, 3, -51 },
  { 86, 29, 19, 34, 3, -51 },
  { 155, 37, 51, 39, 1, -51 },
  { 391, 29, 58, 35, 3, -54 },
  { 602, 56, 52, 60, 2, -51 },
  { 966, 44, 52, 46, 2, -51 },
  { 1252, 12, 19, 18, 3, -51 },
  { 1281, 20, 63, 23, 3, -52 },
  { 1439, 20, 63, 23, 0, -52 },
  { 1597, 32, 32, 34, 1, -54 },
  { 1725, 31, 34, 36, 2, -42 },
  { 1857, 14, 20, 19, 2, -10 },
  { 1892, 19, 10, 23, 2, -24 },
  { 1916, 13, 13, 19, 3, -12 },
  { 1938, 30, 52, 30, 0, -51 },
  { 2133, 31, 52, 35, 2, -51 },
  { 2335, 25, 51, 35, 3, -51 },
  { 2495, 30, 51, 35, 1, -51 },
  { 2687, 30, 52, 35, 2, -51 },
  { 2882, 33, 51, 35, 1, -51 },
  { 3093, 28, 52, 35, 4, -51 },
  { 3275, 31, 52, 35, 2, -51 },
  { 3477, 30, 51, 35, 3, -51 },
  { 3669, 31, 52, 35, 2, -51 },
  { 3871, 31, 52, 35, 2, -51 },
  { 4073, 13, 41, 20, 3, -40 },
  { 4140, 14, 50, 20, 2, -40 },
  { 4228, 31, 35, 36, 2, -43 },
  { 4364, 31, 26, 36, 2, -38 },
  { 4465, 31, 35, 36, 2, -43 },
  { 4601, 28, 52, 29, 0, -51 },
  { 4783, 50, 56, 54, 2, -51 },
  { 5133, 41, 51, 41, 0, -51 },
  { 5395, 33, 51, 40, 4, -51 },
  { 5606, 31, 52, 36, 3, -51 },
  { 5808, 35, 51, 42, 4, -51 },
  { 6032, 25, 51, 31, 4, -51 },
  { 6192, 24, 51, 31, 4, -51 },
  { 6345, 36, 52, 42, 3, -51 },
  { 6579, 35, 51, 43, 4, -51 },
  { 6803, 21, 51, 25, 2, -51 },
  { 6937, 20, 67, 21, -4, -51 },
  { 7105, 36, 51, 39, 4, -51 },
  { 7335, 25, 51, 30, 4, -51 },
  { 7495, 49, 51, 57, 4, -51 },
  { 7808, 38, 51, 47, 4, -51 },
  { 8051, 38, 52, 44, 3, -51 },
  { 8298, 31, 51, 37, 4, -51 },
  { 8496, 38, 63, 44, 3, -51 },
  { 8796, 35, 51, 39, 4, -51 },
  { 9020, 28, 52, 32, 2, -51 },
  { 9202, 30, 51, 33, 1, -51 },
  { 9394, 34, 52, 42, 4, -51 },
  { 9615, 40, 51, 40, 0, -51 },
  { 9870, 58, 51, 58, 0, -51 },
  { 10240, 37, 51, 37, 0, -51 },
  { 10476, 37, 51, 37, 0, -51 },
  { 10712, 31, 51, 33, 1, -51 },
  { 10910, 17, 64, 22, 3, -52 },
  { 11046, 30, 52, 30, 0, -51 },
  { 11241, 18, 64, 22, 1, -52 },
  { 11385, 38, 34, 38, 0, -51 },
  { 11547, 36, 8, 36, 0, 5 },
  { 11583, 18, 11, 24, 3, -54 },
  { 11608, 30, 41, 35, 2, -40 },
  { 11762, 31, 55, 37, 4, -54 },
  { 11976, 27, 41, 31, 2, -40 },
  { 12115, 32, 55, 37, 2, -54 },
  { 12335, 30, 41, 34, 2, -40 },
  { 12489, 25, 54, 23, 0, -54 },
  { 12658, 32, 57, 37, 2, -40 },
  { 12886, 30, 54, 38, 4, -54 },
  { 13089, 12, 55, 19, 3, -55 },
  { 13172, 18, 72, 19, -3, -55 },
  { 13334, 33, 54, 37, 4, -54 },
  { 13557, 11, 54, 19, 4, -54 },
  { 13632, 49, 40, 56, 4, -40 },
  { 13877, 30, 40, 38, 4, -40 },
  { 14027, 32, 41, 37, 2, -40 },
  { 14191, 31, 57, 37, 4, -40 },
  { 14412, 32, 57, 37, 2, -40 },
  { 14640, 22, 40, 27, 4, -40 },
  { 14750, 24, 41, 28, 2, -40 },
  { 14873, 24, 48, 25, 0, -47 },
  { 15017, 31, 40, 38, 3, -39 },
  { 15172, 35, 39, 35, 0, -39 },
  { 15343, 52, 39, 52, 0, -39 },
  { 15597, 33, 39, 34, 0, -39 },
  { 15758, 35, 56, 35, 0, -39 },
  { 16003, 26, 39, 28, 1, -39 },
  { 16130, 24, 63, 26, 1, -51 },
  { 16319, 10, 71, 30, 10, -55 },
  { 16408, 24, 63, 26, 1, -51 },
  { 16597, 32, 14, 36, 2, -32 },
};

const GFXfont NotoSans_ExtraCondensed_Black71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK71PT7B_H_
