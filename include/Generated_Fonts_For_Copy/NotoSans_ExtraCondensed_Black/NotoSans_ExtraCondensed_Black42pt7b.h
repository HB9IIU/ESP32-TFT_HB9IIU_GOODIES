#ifndef _NOTOSANS_EXTRACONDENSED_BLACK42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C, 0x10, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xEF, 0xE3, 0xF7, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xC0, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xC7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x87, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x01,
  0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xDE, 0x7E, 0xE1,
  0x3E, 0x70, 0x1F, 0xB8, 0x0F, 0xDC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0E, 0xFC, 0x07, 0x3F, 0x03, 0x9F, 0xE1, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x07, 0xC0,
  0x1F, 0xFC, 0x07, 0xC0, 0x0F, 0xFE, 0x03, 0xE0, 0x07, 0xDF, 0x83, 0xE0,
  0x07, 0xE7, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0x9F, 0x1F, 0xC3, 0xEF, 0xCF,
  0x9F, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0x7F, 0xE7, 0xCF, 0xFE, 0x3F, 0xE7,
  0xCF, 0xDF, 0x8F, 0xE3, 0xE7, 0xE7, 0xC0, 0x01, 0xF3, 0xE3, 0xE0, 0x01,
  0xF1, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x7C, 0x00,
  0x7C, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x3E, 0x0F, 0x8F, 0x80,
  0x1F, 0x03, 0xEF, 0xC0, 0x1F, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xE0,
  0x07, 0xC0, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xE1, 0xFF, 0xC3, 0xF8, 0xFF, 0xF9, 0xFE,
  0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0xDF, 0xCF, 0xF7, 0xFF, 0xF3, 0xF8, 0xFF,
  0xF8, 0xFE, 0x3F, 0xFE, 0x3F, 0x87, 0xFF, 0x0F, 0xE0, 0xFF, 0xC3, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF0, 0x07, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x02,
  0x1F, 0x84, 0x79, 0xE7, 0x9F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xE7, 0xE1, 0xFC, 0xFE, 0x0F, 0x0F, 0x00, 0xE1, 0xC0, 0x08, 0x10, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7F, 0x7F, 0x1F, 0xDF,
  0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F,
  0x7F, 0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFD, 0xFB, 0xF9, 0xE7, 0xF1, 0x8F, 0xE2,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xC3, 0xF8,
  0xC0, 0xFE, 0x10, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x03, 0xF8, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x3E, 0xFC, 0x0F, 0xFF, 0x81, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0x9F, 0xC3,
  0xF3, 0xF8, 0x7C, 0x7F, 0x1F, 0x8F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xB8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFE, 0x31, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0xE3, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE3, 0xC1, 0xFB, 0xFC, 0x7E, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8,
  0x7F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F, 0x1F,
  0xDF, 0xC7, 0xE3, 0xFB, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xFD, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F,
  0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xDF, 0xCF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFB, 0xF1, 0xFE, 0xFC, 0x3E, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x3B, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x10, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x08, 0x1F, 0x9F,
  0xCF, 0xF7, 0xFB, 0xFC, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x30,
  0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x3E, 0x0F, 0xFC, 0xF8, 0xF8,
  0xFF, 0xF3, 0xE7, 0xC3, 0xFF, 0xC7, 0x9F, 0x1F, 0x9F, 0x1F, 0x7C, 0x7C,
  0x7C, 0x7D, 0xF3, 0xE1, 0xF1, 0xF7, 0x8F, 0x87, 0xC7, 0xFE, 0x3E, 0x1F,
  0x1F, 0xF8, 0xF8, 0x7C, 0x7F, 0xE3, 0xE1, 0xF1, 0xFF, 0x8F, 0x87, 0xC7,
  0xBE, 0x3E, 0x3F, 0x3E, 0x78, 0xFC, 0xFC, 0xF9, 0xF1, 0xFF, 0xFF, 0xC7,
  0xC7, 0xFD, 0xFF, 0x1F, 0x0F, 0xF7, 0xF8, 0x3E, 0x1F, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x0F, 0xF0,
  0x0F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0x1F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE,
  0xFF, 0x0F, 0xEF, 0xF3, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF3, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xF8, 0x19, 0xFE, 0x02, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x05, 0xFE, 0x06, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFC, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE7,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0x01, 0x8F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFE, 0x0F, 0xEF,
  0xF0, 0x7F, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xCF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xEF,
  0xF0, 0x7F, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF,
  0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFF, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF8,
  0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC, 0xFF,
  0x07, 0xFB, 0xFC, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFB, 0xFF, 0xEF, 0x8F,
  0xDF, 0xFF, 0x7E, 0x7E, 0xFF, 0xFB, 0xF3, 0xF7, 0xFF, 0xDF, 0x9F, 0x3F,
  0xFE, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0x1F, 0xF8, 0xFF, 0xF8, 0xFF,
  0x87, 0xFF, 0xC7, 0xFC, 0x3F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFF, 0x87, 0xF0, 0x7F, 0xFC, 0x1F, 0x83, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF,
  0x07, 0xE0, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xDF, 0xDF, 0xFF, 0xBF, 0x9F, 0xFF, 0x3F,
  0x3F, 0xFE, 0x7F, 0x7F, 0xFC, 0x7E, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8,
  0x7F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xCF, 0xF7, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFD,
  0xFE, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F,
  0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8,
  0x7F, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFF, 0x1F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F,
  0xEF, 0xF0, 0x7F, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFC, 0x3D, 0xFE, 0x04, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC,
  0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0,
  0x0F, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0x03, 0xFD, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0x07, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xE0,
  0xFE, 0x3F, 0x0F, 0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF,
  0xC7, 0xF0, 0xFE, 0x3F, 0xF1, 0xFC, 0x3F, 0x8F, 0xFC, 0x7F, 0x07, 0xE7,
  0xFF, 0x1F, 0x81, 0xF9, 0xFF, 0xEF, 0xE0, 0x7E, 0x7C, 0xFB, 0xF8, 0x1F,
  0xDF, 0x3E, 0xFE, 0x07, 0xF7, 0xCF, 0xBF, 0x80, 0xFD, 0xF3, 0xEF, 0xE0,
  0x3F, 0xFC, 0xFB, 0xF0, 0x0F, 0xFF, 0x3E, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x07, 0xF9, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0x7F, 0x3F, 0x81, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC1, 0xFE, 0x7F, 0x03, 0xFB, 0xFC, 0x0F, 0xF0, 0xFF, 0x01,
  0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F,
  0xBF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF9,
  0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xC3, 0xFC,
  0x40, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFB, 0xF3, 0xFC, 0xFC,
  0x7E, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x18, 0x1F,
  0xCF, 0xC3, 0xFB, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF,
  0xCF, 0xF7, 0xF8, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0xFE,
  0x1F, 0xDF, 0xE3, 0xFB, 0xFE, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0x3F, 0xC7, 0xE3, 0xF0, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x8E, 0x7F, 0x02, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0x7F, 0xCF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0x0F, 0xE1, 0xF9, 0xFC, 0x7F, 0xBF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xE3, 0xFD, 0xFE, 0xFF, 0xBF, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFD, 0xF8, 0x7E, 0x3F, 0x00, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xF1, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x27, 0xF8, 0x38, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xF1, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0x00, 0x01, 0xFC, 0xFC, 0x7F, 0x9F, 0x9F,
  0xFB, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB, 0xF8, 0xFF, 0x7F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xE3, 0xFD, 0xFE,
  0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFB, 0xF8, 0x7E,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFD, 0x00, 0x3F, 0x38, 0x0F, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x18, 0x3F, 0xBF, 0x8F,
  0xFF, 0xF3, 0xF7, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0x30, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF3, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x07, 0x07, 0xE7, 0xF8,
  0xFF, 0x3F, 0x7F, 0xEF, 0xFD, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE,
  0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F,
  0x87, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x0F,
  0xFF, 0xC3, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF,
  0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F,
  0xE1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x7F, 0x00, 0x18, 0x3F,
  0x3F, 0x8F, 0xDF, 0xF3, 0xF7, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xE7, 0xF3, 0xF8, 0x7F, 0x7F, 0x0F,
  0xEF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFE, 0x7F,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x18, 0x1F, 0x9F, 0xC3, 0xF3, 0xFC, 0x7E, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xBF, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7E, 0xFE, 0x1F, 0xDF, 0xE3, 0xFB, 0xFE, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xBF, 0xC7, 0xF3, 0xF0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x01,
  0xFC, 0xFC, 0x7F, 0x9F, 0x9F, 0xFB, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xE7, 0xFB, 0xF8, 0xFF, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7F,
  0x0F, 0xEF, 0xE3, 0xFD, 0xFE, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFB, 0xF8, 0x7E, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x3F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xC0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0x86, 0x7F, 0x04,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFE, 0x3F, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xEF, 0xCF, 0xFB, 0xF1, 0xFC, 0x7C, 0xFE,
  0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x1F, 0xF0, 0xFE, 0xFC, 0x3F, 0xE1, 0xF9, 0xF8, 0x7F, 0xC3, 0xF3,
  0xF8, 0xFF, 0x8F, 0xE7, 0xF1, 0xFF, 0x1F, 0xCF, 0xE3, 0xFE, 0x3F, 0x8F,
  0xCF, 0xBE, 0x7E, 0x1F, 0x9F, 0x7C, 0xFC, 0x3F, 0x3E, 0xF9, 0xF8, 0x7F,
  0x7D, 0xF7, 0xF0, 0xFE, 0xFB, 0xEF, 0xC0, 0xFD, 0xF7, 0xDF, 0x81, 0xFF,
  0xEF, 0xBF, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF7, 0xF0, 0xFE, 0x3F,
  0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFB, 0xF8, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x7F, 0x1F, 0xE7, 0xF0,
  0xFE, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x1E, 0x00, 0x2F,
  0xF8, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF4, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Black42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 31, 11, 2, -30 },
  { 32, 17, 11, 20, 2, -30 },
  { 56, 21, 30, 23, 1, -30 },
  { 135, 17, 34, 21, 2, -32 },
  { 208, 33, 30, 35, 1, -30 },
  { 332, 26, 30, 27, 1, -30 },
  { 430, 7, 11, 11, 2, -30 },
  { 440, 12, 38, 14, 2, -31 },
  { 497, 12, 38, 14, 0, -31 },
  { 554, 19, 19, 20, 0, -32 },
  { 600, 19, 20, 21, 1, -25 },
  { 648, 9, 12, 11, 1, -6 },
  { 662, 11, 6, 14, 1, -14 },
  { 671, 8, 8, 11, 2, -7 },
  { 679, 18, 30, 18, 0, -30 },
  { 747, 18, 30, 21, 1, -30 },
  { 815, 15, 30, 21, 2, -30 },
  { 872, 18, 30, 21, 1, -30 },
  { 940, 18, 30, 21, 1, -30 },
  { 1008, 19, 30, 21, 1, -30 },
  { 1080, 17, 30, 21, 2, -30 },
  { 1144, 18, 30, 21, 1, -30 },
  { 1212, 17, 30, 21, 2, -30 },
  { 1276, 18, 30, 21, 1, -30 },
  { 1344, 18, 30, 21, 1, -30 },
  { 1412, 8, 25, 12, 2, -24 },
  { 1437, 9, 30, 12, 1, -24 },
  { 1471, 19, 21, 21, 1, -26 },
  { 1521, 19, 15, 21, 1, -22 },
  { 1557, 19, 21, 21, 1, -26 },
  { 1607, 16, 31, 17, 0, -30 },
  { 1669, 30, 33, 32, 1, -30 },
  { 1793, 24, 30, 24, 0, -30 },
  { 1883, 20, 30, 23, 2, -30 },
  { 1958, 18, 30, 21, 2, -30 },
  { 2026, 21, 30, 25, 2, -30 },
  { 2105, 15, 30, 19, 2, -30 },
  { 2162, 15, 30, 18, 2, -30 },
  { 2219, 21, 30, 25, 2, -30 },
  { 2298, 21, 30, 26, 2, -30 },
  { 2377, 13, 30, 15, 1, -30 },
  { 2426, 13, 39, 12, -3, -30 },
  { 2490, 22, 30, 23, 2, -30 },
  { 2573, 15, 30, 18, 2, -30 },
  { 2630, 29, 30, 34, 2, -30 },
  { 2739, 23, 30, 28, 2, -30 },
  { 2826, 22, 30, 26, 2, -30 },
  { 2909, 19, 30, 22, 2, -30 },
  { 2981, 22, 37, 26, 2, -30 },
  { 3083, 21, 30, 23, 2, -30 },
  { 3162, 17, 30, 19, 1, -30 },
  { 3226, 18, 30, 19, 1, -30 },
  { 3294, 20, 30, 25, 2, -30 },
  { 3369, 24, 30, 24, 0, -30 },
  { 3459, 34, 30, 34, 0, -30 },
  { 3587, 22, 30, 22, 0, -30 },
  { 3670, 22, 30, 22, 0, -30 },
  { 3753, 18, 30, 20, 1, -30 },
  { 3821, 10, 38, 13, 2, -31 },
  { 3869, 18, 30, 18, 0, -30 },
  { 3937, 10, 38, 13, 1, -31 },
  { 3985, 22, 20, 23, 0, -30 },
  { 4040, 21, 5, 21, 0, 3 },
  { 4054, 11, 7, 14, 2, -32 },
  { 4064, 18, 24, 21, 1, -24 },
  { 4118, 19, 32, 22, 2, -32 },
  { 4194, 16, 24, 18, 1, -24 },
  { 4242, 19, 32, 22, 1, -32 },
  { 4318, 18, 24, 20, 1, -24 },
  { 4372, 15, 32, 14, 0, -32 },
  { 4432, 19, 34, 22, 1, -24 },
  { 4513, 18, 32, 22, 2, -32 },
  { 4585, 7, 33, 11, 2, -33 },
  { 4614, 11, 43, 11, -2, -33 },
  { 4674, 20, 32, 22, 2, -32 },
  { 4754, 7, 32, 11, 2, -32 },
  { 4782, 29, 24, 33, 2, -24 },
  { 4869, 18, 24, 22, 2, -24 },
  { 4923, 19, 24, 22, 1, -24 },
  { 4980, 19, 34, 22, 2, -24 },
  { 5061, 19, 34, 22, 1, -24 },
  { 5142, 13, 24, 16, 2, -24 },
  { 5181, 15, 24, 17, 1, -24 },
  { 5226, 14, 28, 15, 0, -28 },
  { 5275, 18, 23, 22, 2, -23 },
  { 5327, 21, 23, 21, 0, -23 },
  { 5388, 31, 23, 31, 0, -23 },
  { 5478, 20, 23, 20, 0, -23 },
  { 5536, 21, 33, 21, 0, -23 },
  { 5623, 15, 23, 17, 1, -23 },
  { 5667, 14, 37, 15, 1, -30 },
  { 5732, 6, 42, 18, 6, -32 },
  { 5764, 14, 37, 15, 1, -30 },
  { 5829, 19, 8, 21, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Black42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK42PT7B_H_
