#ifndef _NOTOSANS_EXTRACONDENSED_BLACK39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0x3F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFC, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0xF0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0xF1,
  0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE1, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFB,
  0x9C, 0xFB, 0x84, 0xFB, 0x80, 0xFB, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xBE, 0x03,
  0x9F, 0x83, 0x9F, 0xC3, 0xBE, 0xF3, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xF0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7F, 0x80, 0x7C, 0x01, 0xFF, 0x80, 0xF0, 0x03, 0xFF,
  0x03, 0xE0, 0x0F, 0x9F, 0x07, 0xC0, 0x1F, 0x3E, 0x1F, 0x00, 0x3E, 0x7C,
  0x3E, 0x00, 0x7C, 0xF8, 0x78, 0x00, 0xF9, 0xF1, 0xF0, 0x01, 0xF3, 0xE3,
  0xE0, 0x03, 0xE7, 0xCF, 0x80, 0x07, 0xCF, 0x9F, 0x1F, 0x0F, 0x9F, 0x3C,
  0x7F, 0x8F, 0xFC, 0xF9, 0xFF, 0x1F, 0xF9, 0xF7, 0xFF, 0x1F, 0xE7, 0xCF,
  0xBE, 0x1F, 0x8F, 0x9F, 0x3C, 0x00, 0x1E, 0x3C, 0x7C, 0x00, 0x7C, 0xF8,
  0xF8, 0x00, 0xF1, 0xF1, 0xF0, 0x03, 0xE3, 0xE3, 0xE0, 0x07, 0xC3, 0xC7,
  0xC0, 0x0F, 0x07, 0xCF, 0x80, 0x3E, 0x0F, 0xBE, 0x00, 0x78, 0x1F, 0xFC,
  0x01, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xBF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0xFE, 0x1F, 0xF8, 0xFE, 0x3F, 0xFC, 0xFE, 0x7F, 0xFC, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFE, 0xFF, 0xFC, 0xFE, 0x7F, 0xF8, 0xFC, 0x3F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x21, 0xF1, 0x9F, 0x79, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFE, 0x07, 0xEF, 0xC3, 0xF3, 0xF8, 0x7C, 0x78, 0x06, 0x1C,
  0x00, 0x82, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9,
  0xFC, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0xBF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xDF, 0x8F, 0xEF, 0xC7, 0xF7, 0xE3, 0xF3, 0xF1, 0xF9, 0xFD, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFF, 0x7F, 0xFF, 0xFD, 0xFC, 0xFB, 0xF8, 0xE7, 0xF0, 0x8F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFF, 0x78, 0x7F, 0x30, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF1, 0xE7,
  0xF8, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x83,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xC3,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xF7,
  0xE0, 0x7D, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8,
  0xF8, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x31, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0xF1,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x01,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0x08,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x10, 0x1F, 0xBF, 0x0F, 0xBF,
  0xCF, 0xDF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xE3, 0xFB, 0xF1, 0xFD, 0xFC, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0xBF, 0x8F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x3F,
  0x9F, 0xBF, 0x8F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFB, 0xFB,
  0xF8, 0xFD, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xDF, 0x8F,
  0xEF, 0xC1, 0xC7, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x39,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x1C, 0x7E, 0x7F, 0x7F, 0x7F,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xE7, 0xFF, 0xEF, 0x9F, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0xFE, 0x3C, 0x3C, 0x3F, 0xF3, 0xE7, 0xC7, 0xFF, 0x1E, 0x7C, 0x7F,
  0xF1, 0xE7, 0x8F, 0x8F, 0x1E, 0x78, 0xF0, 0xF1, 0xFF, 0x9F, 0x0F, 0x1F,
  0xF9, 0xF0, 0xF1, 0xFF, 0x9F, 0x1F, 0x1E, 0xF9, 0xF1, 0xF1, 0xEF, 0x9F,
  0x1F, 0x1E, 0xF9, 0xF1, 0xF1, 0xE7, 0x8F, 0xBF, 0x3C, 0x78, 0xFF, 0xFF,
  0xC7, 0xC7, 0xFB, 0xF8, 0x7C, 0x3F, 0x3F, 0x03, 0xE0, 0x80, 0xC0, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x1F, 0xC0, 0x1C, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF,
  0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xE0,
  0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xC0, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xEF, 0xE3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFE, 0xF9, 0xFC, 0x09, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x09, 0xFF, 0x3C, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0x8F,
  0xF7, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x7F,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xE0, 0x27, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xDF, 0xF3, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFE, 0x7F, 0x8F, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0,
  0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF7, 0xC7, 0xFF, 0xFE, 0xF8, 0xFB, 0xFF, 0xDF, 0x9F, 0x7F, 0xFB,
  0xF3, 0xEF, 0xFF, 0x3E, 0xFD, 0xFF, 0xE7, 0xDF, 0x3F, 0xFE, 0xFF, 0xE7,
  0xFF, 0xDF, 0xFC, 0xFF, 0xF9, 0xFF, 0x9F, 0xFF, 0x3F, 0xE3, 0xFF, 0xE7,
  0xFC, 0x7F, 0xFC, 0xFF, 0x8F, 0xFF, 0x8F, 0xF1, 0xFF, 0xF1, 0xFC, 0x3F,
  0xFE, 0x3F, 0x87, 0xFF, 0xC7, 0xF0, 0xFF, 0xF8, 0x7C, 0x1F, 0xFF, 0x0F,
  0x83, 0xF0, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF3, 0xFF, 0xDF, 0x9F,
  0xFE, 0xFE, 0xFF, 0xF3, 0xF7, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xEF, 0xF1, 0xFC, 0x3F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F,
  0x87, 0xF9, 0xFF, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xEF, 0xF1, 0xFC, 0x3F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x80, 0xFD, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x3F, 0x87, 0xF9, 0xFF, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x1F, 0x9F,
  0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF8, 0x7F,
  0x3F, 0x0F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x1F,
  0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFE, 0x0C, 0xFE,
  0x04, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0xEF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xF7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7E, 0xFE, 0x07, 0xE0,
  0x7E, 0x7E, 0x0F, 0xE0, 0xFE, 0x7E, 0x0F, 0xE0, 0xFE, 0x7E, 0x0F, 0xE0,
  0xFE, 0x7F, 0x0F, 0xF0, 0xFC, 0x7F, 0x0F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF0,
  0xFC, 0x3F, 0x1F, 0xF1, 0xFC, 0x3F, 0x1F, 0xF1, 0xFC, 0x3F, 0x1F, 0xF9,
  0xF8, 0x3F, 0x1F, 0xF9, 0xF8, 0x1F, 0xBE, 0xF9, 0xF8, 0x1F, 0xBE, 0xF9,
  0xF8, 0x1F, 0xBE, 0xFB, 0xF8, 0x1F, 0xBE, 0x7B, 0xF8, 0x1F, 0xBE, 0x7F,
  0xF0, 0x0F, 0xBE, 0x7F, 0xF0, 0x0F, 0xBC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xC3, 0xF1, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0xBF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xF8,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF8,
  0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x83, 0xE0,
  0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0xBF, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x1C, 0x7F, 0x10, 0x3F, 0x00, 0x3F, 0x03,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0x7F,
  0xDF, 0x3F, 0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x78, 0x7E, 0xFE,
  0x3F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFB, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xDF, 0xE7, 0xC7, 0xE0, 0x03, 0xF0, 0x1F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xF7, 0x9F, 0xC1, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x01, 0x7F, 0x0C, 0xFF, 0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x9F, 0x8F, 0xEF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0x7C, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xE0, 0x03, 0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0x41, 0xF8, 0x07, 0xE0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0x8F, 0x8F,
  0xE7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0x3F, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7C, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x40, 0x1F, 0xB8, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0xF8, 0x7E, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFC, 0x7D, 0xFB, 0xF7, 0xFF, 0xCF,
  0x80, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x0F, 0x87,
  0xE1, 0xF8, 0x7F, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xEF, 0xFB, 0xFE, 0xFF, 0x3F, 0xCF, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0,
  0xFE, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xEF,
  0xE0, 0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xF3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xC1, 0xFD, 0xF8, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C,
  0x1F, 0x1F, 0x3F, 0xCF, 0xF3, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xFF, 0xF1, 0xFC,
  0x7F, 0xFC, 0x3F, 0x8F, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE,
  0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x0F, 0xE1,
  0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F,
  0xC0, 0xF8, 0xF8, 0x7C, 0xFF, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFC,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F,
  0xEF, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E,
  0x7F, 0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0xF8, 0x78, 0x7C, 0xFE, 0x3F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFB, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xDF, 0xE7, 0xE7,
  0xE3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0x8F, 0x8F, 0xE7,
  0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0xFE, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7C, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0xF8, 0x7F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF3, 0xF1, 0xCF, 0xC1, 0x3F,
  0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xA0, 0x7F, 0xE1, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF1,
  0xFF, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFD, 0xF8, 0xFC, 0x7C, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0x9F, 0x8F, 0xF0, 0xFC,
  0xFC, 0x7F, 0xC7, 0xE7, 0xE3, 0xFE, 0x3F, 0x3F, 0x1F, 0xF3, 0xF1, 0xFC,
  0xFF, 0x9F, 0x87, 0xEF, 0xBC, 0xFC, 0x3F, 0x7D, 0xE7, 0xE1, 0xFB, 0xEF,
  0xBF, 0x0F, 0xDF, 0x7D, 0xF0, 0x7E, 0xFB, 0xEF, 0x81, 0xF7, 0x9F, 0xFC,
  0x0F, 0xBC, 0xFF, 0xE0, 0x7D, 0xE7, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xDF,
  0xC7, 0xF7, 0xF1, 0xF8, 0xFC, 0xFE, 0x3F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F,
  0xEF, 0xC3, 0xF3, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0xFF, 0x87, 0xF0, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xE7, 0xF0, 0xFC, 0x7E,
  0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xF0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0x20, 0x00, 0x7F, 0x80, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Black39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 15, 10, 19, 2, -28 },
  { 45, 20, 28, 21, 1, -28 },
  { 115, 16, 32, 19, 2, -30 },
  { 179, 31, 28, 33, 1, -28 },
  { 288, 24, 28, 25, 1, -28 },
  { 372, 6, 10, 10, 2, -28 },
  { 380, 11, 35, 13, 2, -29 },
  { 429, 11, 35, 13, 0, -29 },
  { 478, 18, 18, 19, 0, -30 },
  { 519, 17, 19, 20, 1, -23 },
  { 560, 8, 11, 11, 1, -6 },
  { 571, 11, 6, 13, 1, -13 },
  { 580, 7, 7, 11, 2, -7 },
  { 587, 17, 28, 17, 0, -28 },
  { 647, 17, 28, 19, 1, -28 },
  { 707, 15, 28, 19, 1, -28 },
  { 760, 16, 28, 19, 1, -28 },
  { 816, 17, 28, 19, 1, -28 },
  { 876, 18, 28, 19, 1, -28 },
  { 939, 16, 28, 19, 2, -28 },
  { 995, 17, 28, 19, 1, -28 },
  { 1055, 17, 28, 19, 1, -28 },
  { 1115, 17, 28, 19, 1, -28 },
  { 1175, 17, 28, 19, 1, -28 },
  { 1235, 7, 22, 11, 2, -22 },
  { 1255, 8, 27, 11, 1, -22 },
  { 1282, 17, 20, 20, 1, -24 },
  { 1325, 17, 14, 20, 1, -21 },
  { 1355, 17, 20, 20, 1, -24 },
  { 1398, 15, 28, 16, 0, -28 },
  { 1451, 28, 31, 30, 1, -28 },
  { 1560, 22, 28, 22, 0, -28 },
  { 1637, 18, 28, 22, 2, -28 },
  { 1700, 17, 28, 20, 2, -28 },
  { 1760, 19, 28, 23, 2, -28 },
  { 1827, 14, 28, 17, 2, -28 },
  { 1876, 14, 28, 17, 2, -28 },
  { 1925, 19, 28, 23, 2, -28 },
  { 1992, 19, 28, 24, 2, -28 },
  { 2059, 12, 28, 14, 1, -28 },
  { 2101, 11, 37, 11, -2, -28 },
  { 2152, 20, 28, 22, 2, -28 },
  { 2222, 14, 28, 17, 2, -28 },
  { 2271, 27, 28, 31, 2, -28 },
  { 2366, 21, 28, 26, 2, -28 },
  { 2440, 21, 28, 24, 2, -28 },
  { 2514, 17, 28, 20, 2, -28 },
  { 2574, 21, 35, 24, 2, -28 },
  { 2666, 19, 28, 21, 2, -28 },
  { 2733, 16, 28, 18, 1, -28 },
  { 2789, 16, 28, 18, 1, -28 },
  { 2845, 19, 28, 23, 2, -28 },
  { 2912, 22, 28, 22, 0, -28 },
  { 2989, 32, 28, 32, 0, -28 },
  { 3101, 20, 28, 20, 0, -28 },
  { 3171, 21, 28, 21, 0, -28 },
  { 3245, 17, 28, 18, 1, -28 },
  { 3305, 9, 36, 12, 2, -29 },
  { 3346, 16, 28, 17, 0, -28 },
  { 3402, 9, 36, 12, 1, -29 },
  { 3443, 21, 19, 21, 0, -28 },
  { 3493, 20, 4, 20, 0, 3 },
  { 3503, 10, 6, 13, 2, -30 },
  { 3511, 16, 22, 19, 1, -22 },
  { 3555, 17, 30, 20, 2, -30 },
  { 3619, 15, 22, 17, 1, -22 },
  { 3661, 17, 30, 20, 1, -30 },
  { 3725, 17, 22, 19, 1, -22 },
  { 3772, 14, 30, 13, 0, -30 },
  { 3825, 17, 31, 20, 1, -22 },
  { 3891, 17, 30, 21, 2, -30 },
  { 3955, 7, 30, 10, 2, -30 },
  { 3982, 10, 39, 10, -1, -30 },
  { 4031, 19, 30, 20, 2, -30 },
  { 4103, 6, 30, 10, 2, -30 },
  { 4126, 27, 22, 31, 2, -22 },
  { 4201, 17, 22, 21, 2, -22 },
  { 4248, 18, 22, 20, 1, -22 },
  { 4298, 17, 31, 20, 2, -22 },
  { 4364, 17, 31, 20, 1, -22 },
  { 4430, 12, 22, 15, 2, -22 },
  { 4463, 14, 22, 15, 1, -22 },
  { 4502, 13, 26, 14, 0, -26 },
  { 4545, 17, 22, 21, 2, -22 },
  { 4592, 19, 22, 19, 0, -22 },
  { 4645, 29, 22, 29, 0, -22 },
  { 4725, 18, 22, 19, 0, -22 },
  { 4775, 19, 31, 19, 0, -22 },
  { 4849, 14, 22, 15, 1, -22 },
  { 4888, 14, 35, 14, 0, -28 },
  { 4950, 6, 39, 16, 5, -30 },
  { 4980, 13, 35, 14, 1, -28 },
  { 5037, 17, 7, 20, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Black39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK39PT7B_H_
