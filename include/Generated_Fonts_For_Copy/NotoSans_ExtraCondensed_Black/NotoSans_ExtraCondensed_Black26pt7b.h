#ifndef _NOTOSANS_EXTRACONDENSED_BLACK26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDC, 0xE0, 0x00, 0x9F, 0xFF,
  0xDC, 0xFB, 0xFE, 0x7F, 0xCF, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0x70, 0x0E,
  0xE0, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3D, 0xC1, 0xCE, 0x0E, 0x71, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0xEE, 0x07,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0x04, 0x00, 0x80, 0x7E, 0x3F, 0xE7,
  0xFD, 0xEB, 0xBD, 0x07, 0xA0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x0B, 0xE1, 0x7F, 0x2F, 0xFF, 0xDF, 0xF1, 0xFC, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x38, 0x0E, 0x07, 0xE0, 0xE0, 0xFE, 0x1C, 0x0E, 0xF1, 0xC0, 0xE7,
  0x3C, 0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x77, 0x00, 0xEF, 0x73, 0xEF,
  0xEF, 0x7E, 0x7E, 0xEF, 0xF3, 0x8E, 0xE7, 0x01, 0xCE, 0x70, 0x1C, 0xE7,
  0x03, 0x8E, 0x70, 0x38, 0xE7, 0x03, 0x8F, 0xF0, 0x70, 0x7E, 0x07, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0x79,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x3E, 0x7F, 0xBE, 0xFF,
  0xFC, 0xF3, 0xFC, 0xF3, 0xFC, 0xF1, 0xF8, 0xFB, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0xBF, 0xFF, 0xBD, 0xEF, 0x7B, 0xC0, 0x1E, 0x38, 0xF1, 0xE7,
  0x8F, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x78, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x80, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x07, 0x06, 0x76, 0x7F, 0xFF, 0xFF, 0x3F,
  0xC1, 0xF8, 0x3F, 0xC7, 0xDE, 0x39, 0xC0, 0x88, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x7B, 0xDF, 0xEF, 0x7B, 0xDC, 0xFF, 0xFF, 0xFF, 0xF0, 0x27,
  0xFF, 0xF7, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x3F, 0xEF,
  0xBD, 0xE7, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE7, 0xFE, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC3,
  0xE3, 0xF3, 0xFB, 0xFF, 0xFE, 0xEF, 0x27, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1E, 0x1F, 0xEF, 0xFB, 0xFF,
  0x63, 0xD0, 0xF0, 0x3C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x1F, 0xF3, 0xFF, 0x3F,
  0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x7E, 0x3F, 0x87, 0xE0, 0xFF, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F,
  0xE1, 0xDF, 0x1E, 0xF8, 0xE7, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x80,
  0xF0, 0x1E, 0x03, 0xF8, 0x7F, 0x8F, 0xF9, 0xFF, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0xFF, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC, 0x00, 0x07, 0xC3, 0xF8, 0xFF,
  0x3F, 0xE7, 0x80, 0xF0, 0x3C, 0x07, 0xBC, 0xFF, 0xDF, 0xFF, 0xEF, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xFF, 0x7F, 0xC7, 0xF8, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x0F, 0xF1, 0xFF, 0x7F, 0xEF, 0x3F, 0xE7, 0xDE, 0xF3,
  0xFE, 0x3F, 0x87, 0xE1, 0xFF, 0x7F, 0xEF, 0x3F, 0xE3, 0xFC, 0x7F, 0xDF,
  0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0x1E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0x3F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xFF, 0xFF, 0xBE, 0xF3, 0x9E, 0x07,
  0x80, 0xF2, 0x7E, 0x7F, 0x8F, 0xE1, 0xF8, 0x00, 0x23, 0xFF, 0xF7, 0x80,
  0x00, 0x00, 0x08, 0xFF, 0xFD, 0xE0, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0xF7, 0xFF, 0xDE, 0xF7, 0xB8, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3,
  0xFD, 0xFC, 0x3E, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0x80, 0x70, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xF8, 0x7F,
  0x3F, 0xDF, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1E, 0x1F, 0xEF, 0xFD, 0xFF,
  0x63, 0xC0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x80, 0xF8, 0x3E, 0x0F, 0x81, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF0, 0x3C, 0x38, 0x03, 0x9C, 0x7E, 0xE7, 0x3F, 0x9F, 0x9E,
  0xE7, 0xE7, 0x39, 0xF9, 0xCE, 0x7E, 0x73, 0x9F, 0x9C, 0xE7, 0xE7, 0x39,
  0xF9, 0xFF, 0xEE, 0x7F, 0xF9, 0xCF, 0x3C, 0x70, 0x00, 0x0F, 0x00, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x7D, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0x3C,
  0x1E, 0x78, 0x3D, 0xF0, 0x7F, 0xE0, 0xF8, 0xFC, 0x1F, 0xF3, 0xFF, 0x7F,
  0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0xBF, 0xFF, 0xDF, 0xF3, 0xFF, 0xF9, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0x81,
  0xFF, 0x3F, 0xE7, 0xFE, 0x7C, 0x67, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x27, 0xFE, 0x3F, 0xE3,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF3, 0xEF, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F,
  0xF3, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x03, 0xE0,
  0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0xC1, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x87, 0xFC, 0x3D, 0xF1, 0xEF, 0xFF,
  0x3F, 0xF9, 0xFF, 0xC3, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x1F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xFF, 0x8F, 0xBC, 0x7D, 0xE7,
  0xCF, 0x3C, 0x7B, 0xE3, 0xDE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0x7C, 0x79, 0xE3, 0xCF, 0x9E, 0x7C, 0xF1, 0xF7, 0x8F, 0xBC,
  0x3E, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFD, 0xDD, 0xFE, 0xEE,
  0xFF, 0x7F, 0x7F, 0xBF, 0x3F, 0xCF, 0x9F, 0xE7, 0xCF, 0xF3, 0xE7, 0xF9,
  0xE3, 0xFC, 0x71, 0xE0, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFB, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFD,
  0xEF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF,
  0x0F, 0xC0, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xF7, 0xC7, 0x9F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00,
  0xF8, 0x1F, 0xF3, 0xFF, 0x7F, 0xEF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3,
  0xFF, 0xFB, 0xFF, 0x7F, 0xCF, 0xE1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF7, 0xC7, 0x9F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0xFE,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0xF8, 0xFF,
  0xCF, 0xFE, 0xF3, 0xEF, 0x3E, 0xF3, 0xEF, 0x3E, 0xF7, 0xCF, 0xFC, 0xFF,
  0x8F, 0xF8, 0xF7, 0x8F, 0x7C, 0xF3, 0xCF, 0x3E, 0xF3, 0xEF, 0x1F, 0xF1,
  0xF0, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF, 0xF9, 0xBC, 0x0F, 0x83, 0xF0, 0xFE,
  0x1F, 0xE3, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x7F, 0xFF, 0xFF, 0xBF, 0xE7,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7D, 0xE3, 0xEF, 0xFE, 0x7F, 0xF1, 0xFF, 0x07,
  0xF0, 0xF8, 0x3F, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xE7, 0x87, 0xCF, 0x8F,
  0x0F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF8, 0x79, 0xE0, 0x7B, 0xC0, 0xF7, 0x81,
  0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0xF0, 0x70, 0x7F, 0x83, 0xC7, 0xFE, 0x3E, 0x3E, 0xF1, 0xF1, 0xE7,
  0x8F, 0x8F, 0x3C, 0x7C, 0x79, 0xE3, 0xE3, 0xCF, 0x3F, 0xBE, 0x3D, 0xDD,
  0xF1, 0xEE, 0xEF, 0x0F, 0x77, 0x78, 0x7B, 0xBB, 0xC3, 0xFD, 0xDE, 0x0F,
  0xEF, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0xF8, 0xF9, 0xE3, 0xE7, 0xCF, 0x0F, 0x7C, 0x3D, 0xE0,
  0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0xFF, 0x83, 0xDE, 0x0F, 0x7C, 0x7C, 0xF1, 0xE3, 0xEF, 0x87,
  0xC0, 0xF8, 0x7F, 0xE1, 0xE7, 0x8F, 0x9F, 0x3C, 0x3C, 0xF0, 0xF7, 0xC3,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF,
  0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1E, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0x38, 0x3C, 0xF0,
  0xE1, 0xC7, 0x87, 0x9E, 0x0E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF8, 0xF0, 0xF0, 0xF0, 0x06, 0x0F, 0xF1, 0xFF, 0x3F, 0xE2, 0x3C, 0x07,
  0xCF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0xFF, 0xFB, 0xDF,
  0x78, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x10, 0xF7, 0xCF,
  0xFE, 0xFF, 0xEF, 0x9E, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xEF, 0xFE, 0xFF, 0xCF, 0x7C, 0x06, 0x0F, 0xF7, 0xF9, 0xFE,
  0xF8, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xF6, 0x7F, 0x9F,
  0xE3, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x33, 0xCF, 0x7B,
  0xFF, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xFB, 0xEF, 0xFD, 0xFF, 0x9E, 0x70, 0x06, 0x07, 0xF1, 0xFF, 0x3F, 0xEF,
  0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x7C, 0x27, 0xFC,
  0xFF, 0x8F, 0xF0, 0x0F, 0x0F, 0xCF, 0xE7, 0xE3, 0xC1, 0xE1, 0xFD, 0xFE,
  0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x80, 0x18, 0x07, 0xDD, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFD, 0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0x0F,
  0x01, 0xFC, 0x7F, 0xFF, 0x7F, 0xE7, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE3, 0x3D, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xF0, 0x77,
  0xFE, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x0F, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xFF, 0x7E, 0xFD, 0xF0, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE7, 0xDF, 0x3C,
  0xFB, 0xE7, 0xDE, 0x3D, 0xE1, 0xEF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F,
  0x78, 0xFB, 0xE7, 0xCF, 0x3E, 0x7D, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x87, 0x3D,
  0xF3, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF3, 0xFE, 0x7C, 0xFF, 0x9E,
  0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F,
  0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x9E, 0x3C, 0x01, 0x1E, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x78, 0x06, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF,
  0x1E, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0xBE, 0x7F, 0xE3,
  0xFC, 0x1F, 0x80, 0x03, 0x8F, 0x7C, 0xFF, 0xEF, 0xFE, 0xF9, 0xEF, 0x9F,
  0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9, 0xFF, 0xFE, 0xFF, 0xEF, 0x7E,
  0xF3, 0xCF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x18,
  0x07, 0xDD, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xFD, 0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0xFB, 0xBD, 0xDF, 0xEF, 0xF7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x18, 0x3F, 0xBF,
  0xDF, 0xEF, 0x17, 0xC3, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xFD, 0xFF, 0xF7,
  0xFB, 0xF8, 0x1C, 0x1E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF4, 0xFE, 0x7F, 0x1F, 0x80, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFF, 0x3F,
  0xFF, 0xBF, 0xF7, 0xEE, 0x7D, 0xC0, 0xF8, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3,
  0xE7, 0x9E, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0xF1, 0xF1, 0xEF, 0x3E, 0x3D, 0xE7, 0xCF,
  0x3D, 0xFD, 0xE7, 0xBB, 0xBC, 0xF7, 0x77, 0x8E, 0xEE, 0xF1, 0xDD, 0xDC,
  0x3F, 0xBB, 0x87, 0xF7, 0xF0, 0xFC, 0x7E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0,
  0x3E, 0x3E, 0x00, 0xF9, 0xF7, 0x9E, 0x3F, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0xE7, 0xDE, 0x79, 0xFF, 0x9F,
  0xF8, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87,
  0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xDF, 0xF7,
  0xFC, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x87, 0xC7, 0xE3, 0xF1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x1F, 0x3F, 0x1F, 0x0F, 0xC3, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xF8, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0xF8, 0xF8, 0xF8, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3F, 0x1F, 0x3F, 0x3F, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8,
  0xF8, 0xF0, 0x30, 0x3F, 0xC7, 0xFF, 0xFF, 0xF8, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_Black26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 11, 7, 13, 1, -19 },
  { 23, 13, 19, 14, 1, -19 },
  { 54, 11, 22, 13, 1, -20 },
  { 85, 20, 19, 22, 1, -19 },
  { 133, 16, 19, 17, 1, -19 },
  { 171, 5, 7, 7, 1, -19 },
  { 176, 7, 23, 8, 1, -19 },
  { 197, 7, 23, 8, 0, -19 },
  { 218, 12, 12, 12, 0, -20 },
  { 236, 11, 13, 13, 1, -16 },
  { 254, 5, 8, 7, 1, -4 },
  { 259, 7, 4, 8, 1, -9 },
  { 263, 5, 5, 7, 1, -5 },
  { 267, 11, 19, 11, 0, -19 },
  { 294, 11, 19, 13, 1, -19 },
  { 321, 9, 19, 13, 1, -19 },
  { 343, 10, 19, 13, 1, -19 },
  { 367, 11, 19, 13, 1, -19 },
  { 394, 13, 19, 13, 0, -19 },
  { 425, 11, 19, 13, 1, -19 },
  { 452, 11, 19, 13, 1, -19 },
  { 479, 11, 19, 13, 1, -19 },
  { 506, 11, 19, 13, 1, -19 },
  { 533, 11, 19, 13, 1, -19 },
  { 560, 5, 15, 7, 1, -15 },
  { 570, 5, 19, 7, 1, -15 },
  { 582, 11, 13, 13, 1, -16 },
  { 600, 11, 9, 13, 1, -14 },
  { 613, 11, 13, 13, 1, -16 },
  { 631, 10, 19, 10, 0, -19 },
  { 655, 18, 21, 20, 1, -19 },
  { 703, 15, 19, 15, 0, -19 },
  { 739, 11, 19, 15, 2, -19 },
  { 766, 12, 19, 13, 1, -19 },
  { 795, 12, 19, 15, 2, -19 },
  { 824, 8, 19, 12, 2, -19 },
  { 843, 8, 19, 11, 2, -19 },
  { 862, 13, 19, 15, 1, -19 },
  { 893, 12, 19, 16, 2, -19 },
  { 922, 8, 19, 9, 1, -19 },
  { 941, 8, 25, 8, -2, -19 },
  { 966, 13, 19, 14, 2, -19 },
  { 997, 9, 19, 11, 2, -19 },
  { 1019, 17, 19, 21, 2, -19 },
  { 1060, 14, 19, 17, 2, -19 },
  { 1094, 14, 19, 16, 1, -19 },
  { 1128, 11, 19, 14, 2, -19 },
  { 1155, 14, 23, 16, 1, -19 },
  { 1196, 12, 19, 14, 2, -19 },
  { 1225, 10, 19, 12, 1, -19 },
  { 1249, 12, 19, 12, 0, -19 },
  { 1278, 13, 19, 15, 1, -19 },
  { 1309, 15, 19, 15, 0, -19 },
  { 1345, 21, 19, 21, 0, -19 },
  { 1395, 14, 19, 14, 0, -19 },
  { 1429, 14, 19, 14, 0, -19 },
  { 1463, 11, 19, 12, 1, -19 },
  { 1490, 6, 23, 8, 1, -19 },
  { 1508, 11, 19, 11, 0, -19 },
  { 1535, 7, 23, 8, 0, -19 },
  { 1556, 14, 13, 14, 0, -19 },
  { 1579, 13, 3, 13, 0, 2 },
  { 1584, 7, 4, 9, 1, -20 },
  { 1588, 11, 15, 13, 1, -15 },
  { 1609, 12, 20, 14, 1, -20 },
  { 1639, 10, 15, 11, 1, -15 },
  { 1658, 11, 20, 14, 1, -20 },
  { 1686, 11, 15, 13, 1, -15 },
  { 1707, 9, 20, 9, 0, -20 },
  { 1730, 11, 21, 14, 1, -15 },
  { 1759, 11, 20, 14, 1, -20 },
  { 1787, 5, 20, 7, 1, -20 },
  { 1800, 7, 26, 7, -1, -20 },
  { 1823, 13, 20, 14, 1, -20 },
  { 1856, 5, 20, 7, 1, -20 },
  { 1869, 18, 15, 21, 1, -15 },
  { 1903, 11, 15, 14, 1, -15 },
  { 1924, 12, 15, 13, 1, -15 },
  { 1947, 12, 21, 14, 1, -15 },
  { 1979, 11, 21, 14, 1, -15 },
  { 2008, 9, 15, 10, 1, -15 },
  { 2025, 9, 15, 10, 1, -15 },
  { 2042, 9, 17, 9, 0, -17 },
  { 2062, 11, 14, 14, 1, -14 },
  { 2082, 13, 14, 13, 0, -14 },
  { 2105, 19, 14, 19, 0, -14 },
  { 2139, 12, 14, 12, 0, -14 },
  { 2160, 13, 20, 13, 0, -14 },
  { 2193, 10, 14, 10, 0, -14 },
  { 2211, 9, 23, 10, 0, -19 },
  { 2237, 3, 26, 11, 4, -20 },
  { 2247, 8, 23, 10, 1, -19 },
  { 2270, 11, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Black26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK26PT7B_H_
