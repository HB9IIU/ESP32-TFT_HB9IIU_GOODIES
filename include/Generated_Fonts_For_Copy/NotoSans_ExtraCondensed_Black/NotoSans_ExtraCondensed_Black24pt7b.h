#ifndef _NOTOSANS_EXTRACONDENSED_BLACK24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF3, 0x9C, 0x00, 0x7B, 0xDE, 0xF0,
  0xF7, 0xFC, 0xFF, 0x3F, 0xCE, 0xF3, 0xBC, 0xE0, 0x0E, 0xE0, 0x77, 0x03,
  0xB8, 0x1D, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0xB8, 0x1D, 0xC0, 0xEE,
  0x3F, 0xFD, 0xFF, 0xE3, 0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x80,
  0x0C, 0x03, 0x07, 0xFD, 0xFE, 0xFF, 0xBB, 0x0E, 0xC3, 0xF0, 0x7E, 0x0F,
  0xE0, 0xF8, 0x3F, 0x0D, 0xF3, 0x7F, 0xFB, 0xFE, 0x7F, 0x03, 0x00, 0xC0,
  0x7C, 0x1C, 0x1F, 0x87, 0x03, 0xB8, 0xE0, 0x77, 0x1C, 0x0E, 0xE7, 0x01,
  0xDC, 0xE0, 0x3B, 0xB8, 0x87, 0x77, 0x7C, 0xFC, 0xCF, 0xCF, 0xBB, 0xB8,
  0x07, 0x77, 0x01, 0xCE, 0x70, 0x39, 0xCE, 0x06, 0x3B, 0x81, 0xC7, 0xF0,
  0x38, 0x7E, 0x0E, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xE0, 0x1F, 0x9E, 0x7F, 0x3D, 0xFF, 0xF3,
  0xDF, 0xE7, 0xBF, 0xCF, 0x3F, 0x1E, 0x7E, 0x3F, 0xFE, 0x7F, 0xFC, 0x3F,
  0x7E, 0xFF, 0xFF, 0xFF, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x1C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0,
  0xF0, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x3C, 0x78, 0xE3, 0xC7, 0x1E, 0x00, 0x0E, 0x01, 0xC1, 0x39,
  0x3F, 0xFF, 0xFE, 0xFF, 0x87, 0xC1, 0xFC, 0x7B, 0xC2, 0x30, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x7B, 0xBD, 0xEF, 0x7B, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x3F, 0x1F, 0xE7, 0xFB,
  0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFD, 0xE7, 0xF9, 0xFE, 0x3F, 0x00, 0x0F, 0x8F, 0xC7, 0xE7, 0xF7, 0xFF,
  0xBD, 0x9E, 0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x80, 0x3F, 0x0F, 0xF3, 0xFF, 0x39, 0xE2, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xE0, 0x7F, 0x3F, 0xEF, 0xF9, 0x1E, 0x03, 0x81, 0xE1, 0xF8, 0xF8,
  0x3F, 0x0F, 0xE0, 0x7C, 0x0F, 0x03, 0xF3, 0xFF, 0xFB, 0xFE, 0xFE, 0x00,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0xC3, 0xBC,
  0x7B, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x07, 0xF3, 0xFE,
  0xFF, 0x91, 0xF0, 0x3C, 0x0F, 0x03, 0xF1, 0xFF, 0xFB, 0xFE, 0xFE, 0x00,
  0x1F, 0x8F, 0xE7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0F, 0xFB, 0xBE, 0xFF, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0x3F, 0x1F, 0xEF, 0xFF,
  0xCF, 0xF3, 0xFD, 0xE7, 0xF8, 0xFC, 0x3F, 0x1F, 0xEF, 0x7F, 0xCF, 0xF3,
  0xFC, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xDF, 0xF7, 0xFC, 0x0F, 0x03, 0x83, 0xE7,
  0xF1, 0xFC, 0x7C, 0x00, 0xF7, 0xFC, 0xE0, 0x00, 0x00, 0x03, 0xBD, 0xF7,
  0x00, 0xF7, 0xFC, 0xE0, 0x00, 0x00, 0x03, 0xDD, 0xEF, 0x7B, 0xDC, 0x00,
  0x40, 0x30, 0x3C, 0x3F, 0x7F, 0xBF, 0x0F, 0x83, 0xF8, 0x3F, 0x83, 0xF0,
  0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x30, 0x0F, 0x03, 0xF0, 0x7F, 0x83, 0xF0, 0x7C, 0x7F,
  0x7F, 0x3F, 0x0F, 0x03, 0x00, 0x7F, 0x7F, 0xFF, 0xEC, 0xF0, 0x78, 0x3C,
  0x3E, 0x3E, 0x1E, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x78, 0x3C,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xC7, 0x1F, 0x77,
  0x3F, 0xBB, 0x9D, 0xCD, 0xDC, 0xE7, 0xEE, 0x73, 0xF7, 0x39, 0xFB, 0x9C,
  0xDD, 0xCE, 0xEE, 0x7F, 0xF7, 0x3C, 0xF1, 0xC0, 0x00, 0xF0, 0x08, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xDE, 0x0F, 0x38, 0x3C, 0xF0, 0xF3, 0xC3,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0x7C,
  0xFF, 0x9F, 0xFB, 0xFF, 0xFD, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFC, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x00,
  0x1F, 0xE7, 0xF9, 0xFF, 0x3E, 0x6F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF9, 0x9F, 0xF1, 0xFE, 0x1F, 0xC0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xBE, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBE, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xFE, 0xFF, 0x7F, 0xBE, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0xE7, 0xC2,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0xFF, 0x8F,
  0xF8, 0xF7, 0xCF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0xFF, 0xFF,
  0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0x7F,
  0xFE, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF7, 0xEF, 0xDF, 0x00, 0xF8, 0xFF, 0xCF,
  0xBE, 0x79, 0xF7, 0xCF, 0xBC, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x87,
  0xFC, 0x3F, 0xF1, 0xF7, 0x8F, 0xBE, 0x7C, 0xF3, 0xE7, 0x9F, 0x3E, 0xF8,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF,
  0xEE, 0xFF, 0xF7, 0x77, 0xFB, 0xFB, 0xFD, 0xFD, 0xFE, 0x7E, 0xFF, 0x3E,
  0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE3, 0xCF, 0xF1, 0xC7, 0x80, 0xF8, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0xFE, 0xE7, 0xF7,
  0xBF, 0xBD, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F,
  0xF0, 0xF8, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF3, 0xEF, 0x8F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x8F, 0x3E,
  0xF9, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0xFF, 0x1F, 0xFB, 0xFF, 0x7D, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xDF, 0xFF, 0xDF, 0xFB, 0xFC, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF3,
  0xEF, 0x8F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE1, 0xFF, 0x8F, 0x3E, 0xF9, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0xBE, 0xF9,
  0xEF, 0x9E, 0xFB, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x8F, 0xFC, 0xFB,
  0xCF, 0xBE, 0xF9, 0xEF, 0x9E, 0xF8, 0xF0, 0x3F, 0xBF, 0xFF, 0xFE, 0x7F,
  0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x9F,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xF0, 0x7F, 0xC3, 0xDE, 0x1E, 0xF1, 0xF7,
  0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF, 0x07, 0x78, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xF1, 0xFE,
  0x1E, 0x3D, 0xC3, 0xC7, 0xBC, 0xF8, 0xF7, 0x9F, 0x1E, 0xF3, 0xE7, 0x9E,
  0x7E, 0xF3, 0xCF, 0xDE, 0x3B, 0xBB, 0xC7, 0xF7, 0x78, 0xFE, 0xEE, 0x1F,
  0xCD, 0xC3, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x00, 0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x1E,
  0xF1, 0xE7, 0x8F, 0x1E, 0xF0, 0xF8, 0xF0, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3,
  0xC3, 0xDE, 0x1E, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xEF,
  0xFD, 0xFF, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F,
  0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0x87, 0x1C, 0x78, 0xF3, 0x83, 0xBC, 0x1E,
  0xFF, 0xFF, 0xFF, 0xF9, 0xE3, 0xC0, 0x04, 0x1F, 0xC7, 0xF9, 0xFE, 0x43,
  0xC0, 0xF7, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xDE, 0x70,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x21, 0xEF, 0x3F, 0xF7, 0xFE, 0xF3,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0xF7, 0xFE, 0xFF, 0xDE,
  0xF0, 0x04, 0x1F, 0xDF, 0xFF, 0xEF, 0x17, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3E, 0x7F, 0xF7, 0xF9, 0xF8, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x13, 0xDF,
  0x77, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xFF, 0x7F, 0xCF, 0x70, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x2F, 0xF9, 0xFE, 0x3F, 0x80, 0x1F, 0x3F, 0x3F,
  0x3C, 0x3C, 0x7F, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x10, 0x1F, 0x77, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFF, 0x7D, 0xCF, 0xF0, 0x3E, 0x0F, 0xFF,
  0xFF, 0xEF, 0xF0, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x21, 0xFF,
  0x3F, 0xF7, 0xFE, 0xFB, 0xDE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3C, 0x6F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xCF, 0x00, 0x03, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFE, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x04,
  0x77, 0xEF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBE, 0x7F, 0x9F, 0x3F, 0xC7,
  0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF,
  0x1C, 0x7F, 0x8E, 0x3C, 0x02, 0x1D, 0xF3, 0xFF, 0x7F, 0xEF, 0xBD, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0,
  0x04, 0x07, 0xE1, 0xFE, 0x7F, 0xEF, 0x3D, 0xE3, 0xBC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x7B, 0xCF, 0x3F, 0xE7, 0xF8, 0x7E, 0x00, 0x02, 0x1E, 0xF3, 0xFF,
  0x7F, 0xEF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0x7F,
  0xEF, 0xFD, 0xEF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00,
  0x10, 0x1F, 0x77, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xFF, 0x7D, 0xCF, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x02, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x10, 0x7F, 0xFE, 0xFE, 0xE2, 0xF8, 0xFC, 0x7E, 0x3F,
  0x0F, 0x8F, 0xFF, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0x7F, 0xFF,
  0xBF, 0xF3, 0xDE, 0xF0, 0xF7, 0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xC3, 0xBC,
  0x3B, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF3,
  0xE3, 0xFC, 0xF9, 0xE7, 0x3F, 0x79, 0xEF, 0xDE, 0x7B, 0xF7, 0x9E, 0xFD,
  0xC3, 0xF7, 0x70, 0xFD, 0xDC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1E, 0x3E, 0x00, 0xF9, 0xEF, 0x79, 0xEF, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xF9, 0xEF, 0x3D, 0xFF, 0x1E, 0xF0,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x39, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x78, 0x00, 0x7F, 0xBF, 0xDF, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x1F, 0x1F, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0xFC, 0xF8, 0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1E, 0x1F, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x3F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0xC3, 0xE3, 0xF3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x3F, 0x1F, 0x8F, 0x00, 0x70, 0x7F, 0xBF, 0xFF, 0x7F, 0x83, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Black24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 17, 7, 1, -17 },
  { 12, 10, 6, 12, 1, -17 },
  { 20, 13, 17, 13, 0, -17 },
  { 48, 10, 19, 12, 1, -18 },
  { 72, 19, 17, 20, 1, -17 },
  { 113, 15, 17, 15, 1, -17 },
  { 145, 4, 6, 6, 1, -17 },
  { 148, 7, 22, 8, 1, -18 },
  { 168, 7, 22, 8, 0, -18 },
  { 188, 11, 10, 11, 0, -18 },
  { 202, 10, 11, 12, 1, -14 },
  { 216, 5, 7, 7, 1, -4 },
  { 221, 6, 3, 8, 1, -8 },
  { 224, 4, 4, 7, 1, -4 },
  { 226, 10, 17, 10, 0, -17 },
  { 248, 10, 17, 12, 1, -17 },
  { 270, 9, 17, 12, 1, -17 },
  { 290, 11, 17, 12, 0, -17 },
  { 314, 10, 17, 12, 1, -17 },
  { 336, 12, 17, 12, 0, -17 },
  { 362, 10, 17, 12, 1, -17 },
  { 384, 10, 17, 12, 1, -17 },
  { 406, 10, 17, 12, 1, -17 },
  { 428, 10, 17, 12, 1, -17 },
  { 450, 10, 17, 12, 1, -17 },
  { 472, 5, 13, 7, 1, -13 },
  { 481, 5, 16, 7, 1, -13 },
  { 491, 10, 12, 12, 1, -15 },
  { 506, 10, 9, 12, 1, -13 },
  { 518, 10, 12, 12, 1, -15 },
  { 533, 9, 17, 10, 0, -17 },
  { 553, 17, 19, 18, 1, -17 },
  { 594, 14, 17, 14, 0, -17 },
  { 624, 11, 17, 13, 1, -17 },
  { 648, 11, 17, 12, 1, -17 },
  { 672, 12, 17, 14, 1, -17 },
  { 698, 9, 17, 11, 1, -17 },
  { 718, 9, 17, 10, 1, -17 },
  { 738, 12, 17, 14, 1, -17 },
  { 764, 12, 17, 15, 1, -17 },
  { 790, 7, 17, 9, 1, -17 },
  { 805, 7, 22, 7, -1, -17 },
  { 825, 13, 17, 13, 1, -17 },
  { 853, 9, 17, 10, 1, -17 },
  { 873, 17, 17, 19, 1, -17 },
  { 910, 13, 17, 16, 1, -17 },
  { 938, 13, 17, 15, 1, -17 },
  { 966, 11, 17, 12, 1, -17 },
  { 990, 13, 21, 15, 1, -17 },
  { 1025, 12, 17, 13, 1, -17 },
  { 1051, 9, 17, 11, 1, -17 },
  { 1071, 11, 17, 11, 0, -17 },
  { 1095, 12, 17, 14, 1, -17 },
  { 1121, 13, 17, 13, 0, -17 },
  { 1149, 19, 17, 19, 0, -17 },
  { 1190, 13, 17, 12, 0, -17 },
  { 1218, 13, 17, 13, 0, -17 },
  { 1246, 11, 17, 11, 0, -17 },
  { 1270, 6, 22, 7, 1, -18 },
  { 1287, 10, 17, 10, 0, -17 },
  { 1309, 6, 22, 7, 0, -18 },
  { 1326, 13, 11, 13, 0, -17 },
  { 1344, 12, 2, 12, 0, 2 },
  { 1347, 6, 3, 8, 1, -18 },
  { 1350, 10, 14, 12, 1, -14 },
  { 1368, 11, 18, 13, 1, -18 },
  { 1393, 9, 14, 10, 1, -14 },
  { 1409, 10, 18, 13, 1, -18 },
  { 1432, 10, 13, 12, 1, -13 },
  { 1449, 8, 18, 8, 0, -18 },
  { 1467, 10, 20, 13, 1, -14 },
  { 1492, 11, 18, 13, 1, -18 },
  { 1517, 4, 19, 6, 1, -19 },
  { 1527, 6, 25, 6, -1, -19 },
  { 1546, 12, 18, 13, 1, -18 },
  { 1573, 4, 18, 6, 1, -18 },
  { 1582, 17, 14, 19, 1, -14 },
  { 1612, 11, 14, 13, 1, -14 },
  { 1632, 11, 14, 12, 1, -14 },
  { 1652, 11, 20, 13, 1, -14 },
  { 1680, 10, 20, 13, 1, -14 },
  { 1705, 8, 14, 9, 1, -14 },
  { 1719, 8, 14, 10, 1, -14 },
  { 1733, 8, 16, 9, 0, -16 },
  { 1749, 11, 13, 13, 1, -13 },
  { 1767, 12, 13, 12, 0, -13 },
  { 1787, 18, 13, 18, 0, -13 },
  { 1817, 11, 13, 11, 0, -13 },
  { 1835, 12, 19, 12, 0, -13 },
  { 1864, 9, 13, 10, 0, -13 },
  { 1879, 8, 21, 9, 0, -17 },
  { 1900, 4, 25, 10, 3, -19 },
  { 1913, 9, 21, 9, 0, -17 },
  { 1937, 10, 5, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Black24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK24PT7B_H_
