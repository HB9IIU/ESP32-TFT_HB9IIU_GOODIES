#ifndef _NOTOSANS_EXTRACONDENSED_BLACK46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0x7E, 0x04, 0x00, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x01, 0xF9, 0xF8, 0x03, 0xE3,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1,
  0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xDC, 0xF3, 0xF3, 0x82, 0x7E, 0x70, 0x0F, 0xCE,
  0x01, 0xFD, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3B,
  0xF8, 0x07, 0x3F, 0x00, 0xE7, 0xF0, 0x1C, 0xFF, 0x83, 0xBF, 0xFE, 0x7F,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xF8,
  0x07, 0xE0, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xFC, 0x0F, 0xC0, 0x07,
  0xCF, 0xC0, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x0F, 0xC7, 0xE1, 0xF8,
  0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x7E, 0x00, 0x0F,
  0xC7, 0xC7, 0xC3, 0xF0, 0x7C, 0xFC, 0xFC, 0x7F, 0xC7, 0xFF, 0xCF, 0x8F,
  0xFC, 0x7F, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0x9F, 0x9F, 0xFF, 0x1F, 0xF1,
  0xF3, 0xF3, 0xF0, 0xFE, 0x3F, 0x3F, 0x3F, 0x00, 0x03, 0xE3, 0xF1, 0xF0,
  0x00, 0x7E, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xF1, 0xF0, 0x00, 0x7C, 0x3F,
  0x1F, 0x00, 0x0F, 0xC3, 0xF1, 0xF0, 0x00, 0xF8, 0x3F, 0x1F, 0x00, 0x1F,
  0x83, 0xF1, 0xF0, 0x01, 0xF8, 0x3F, 0x3F, 0x00, 0x1F, 0x01, 0xFF, 0xF0,
  0x03, 0xF0, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0x1F, 0xE1, 0xFF, 0xFC, 0xFF, 0x1F,
  0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xF3, 0xFF, 0xFC, 0x7F, 0x8F,
  0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x07, 0xFF,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xF7, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x41, 0xF8, 0x27, 0x1F, 0x8E, 0x7F,
  0xF7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFB, 0xFC,
  0x7F, 0x9F, 0xE3, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0x60, 0x60, 0x02, 0x04,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0xFE, 0xFF, 0x1F,
  0xDF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xEF, 0xE3, 0xF9, 0xFE, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x3E, 0x7F,
  0x1C, 0x7F, 0x08, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xDF, 0xF9, 0xE0, 0xFF, 0x18,
  0x1F, 0xE2, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3E, 0x3F, 0xE1, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0xFF, 0xFC, 0x0F, 0xDF, 0xE0, 0x7E,
  0xFF, 0x07, 0xE7, 0xF8, 0x3F, 0x3F, 0xC3, 0xF1, 0xFE, 0x1F, 0x8F, 0xF1,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x98, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x41, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x07, 0xFB, 0xE1, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xF0, 0x23, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF1, 0xE0, 0x7F, 0x7F, 0x87, 0xF7, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x8F, 0xF7, 0xF8,
  0xFF, 0x3F, 0xDF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF8, 0xFF, 0x7F, 0x0F,
  0xF7, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFD, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x9F, 0xF7, 0xF0, 0xFF, 0x7F, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xDF, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0x7F, 0x8F, 0xF7, 0xFD, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0x7F, 0x1F, 0xF7, 0xF0, 0x7C, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0x02, 0x00, 0x0E, 0x0F, 0xE3, 0xF9, 0xFF,
  0x7F, 0xDF, 0xF3, 0xF8, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xE7,
  0xFC, 0xC0, 0xFF, 0x20, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x03,
  0xF8, 0x7C, 0x7E, 0x0F, 0xFE, 0x7E, 0x7E, 0x1F, 0xFE, 0x3E, 0x7C, 0x3F,
  0xFE, 0x3E, 0xFC, 0x7F, 0x3E, 0x3E, 0xF8, 0x7E, 0x3E, 0x3F, 0xF8, 0xFC,
  0x3E, 0x3F, 0xF8, 0xFC, 0x3E, 0x3F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF8, 0xF8,
  0x3E, 0x3F, 0xF8, 0xF8, 0x7E, 0x3F, 0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0xF8,
  0x7E, 0x3E, 0xF8, 0xFC, 0x7E, 0x3E, 0xF8, 0xFC, 0x7E, 0x7E, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x7F, 0xFF, 0xFC, 0xFC, 0x3F, 0xEF, 0xF8, 0x7C, 0x1F,
  0xC7, 0xF0, 0x7E, 0x07, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0xFF, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0x9F, 0xE0, 0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF,
  0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF1, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFE, 0x3F, 0xEF, 0xF0, 0xFF, 0x7F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xF3, 0xE7, 0xFC,
  0x04, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x06, 0x7F, 0xF1,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xC7, 0xFE, 0xFF, 0x0F, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x0F,
  0xFB, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0x7E, 0x3F, 0xF0, 0x0C, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0xC7,
  0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x8F, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xF7,
  0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x9F, 0xE1, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F,
  0x8F, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFD, 0xFE, 0x07, 0xFB,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x81, 0xFE, 0xFF,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF,
  0x8F, 0xDF, 0xFF, 0xBF, 0x1F, 0xBF, 0xFF, 0x7E, 0x3F, 0x7F, 0xFE, 0xFE,
  0x7E, 0xFF, 0xFC, 0xFD, 0xF9, 0xFF, 0xF9, 0xFB, 0xF3, 0xFF, 0xF3, 0xF7,
  0xE7, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x8F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF8, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFE, 0x0F, 0xC0, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFE, 0xFE,
  0x7F, 0xFE, 0xFE, 0x7F, 0xFE, 0xFF, 0x7F, 0xFE, 0x7F, 0x7F, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xDF, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFF, 0x7F,
  0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x81,
  0xFF, 0x3F, 0xE0, 0xFF, 0x1F, 0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF1, 0xFE, 0xFF,
  0x1F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFE, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xF8,
  0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFB, 0xFC,
  0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x0F,
  0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x7F, 0x8F, 0xF7, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x0F,
  0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xEF, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFC,
  0x1C, 0xFF, 0x00, 0x9F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xFD, 0xFF, 0xBF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F,
  0xE0, 0x7F, 0x3F, 0xC1, 0xFF, 0x03, 0xF9, 0xFE, 0x0F, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0x83, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0x8F, 0xFE, 0x1F, 0xC3, 0xFC,
  0x7F, 0xF1, 0xFE, 0x0F, 0xE3, 0xEF, 0x8F, 0xF0, 0x7F, 0x1F, 0x7C, 0x7F,
  0x83, 0xF9, 0xFB, 0xF3, 0xF8, 0x1F, 0xCF, 0xDF, 0x9F, 0xC0, 0xFE, 0x7E,
  0xFC, 0xFE, 0x03, 0xFB, 0xF7, 0xEF, 0xF0, 0x1F, 0xDF, 0x9F, 0x7F, 0x80,
  0xFE, 0xFC, 0xFB, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F,
  0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF0, 0x0F, 0xEF, 0xF0,
  0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC7, 0xF8,
  0x3F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC,
  0x1F, 0xE3, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x3F,
  0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0,
  0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC3, 0x87, 0xF8, 0x40, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xFB, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xBF, 0x3F, 0xE3, 0xE3, 0xF8, 0x7C,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0xF0, 0x3F, 0xCF, 0xE1, 0xFE, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF7, 0xF8, 0x3F, 0xBF,
  0xC1, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE,
  0x1F, 0xEF, 0xF8, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC7, 0xF3, 0xFE, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFE, 0xF1,
  0xFE, 0x04, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x09, 0xFF, 0x0E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1E, 0x3F, 0xC3, 0xFD, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0x8F, 0xFB, 0xFC, 0x3F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x07,
  0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xDF,
  0xC1, 0xF8, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7E, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x06, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0x9F, 0xC7,
  0xFE, 0xFE, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xF1, 0xFF, 0x7F, 0x87, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF,
  0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x1F, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF8,
  0x3F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x10, 0x07,
  0xF8, 0xF8, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF1, 0xE0, 0xFF, 0x7F, 0x8F,
  0xEF, 0xFC, 0xFE, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xF0,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFD, 0xFE,
  0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFB,
  0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF,
  0x3F, 0xC3, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x01, 0xF0, 0xFC, 0x7F, 0xC7, 0xF8, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x1E, 0x0F, 0xC7, 0xF8,
  0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x3F, 0xCF, 0xF0, 0xFE, 0x7F, 0x87, 0xFB,
  0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFE, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x07,
  0xF3, 0xFC, 0x3F, 0x9F, 0xF1, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0x7F, 0xDF, 0xF1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC3, 0xFD, 0xFF,
  0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0x7F, 0xC7, 0xF9, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x3F, 0xF7, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0x7F, 0x87, 0xFB, 0xF8,
  0x3F, 0xDF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0x7F, 0x1F, 0xF7, 0xF8, 0x3F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0x1C, 0xFE, 0x04, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE2, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFB, 0xF3, 0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0xFF, 0x01, 0xFE, 0xFE,
  0x07, 0xF9, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x87, 0xF0,
  0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x3F,
  0xDF, 0xC3, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xC3, 0xF9, 0xFC, 0x3F, 0xF0,
  0xFE, 0x7F, 0x0F, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF9, 0xFF,
  0xC7, 0xF0, 0xFE, 0x7F, 0xF9, 0xFC, 0x3F, 0x9F, 0xFE, 0x7F, 0x0F, 0xE7,
  0xDF, 0x9F, 0xC3, 0xF9, 0xF7, 0xEF, 0xE0, 0x7F, 0x7C, 0xFB, 0xF8, 0x1F,
  0xFF, 0x3E, 0xFE, 0x07, 0xFF, 0xCF, 0xBF, 0x81, 0xFF, 0xF3, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF9, 0xFE, 0x1F,
  0xE3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x07, 0xF9, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x09, 0xFE, 0x00, 0x5F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 34, 12, 2, -33 },
  { 40, 18, 12, 22, 2, -33 },
  { 67, 23, 33, 25, 1, -33 },
  { 162, 19, 38, 23, 2, -35 },
  { 253, 36, 33, 39, 1, -33 },
  { 402, 29, 33, 30, 1, -33 },
  { 522, 8, 12, 12, 2, -33 },
  { 534, 13, 41, 15, 2, -34 },
  { 601, 13, 41, 15, 0, -34 },
  { 668, 20, 21, 22, 1, -35 },
  { 721, 19, 22, 23, 2, -27 },
  { 774, 10, 13, 13, 1, -7 },
  { 791, 13, 7, 15, 1, -16 },
  { 803, 8, 9, 13, 2, -8 },
  { 812, 19, 33, 20, 0, -33 },
  { 891, 19, 33, 23, 2, -33 },
  { 970, 16, 33, 23, 2, -33 },
  { 1036, 19, 33, 23, 1, -33 },
  { 1115, 20, 33, 23, 1, -33 },
  { 1198, 21, 33, 23, 1, -33 },
  { 1285, 19, 33, 23, 2, -33 },
  { 1364, 20, 33, 23, 1, -33 },
  { 1447, 19, 33, 23, 2, -33 },
  { 1526, 20, 33, 23, 1, -33 },
  { 1609, 20, 33, 23, 1, -33 },
  { 1692, 9, 27, 13, 2, -26 },
  { 1723, 10, 32, 13, 1, -26 },
  { 1763, 20, 23, 23, 1, -28 },
  { 1821, 19, 16, 23, 2, -24 },
  { 1859, 20, 23, 23, 2, -28 },
  { 1917, 18, 34, 18, 0, -33 },
  { 1994, 32, 36, 35, 2, -33 },
  { 2138, 26, 33, 26, 0, -33 },
  { 2246, 21, 33, 26, 3, -33 },
  { 2333, 20, 33, 23, 2, -33 },
  { 2416, 22, 33, 27, 3, -33 },
  { 2507, 16, 33, 20, 3, -33 },
  { 2573, 15, 33, 20, 3, -33 },
  { 2635, 23, 33, 27, 2, -33 },
  { 2730, 22, 33, 28, 3, -33 },
  { 2821, 14, 33, 16, 1, -33 },
  { 2879, 14, 43, 13, -3, -33 },
  { 2955, 23, 33, 25, 3, -33 },
  { 3050, 16, 33, 20, 3, -33 },
  { 3116, 31, 33, 37, 3, -33 },
  { 3244, 24, 33, 30, 3, -33 },
  { 3343, 25, 33, 29, 2, -33 },
  { 3447, 20, 33, 24, 3, -33 },
  { 3530, 25, 41, 29, 2, -33 },
  { 3659, 22, 33, 25, 3, -33 },
  { 3750, 19, 33, 21, 1, -33 },
  { 3829, 19, 33, 21, 1, -33 },
  { 3908, 22, 33, 27, 3, -33 },
  { 3999, 26, 33, 26, 0, -33 },
  { 4107, 37, 33, 37, 0, -33 },
  { 4260, 24, 33, 24, 0, -33 },
  { 4359, 24, 33, 24, 0, -33 },
  { 4458, 20, 33, 22, 1, -33 },
  { 4541, 11, 42, 14, 2, -34 },
  { 4599, 19, 33, 20, 0, -33 },
  { 4678, 11, 42, 14, 1, -34 },
  { 4736, 25, 22, 25, 0, -33 },
  { 4805, 23, 6, 23, 0, 3 },
  { 4823, 12, 7, 16, 2, -35 },
  { 4834, 19, 26, 23, 1, -26 },
  { 4896, 21, 35, 24, 2, -35 },
  { 4988, 18, 26, 20, 1, -26 },
  { 5047, 21, 35, 24, 1, -35 },
  { 5139, 20, 26, 22, 1, -26 },
  { 5204, 16, 35, 15, 0, -35 },
  { 5274, 21, 37, 24, 1, -26 },
  { 5372, 20, 35, 24, 2, -35 },
  { 5460, 8, 36, 12, 2, -36 },
  { 5496, 12, 47, 12, -2, -36 },
  { 5567, 22, 35, 24, 2, -35 },
  { 5664, 8, 35, 12, 2, -35 },
  { 5699, 32, 26, 36, 2, -26 },
  { 5803, 20, 26, 24, 2, -26 },
  { 5868, 21, 26, 24, 1, -26 },
  { 5937, 21, 37, 24, 2, -26 },
  { 6035, 21, 37, 24, 1, -26 },
  { 6133, 15, 26, 17, 2, -26 },
  { 6182, 16, 26, 18, 1, -26 },
  { 6234, 15, 31, 16, 0, -31 },
  { 6293, 20, 25, 24, 2, -25 },
  { 6356, 23, 25, 23, 0, -25 },
  { 6428, 34, 25, 34, 0, -25 },
  { 6535, 22, 25, 22, 0, -25 },
  { 6604, 23, 36, 23, 0, -25 },
  { 6708, 16, 25, 18, 1, -25 },
  { 6758, 15, 41, 17, 1, -33 },
  { 6835, 7, 46, 19, 6, -35 },
  { 6876, 15, 41, 17, 1, -33 },
  { 6953, 21, 9, 23, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Black46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK46PT7B_H_
