#ifndef _NOTOSANS_EXTRACONDENSED_BLACK22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x6F, 0xFF, 0xF7, 0xFB, 0xFD,
  0xFC, 0xFE, 0x77, 0x38, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1, 0xDC, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF1, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xEF, 0xFE, 0x3B, 0x83,
  0xB8, 0x33, 0x03, 0x30, 0x08, 0x04, 0x0F, 0xCF, 0xFF, 0xF7, 0x43, 0xA1,
  0xF0, 0x7E, 0x1F, 0x83, 0xE1, 0x78, 0xBF, 0x7F, 0xFC, 0xFC, 0x08, 0x04,
  0x00, 0x78, 0x38, 0x7E, 0x18, 0x3F, 0x1C, 0x19, 0x8C, 0x0C, 0xEE, 0x06,
  0x67, 0x03, 0x33, 0x39, 0xFB, 0xBE, 0xFD, 0xBF, 0x3D, 0xDD, 0xC0, 0xEE,
  0xE0, 0x67, 0x70, 0x73, 0xB8, 0x31, 0xDC, 0x38, 0x7C, 0x1C, 0x1C, 0x0F,
  0x00, 0x7E, 0x03, 0xFC, 0x0E, 0x70, 0x39, 0xC0, 0xFF, 0x01, 0xF8, 0x07,
  0xCF, 0x3F, 0x39, 0xFF, 0xE7, 0x3F, 0xBC, 0xFC, 0x71, 0xF1, 0xFF, 0xC7,
  0xFF, 0x8F, 0xDF, 0xFF, 0xFE, 0xEE, 0x3C, 0xE7, 0x9C, 0x73, 0xCF, 0x38,
  0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x78, 0xE3, 0xC0, 0xF1, 0xC7, 0x8E,
  0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0xCE, 0x39, 0xCF, 0x00,
  0x0E, 0x03, 0x84, 0xE5, 0xFF, 0xFF, 0xDF, 0xE1, 0xF0, 0xFE, 0x73, 0x84,
  0xC0, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E,
  0x07, 0x00, 0xFF, 0xFE, 0xEE, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x83, 0x81, 0xC1, 0xC0, 0x3C, 0x3F, 0x9F, 0xDE, 0xFF, 0x7F, 0xBF, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFE, 0xFF, 0x7B, 0xF9, 0xFC, 0x7C, 0x0F, 0x1F,
  0x3F, 0x3F, 0x7F, 0xFF, 0x6F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1E, 0x1F, 0xCF, 0xF9, 0xDE, 0x23, 0xC0, 0xE0, 0x78, 0x1E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x1F, 0xF7, 0xFD, 0xFF, 0x3E, 0x7F,
  0xBF, 0xC8, 0xF0, 0x78, 0x38, 0xFC, 0x78, 0x3F, 0x0F, 0xC1, 0xE0, 0xF8,
  0x7F, 0xFF, 0xFD, 0xFC, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F,
  0x0F, 0xE1, 0xFC, 0x77, 0x8E, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x01,
  0xE0, 0x3C, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0x07, 0x83, 0xF9, 0xFE, 0xFF,
  0x83, 0xC1, 0xE0, 0xF8, 0x7F, 0xFB, 0xFD, 0xFC, 0x0F, 0x1F, 0x9F, 0xCF,
  0x0F, 0x07, 0x03, 0xBD, 0xFF, 0xFF, 0xFB, 0xF8, 0xFE, 0x7F, 0x7F, 0xFD,
  0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x3E, 0x3F, 0xBF, 0xFE,
  0xFF, 0x7F, 0xBD, 0xFC, 0x7C, 0x7F, 0x7F, 0xFD, 0xFC, 0x7E, 0x3F, 0xFF,
  0xFC, 0xFC, 0x3C, 0x3F, 0xBF, 0xDE, 0xFE, 0x7F, 0x3F, 0x9F, 0xEF, 0xFF,
  0xBD, 0xCC, 0xE0, 0xF0, 0x77, 0xFB, 0xF9, 0xF8, 0xFF, 0xF6, 0x00, 0x00,
  0x6F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x0F, 0xFF, 0xEE, 0xE0, 0x01, 0x83,
  0xC7, 0xEF, 0xEF, 0x87, 0xC1, 0xF8, 0x3F, 0x07, 0x80, 0xC0, 0x20, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x3F, 0x0F,
  0xE0, 0xF8, 0x7C, 0xFD, 0xF8, 0xF0, 0x60, 0x20, 0x00, 0x3C, 0x7F, 0xBF,
  0xCC, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x00, 0x00, 0x01, 0x81,
  0xE0, 0xF0, 0x78, 0x07, 0xC0, 0x3F, 0xE0, 0xF0, 0xE3, 0x80, 0xE6, 0x3E,
  0xFC, 0xFD, 0xFB, 0xB9, 0xE7, 0x73, 0xCC, 0xE7, 0x99, 0xCF, 0x33, 0xBF,
  0x7F, 0xEE, 0x7B, 0xCC, 0x00, 0x1C, 0x02, 0x1F, 0x78, 0x1F, 0xF0, 0x07,
  0x80, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xF7,
  0x07, 0xBC, 0x39, 0xE1, 0xCF, 0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0x3C, 0x7B,
  0xC3, 0xDE, 0x0F, 0xFE, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xFB,
  0xFC, 0xFF, 0xBC, 0xFF, 0x3F, 0xC7, 0xF3, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F,
  0x0F, 0xF7, 0xF9, 0xE6, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x9F, 0xE3, 0xF8, 0x7E, 0xFC, 0x1F, 0xF3, 0xFF, 0x7F,
  0xEF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x3D, 0xFF, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x0F, 0x87, 0xFD, 0xFF, 0x3E, 0x6F, 0x81, 0xE0, 0x3C, 0x07, 0xBF,
  0xF7, 0xFE, 0xFF, 0xC7, 0xF8, 0xF7, 0x9E, 0xFF, 0xCF, 0xF8, 0xFE, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xFF, 0xDE,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE,
  0xF0, 0xF1, 0xFE, 0x3F, 0xCF, 0x79, 0xEF, 0x79, 0xEF, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xF3, 0xDE, 0x7B, 0xCF, 0x3D, 0xE7, 0xBC, 0x7F, 0x8F, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x37, 0xFF, 0xEF, 0xEF, 0xDF, 0xDF, 0xBF,
  0xBE, 0x7F, 0x3C, 0xFE, 0x79, 0xFC, 0xF3, 0xF9, 0xC7, 0xF8, 0x7F, 0x87,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xF7, 0xF7, 0x7F, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0x1F, 0x03, 0xFC,
  0x7F, 0xE7, 0x9E, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFE, 0x3F, 0xEF,
  0xFB, 0xDF, 0xF3, 0xFC, 0xFF, 0x3F, 0xDF, 0xFF, 0xBF, 0xCF, 0xE3, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF1,
  0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0x79,
  0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xFE,
  0x1F, 0xF3, 0xFE, 0x7B, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0xFC, 0xFF, 0x9F,
  0xE3, 0xDC, 0x7B, 0xCF, 0x39, 0xE7, 0xBC, 0xF7, 0x8F, 0x3E, 0x7F, 0xFF,
  0xF7, 0xE0, 0xF0, 0xF8, 0xFE, 0x7F, 0x1F, 0x0F, 0x87, 0xCF, 0xFF, 0xFE,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1E, 0xFF, 0x9F, 0xF1, 0xF8, 0xF0, 0xFF, 0x0F, 0x70, 0xF7,
  0x8E, 0x78, 0xE7, 0x9E, 0x39, 0xE3, 0x9C, 0x3D, 0xC3, 0xDC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0xF1, 0xC3, 0xFC, 0x78, 0xFF,
  0x1E, 0x39, 0xC7, 0x8E, 0x71, 0xE7, 0x9E, 0xF9, 0xE7, 0xBF, 0x79, 0xEF,
  0xDC, 0x3B, 0xF7, 0x0E, 0xDD, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0xF1, 0xEE, 0x39, 0xEF, 0x1D,
  0xE3, 0xF8, 0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFE, 0x1F, 0xC3,
  0xBC, 0xF7, 0x9C, 0x7F, 0x8F, 0xF0, 0xFF, 0x1E, 0x79, 0xE7, 0x9C, 0x3B,
  0xC3, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0xFF, 0xF0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0xFF, 0xFF, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x06,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC3, 0x9C, 0x70,
  0xE7, 0x0E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x87,
  0x7F, 0x3F, 0x9F, 0xE0, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0xFE,
  0xEF, 0x70, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xCF, 0xFB, 0xFE,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFB, 0xFE, 0xEF, 0x00,
  0x3F, 0x7F, 0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF1, 0xFF, 0x7F, 0x3E,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3B, 0xDD, 0xFF, 0xFF, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x9F, 0xFE, 0xFF, 0x7B, 0x80, 0x3E, 0x3F, 0xBD, 0xFC,
  0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0xFF, 0x9F, 0xC7, 0xE0, 0x1F, 0x3E,
  0x3E, 0x38, 0x38, 0x7E, 0xFE, 0xFE, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x7B, 0xBF, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xF3, 0xFF, 0xDF, 0xEF, 0x70, 0x3C, 0x1F, 0xFF, 0xFE, 0xFE, 0x00, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xCF, 0xFB, 0xFE, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0xEF, 0xF6, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xF3, 0xC6, 0x00, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE7, 0xBC, 0xE7, 0xBC, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xEF, 0x3C, 0xE7, 0x9E, 0xF3, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xBD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9E, 0x7F, 0x3C, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0xF3,
  0x8F, 0xE7, 0x1F, 0xCE, 0x3F, 0x9C, 0x70, 0xEF, 0x3F, 0xEF, 0xFB, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0x3E, 0x1F,
  0xCF, 0xFB, 0xCE, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xBF, 0xE7, 0xF0,
  0xF8, 0xEF, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFF, 0xEF, 0xFB, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x7B,
  0xBF, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xDF, 0xEF,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xEF, 0xDF, 0xFF, 0xDF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x7F, 0xFF, 0xB7, 0x0F, 0x9F, 0x9F,
  0x8F, 0x8F, 0xFF, 0xFF, 0xE0, 0x38, 0x70, 0xE3, 0xFF, 0xFF, 0xDE, 0x3C,
  0x78, 0xF1, 0xE3, 0xC3, 0xE7, 0xCF, 0x80, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xF7, 0xFD, 0xE7, 0xF1, 0xEE,
  0x39, 0xCF, 0x39, 0xE7, 0xB8, 0x77, 0x0E, 0xE1, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x00, 0xF3, 0xCF, 0xF3, 0xCF, 0x73, 0xEF, 0x77, 0xEE, 0x77,
  0xEE, 0x7F, 0xEE, 0x7F, 0x6E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x7C, 0xF3, 0xDE, 0xE7, 0xF8, 0xFE, 0x3F, 0x07, 0xC1, 0xF0,
  0xFC, 0x3F, 0x9E, 0xE7, 0x3F, 0xCF, 0xF1, 0xEE, 0x39, 0xCF, 0x3D, 0xE7,
  0xB8, 0x77, 0x0E, 0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x00, 0xE0,
  0x3C, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x7F, 0x7F, 0x7F, 0x0E, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x7F, 0xFF, 0xFF, 0x0F, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0xFC, 0xF8, 0xF8, 0x7C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F,
  0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0xF8, 0xF8, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F, 0x1F, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0xF8, 0xF8, 0xE0, 0x70, 0xFF, 0xFF, 0xF1, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Black22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 12, 16, 12, 0, -16 },
  { 40, 9, 18, 11, 1, -17 },
  { 61, 17, 16, 18, 1, -16 },
  { 95, 14, 16, 14, 0, -16 },
  { 123, 4, 6, 6, 1, -16 },
  { 126, 6, 19, 7, 1, -16 },
  { 141, 6, 19, 7, 0, -16 },
  { 156, 10, 10, 10, 0, -17 },
  { 169, 9, 11, 11, 1, -13 },
  { 182, 4, 6, 6, 1, -3 },
  { 185, 6, 4, 7, 1, -8 },
  { 188, 4, 4, 6, 1, -4 },
  { 190, 9, 16, 9, 0, -16 },
  { 208, 9, 16, 11, 1, -16 },
  { 226, 8, 16, 11, 1, -16 },
  { 242, 10, 16, 11, 0, -16 },
  { 262, 9, 16, 11, 1, -16 },
  { 280, 11, 16, 11, 0, -16 },
  { 302, 9, 16, 11, 1, -16 },
  { 320, 9, 16, 11, 1, -16 },
  { 338, 9, 16, 11, 1, -16 },
  { 356, 9, 16, 11, 1, -16 },
  { 374, 9, 16, 11, 1, -16 },
  { 392, 4, 12, 6, 1, -12 },
  { 398, 4, 15, 6, 1, -12 },
  { 406, 9, 11, 11, 1, -13 },
  { 419, 9, 8, 11, 1, -12 },
  { 428, 9, 11, 11, 1, -13 },
  { 441, 9, 16, 9, 0, -16 },
  { 459, 15, 18, 17, 1, -16 },
  { 493, 13, 16, 13, 0, -16 },
  { 519, 10, 16, 12, 1, -16 },
  { 539, 10, 16, 11, 1, -16 },
  { 559, 11, 16, 13, 1, -16 },
  { 581, 8, 16, 10, 1, -16 },
  { 597, 8, 16, 10, 1, -16 },
  { 613, 11, 16, 13, 1, -16 },
  { 635, 11, 16, 13, 1, -16 },
  { 657, 6, 16, 8, 1, -16 },
  { 669, 6, 21, 6, -1, -16 },
  { 685, 11, 16, 12, 1, -16 },
  { 707, 8, 16, 9, 1, -16 },
  { 723, 15, 16, 18, 1, -16 },
  { 753, 12, 16, 14, 1, -16 },
  { 777, 12, 16, 14, 1, -16 },
  { 801, 10, 16, 11, 1, -16 },
  { 821, 12, 20, 14, 1, -16 },
  { 851, 11, 16, 12, 1, -16 },
  { 873, 8, 16, 10, 1, -16 },
  { 889, 10, 16, 10, 0, -16 },
  { 909, 11, 16, 13, 1, -16 },
  { 931, 12, 16, 12, 0, -16 },
  { 955, 18, 16, 18, 0, -16 },
  { 991, 11, 16, 11, 0, -16 },
  { 1013, 12, 16, 12, 0, -16 },
  { 1037, 10, 16, 10, 0, -16 },
  { 1057, 5, 20, 7, 1, -16 },
  { 1070, 9, 16, 9, 0, -16 },
  { 1088, 6, 20, 7, 0, -16 },
  { 1103, 12, 11, 12, 0, -16 },
  { 1120, 11, 3, 11, 0, 1 },
  { 1125, 6, 4, 7, 1, -17 },
  { 1128, 9, 12, 11, 1, -12 },
  { 1142, 10, 17, 12, 1, -17 },
  { 1164, 8, 12, 10, 1, -12 },
  { 1176, 9, 17, 12, 1, -17 },
  { 1196, 9, 12, 11, 1, -12 },
  { 1210, 8, 17, 7, 0, -17 },
  { 1227, 9, 17, 12, 1, -12 },
  { 1247, 10, 17, 12, 1, -17 },
  { 1269, 4, 17, 6, 1, -17 },
  { 1278, 6, 22, 6, -1, -17 },
  { 1295, 11, 17, 11, 1, -17 },
  { 1319, 4, 17, 6, 1, -17 },
  { 1328, 15, 12, 17, 1, -12 },
  { 1351, 10, 12, 12, 1, -12 },
  { 1366, 10, 12, 11, 1, -12 },
  { 1381, 10, 17, 12, 1, -12 },
  { 1403, 9, 17, 12, 1, -12 },
  { 1423, 7, 12, 8, 1, -12 },
  { 1434, 7, 12, 9, 1, -12 },
  { 1445, 7, 15, 8, 0, -15 },
  { 1459, 10, 12, 12, 1, -12 },
  { 1474, 11, 12, 11, 0, -12 },
  { 1491, 16, 12, 16, 0, -12 },
  { 1515, 10, 12, 10, 0, -12 },
  { 1530, 11, 17, 11, 0, -12 },
  { 1554, 8, 12, 9, 0, -12 },
  { 1566, 8, 20, 8, 0, -16 },
  { 1586, 3, 22, 9, 3, -17 },
  { 1595, 8, 20, 8, 0, -16 },
  { 1615, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Black22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK22PT7B_H_
