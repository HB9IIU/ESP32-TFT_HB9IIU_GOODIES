#ifndef _NOTOSANS_EXTRACONDENSED_BLACK6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black6pt7bBitmaps[] PROGMEM = {
  0x00, 0xD0, 0xA0, 0x7F, 0xE0, 0x5F, 0x3C, 0xD7, 0x8E, 0xB0, 0xE4, 0xBF,
  0x80, 0x6A, 0x40, 0x95, 0x80, 0x5F, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x69, 0x40, 0xF6, 0xA0, 0x75, 0xE9, 0x70, 0xE8, 0xF0, 0x4B, 0xA0, 0xF8,
  0xE0, 0x7E, 0xB0, 0xE9, 0x20, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39,
  0x80, 0xFC, 0x8F, 0x00, 0xD3, 0x7F, 0xFF, 0x6F, 0xD0, 0xFE, 0xF0, 0x72,
  0x30, 0xF6, 0xF0, 0xFB, 0xFA, 0x76, 0xB0, 0xBE, 0xD0, 0xD7, 0xF8, 0xBA,
  0xD0, 0xAB, 0xDD, 0xBB, 0xDD, 0xBB, 0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB2,
  0xFE, 0xD0, 0xF9, 0xE0, 0xE9, 0x20, 0xB6, 0xB0, 0xB5, 0xA0, 0xAD, 0x54,
  0xA0, 0xA9, 0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0, 0x89, 0x30, 0xD5,
  0xC0, 0x56, 0x80, 0xE0, 0xC0, 0xFF, 0x80, 0x93, 0xDE, 0xEC, 0x27, 0xDE,
  0xFF, 0x80, 0x6E, 0x80, 0xF7, 0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x92, 0xEA,
  0xF8, 0xFB, 0xB0, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8,
  0xDC, 0xBB, 0xB7, 0x80, 0xB9, 0x00, 0xBF, 0x70, 0xEA, 0x80, 0xA9, 0x60,
  0xDC, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Black6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 2, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 1, 3, 2, 0, -3 },
  { 46, 1, 4, 2, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 2, 4, 2, 0, -4 },
  { 53, 4, 4, 5, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 3, 0, -4 },
  { 64, 2, 4, 3, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 1, 5, 2, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 2, 4, 3, 0, -4 },
  { 74, 4, 4, 5, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 5, 4, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 5, 4, 5, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 2, 5, 2, 0, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 2, 5, 2, 0, -4 },
  { 109, 3, 3, 3, 0, -4 },
  { 111, 3, 1, 3, 0, 0 },
  { 112, 2, 1, 2, 0, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 2, 3, 3, 0, -3 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 2, 5, 2, 0, -5 },
  { 124, 3, 4, 3, 0, -3 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 1, 5, 2, 0, -5 },
  { 129, 1, 6, 2, 0, -5 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 1, 5, 2, 0, -5 },
  { 133, 4, 3, 5, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 2, 3, 2, 0, -3 },
  { 144, 2, 3, 2, 0, -3 },
  { 145, 2, 4, 2, 0, -4 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 4, 3, 4, 0, -3 },
  { 152, 3, 3, 3, 0, -3 },
  { 154, 3, 4, 3, 0, -3 },
  { 156, 2, 3, 2, 0, -3 },
  { 157, 2, 5, 2, 0, -4 },
  { 159, 1, 6, 3, 1, -5 },
  { 160, 2, 5, 2, 0, -4 },
  { 162, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Black6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK6PT7B_H_
