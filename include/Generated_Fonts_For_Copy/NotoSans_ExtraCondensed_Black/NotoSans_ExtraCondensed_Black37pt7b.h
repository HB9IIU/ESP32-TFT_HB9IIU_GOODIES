#ifndef _NOTOSANS_EXTRACONDENSED_BLACK37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x7E, 0xFC,
  0xFD, 0xF9, 0xFB, 0xF3, 0xF7, 0xE7, 0xEF, 0x8F, 0xDF, 0x0F, 0xBE, 0x1F,
  0x7C, 0x3E, 0x03, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03,
  0xCF, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F,
  0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3C,
  0x78, 0x07, 0x9F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xC7,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7D, 0xDC, 0xFB, 0x89, 0xE7, 0x03, 0xEE,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0E, 0xF8, 0x1D, 0xF8, 0x3B, 0xFC, 0x7F, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xF8, 0xFF, 0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x1E, 0x00,
  0xFF, 0xC1, 0xF0, 0x0F, 0xBE, 0x0F, 0x80, 0x7C, 0xF0, 0x78, 0x03, 0xE7,
  0x87, 0xC0, 0x1F, 0x3E, 0x3C, 0x00, 0xF1, 0xF3, 0xE0, 0x07, 0x8F, 0x9E,
  0x00, 0x3E, 0x78, 0xF0, 0x01, 0xF3, 0xCF, 0x9F, 0x8F, 0xBE, 0x79, 0xFE,
  0x3F, 0xF7, 0xCF, 0xF9, 0xFF, 0x3C, 0xFF, 0xC7, 0xF1, 0xE7, 0xDF, 0x0E,
  0x1F, 0x3C, 0xF8, 0x00, 0xF1, 0xE7, 0xC0, 0x0F, 0x9F, 0x1E, 0x00, 0x78,
  0xF8, 0xF0, 0x07, 0xC3, 0xCF, 0x80, 0x3E, 0x1E, 0x7C, 0x01, 0xE0, 0xF3,
  0xE0, 0x1F, 0x07, 0xFE, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0x00,
  0x7C, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x9F, 0xC3, 0xFE, 0x3F, 0x8F, 0xFE, 0x7E, 0x3F, 0xFE,
  0xFC, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0xE3, 0xF1, 0xFF, 0xC7, 0xE1, 0xFF,
  0x8F, 0xC3, 0xFE, 0x1F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF8, 0xFE, 0xFD, 0xFB,
  0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x08,
  0x3C, 0x27, 0x9E, 0x73, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xE1, 0xF9, 0xF8, 0x78,
  0xF0, 0x0C, 0x30, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFD, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7E, 0xFC, 0xF3, 0xF1, 0x8F, 0xC2, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xDE,
  0x3F, 0x98, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFE, 0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x01,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xBF, 0x07, 0xDF, 0x87, 0xCF,
  0xC3, 0xE7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x8F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0x88, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xE6, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x20, 0x7D, 0xFC, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7E, 0x3F,
  0x7E, 0x7F, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7E, 0x7E, 0x7E, 0x3F, 0x7E, 0x3E, 0x7E, 0x7E, 0x7F, 0x7E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0xFE, 0x7E,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xBF, 0x1F, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x39, 0xFB, 0xF7, 0xFF, 0xDF, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFD, 0xFF, 0xFF, 0xE7, 0xC0, 0x1C,
  0x7E, 0x7E, 0x7F, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC,
  0xF8, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFF, 0x1F, 0xFE, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0xFF, 0xF0, 0xFF,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0x80, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF2, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0xF8, 0x7F, 0x1E, 0x3C,
  0x3F, 0xE7, 0x9F, 0x1F, 0xF9, 0xF7, 0x8F, 0x9E, 0x3D, 0xE3, 0xC7, 0x8F,
  0xF9, 0xF1, 0xE3, 0xFE, 0x78, 0x78, 0xFF, 0x9E, 0x1E, 0x3F, 0xE7, 0x87,
  0x8F, 0xF9, 0xE3, 0xE3, 0xFE, 0x78, 0xF8, 0xFF, 0x9F, 0x3E, 0x79, 0xE7,
  0xFF, 0xFE, 0x78, 0xFF, 0xFF, 0x1F, 0x1F, 0x9F, 0x87, 0xC1, 0xC1, 0xC0,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x07, 0xF0, 0x0E, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0x7E, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFE, 0x08, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x11, 0xFC, 0x38, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0x1F, 0xEF, 0xC3, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFD,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xE0, 0x23, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0x7E, 0x3F, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x83, 0xF7, 0xF0, 0x7E, 0x7F, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFD, 0xFF,
  0xBF, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0,
  0x7E, 0x7E, 0x1F, 0xCF, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x3F, 0x87, 0xE7,
  0xF0, 0xFD, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0x9F,
  0xC3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F, 0x3F, 0x0F,
  0xE7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x81, 0xFC, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7B, 0xFF,
  0xFF, 0x3E, 0xFF, 0xF7, 0xCF, 0xBF, 0xFD, 0xF3, 0xEF, 0xFF, 0x7C, 0xF3,
  0xFF, 0xCF, 0xFC, 0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0xCF, 0xFF, 0x3F,
  0xE3, 0xFF, 0xC7, 0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF,
  0x1F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F,
  0xFF, 0x0F, 0x83, 0xF0, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0xBF, 0xFD, 0xFB,
  0xFF, 0xCF, 0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFE, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0x1F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFD, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC, 0x1F, 0xFF,
  0x07, 0xF0, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF,
  0xFF, 0xBF, 0x87, 0x7F, 0x02, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xF9, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x87,
  0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x07, 0xF7, 0xE0, 0xFC,
  0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x1F, 0xC1, 0xF9, 0xF8, 0x7F, 0x87,
  0xE7, 0xE1, 0xFE, 0x1F, 0x8F, 0x87, 0xF8, 0xFC, 0x3F, 0x1F, 0xE3, 0xF0,
  0xFC, 0xFF, 0x8F, 0xC3, 0xF3, 0xFF, 0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F,
  0x3F, 0xF3, 0xF0, 0x7C, 0xF7, 0xDF, 0x81, 0xFB, 0xCF, 0x7E, 0x07, 0xFF,
  0x3D, 0xF8, 0x1F, 0xFC, 0xF7, 0xE0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xCF,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xF3, 0xF8,
  0x7E, 0x7E, 0x0F, 0xFF, 0xC1, 0xFC, 0xFE, 0x07, 0xEF, 0xC1, 0xFD, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7F, 0x3F, 0x07, 0xE7, 0xE0, 0xFD,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xF9, 0xF0, 0x1F,
  0x9F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xE7,
  0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0,
  0xF0, 0x03, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xE3, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFC, 0xF3, 0xF1, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x70, 0xFD, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9,
  0xF8, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xF9, 0xFC, 0xE7,
  0xE0, 0xBF, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x5F, 0x83, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1E, 0x3F, 0x1F, 0x9F, 0x9F, 0xEF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF7, 0xFB, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1,
  0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xF7, 0xE3,
  0xF1, 0xF0, 0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7E, 0x3E, 0x7C, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x02, 0x7F, 0xBE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7F, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0x00, 0x0F, 0xCF, 0xCF, 0xF7,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFB, 0xFD, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFE, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xF7, 0xE7, 0xFB,
  0xF1, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x80, 0x7E, 0x78, 0x7F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x80, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0xF0, 0xFD, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x73, 0xFF, 0xFF, 0xFF, 0xE2, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x10,
  0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0xBF, 0xFF, 0xFF, 0xDF, 0xEF, 0xE7, 0xC0, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x1F, 0x9F, 0x9F,
  0xCF, 0xCF, 0xC7, 0xEF, 0xC3, 0xF7, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7F, 0x7E, 0x1F, 0xBF, 0x0F, 0xFF, 0x83, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x3C, 0x7C,
  0xFE, 0x7F, 0xBE, 0xFF, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x7F, 0xF8, 0xFE, 0x3F, 0xFC, 0x3F, 0x1F,
  0xFE, 0x1F, 0x8F, 0xFF, 0x0F, 0xC7, 0xFF, 0x87, 0xE3, 0xFF, 0xC3, 0xF1,
  0xFF, 0xE1, 0xF8, 0xFF, 0xF0, 0xFC, 0x7F, 0xF8, 0x7E, 0x3F, 0xFC, 0x3F,
  0x1F, 0xFE, 0x1F, 0x8F, 0xFF, 0x0F, 0xC7, 0xFF, 0x87, 0xE3, 0xFF, 0xC3,
  0xF1, 0xF8, 0x00, 0xF0, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFD, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFD, 0xF8, 0xFC, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xF0, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFD, 0xFC, 0xFC, 0xF8, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x0F, 0xCF, 0xCF, 0xF7, 0xE7,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFB, 0xFD, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFE, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xF7, 0xE7, 0xFB, 0xF1,
  0xF9, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x9F,
  0xFB, 0xEF, 0xBE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7E, 0x33, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD,
  0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF9, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x9F, 0x3F, 0x1F, 0xFE, 0x0F,
  0xDF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0xC7, 0xC3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xEF, 0x87,
  0xF0, 0xFD, 0xF8, 0xFF, 0x1F, 0x3F, 0x3F, 0xE7, 0xE7, 0xE7, 0xFC, 0xFC,
  0xFC, 0xF7, 0x9F, 0x8F, 0x9E, 0xF3, 0xF1, 0xF3, 0xDE, 0x7C, 0x3F, 0x7B,
  0xEF, 0x87, 0xFF, 0x7D, 0xF0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0xC1,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x3F, 0xBF, 0x9F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7E,
  0xFC, 0x3F, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xFF, 0xC3, 0xF0, 0xFE, 0x0F,
  0xDF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3,
  0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xBF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0xFF, 0x1F, 0xF1,
  0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xF8, 0x00, 0x08, 0x01, 0x7F,
  0x81, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_Black37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 15, 9, 18, 1, -26 },
  { 38, 19, 26, 20, 1, -26 },
  { 100, 15, 30, 18, 2, -28 },
  { 157, 29, 27, 31, 1, -27 },
  { 255, 23, 27, 24, 1, -27 },
  { 333, 7, 9, 9, 1, -26 },
  { 341, 10, 33, 12, 2, -27 },
  { 383, 10, 33, 12, 0, -27 },
  { 425, 17, 16, 18, 0, -28 },
  { 459, 16, 18, 19, 1, -22 },
  { 495, 8, 10, 10, 1, -5 },
  { 505, 10, 6, 12, 1, -13 },
  { 513, 6, 6, 10, 2, -6 },
  { 518, 16, 27, 16, 0, -27 },
  { 572, 16, 27, 18, 1, -27 },
  { 626, 14, 26, 18, 1, -26 },
  { 672, 15, 27, 18, 1, -27 },
  { 723, 16, 27, 18, 1, -27 },
  { 777, 17, 26, 18, 1, -26 },
  { 833, 15, 26, 18, 2, -26 },
  { 882, 16, 27, 18, 1, -27 },
  { 936, 16, 26, 18, 1, -26 },
  { 988, 16, 27, 18, 1, -27 },
  { 1042, 16, 27, 18, 1, -27 },
  { 1096, 7, 21, 10, 2, -21 },
  { 1115, 8, 26, 10, 1, -21 },
  { 1141, 16, 19, 19, 1, -23 },
  { 1179, 16, 14, 19, 1, -20 },
  { 1207, 16, 19, 19, 1, -23 },
  { 1245, 14, 27, 15, 0, -27 },
  { 1293, 26, 30, 28, 1, -27 },
  { 1391, 21, 26, 21, 0, -26 },
  { 1460, 17, 26, 21, 2, -26 },
  { 1516, 17, 27, 19, 1, -27 },
  { 1574, 18, 26, 22, 2, -26 },
  { 1633, 13, 26, 16, 2, -26 },
  { 1676, 13, 26, 16, 2, -26 },
  { 1719, 19, 27, 22, 1, -27 },
  { 1784, 18, 26, 23, 2, -26 },
  { 1843, 11, 26, 13, 1, -26 },
  { 1879, 11, 34, 11, -2, -26 },
  { 1926, 19, 26, 20, 2, -26 },
  { 1988, 13, 26, 16, 2, -26 },
  { 2031, 26, 26, 30, 2, -26 },
  { 2116, 20, 26, 24, 2, -26 },
  { 2181, 21, 27, 23, 1, -27 },
  { 2252, 16, 26, 19, 2, -26 },
  { 2304, 21, 33, 23, 1, -27 },
  { 2391, 18, 26, 20, 2, -26 },
  { 2450, 15, 27, 17, 1, -27 },
  { 2501, 15, 26, 17, 1, -26 },
  { 2550, 18, 26, 22, 2, -26 },
  { 2609, 21, 26, 21, 0, -26 },
  { 2678, 30, 26, 30, 0, -26 },
  { 2776, 19, 26, 19, 0, -26 },
  { 2838, 19, 26, 19, 0, -26 },
  { 2900, 16, 26, 17, 1, -26 },
  { 2952, 9, 33, 11, 2, -27 },
  { 2990, 16, 27, 16, 0, -27 },
  { 3044, 9, 33, 11, 1, -27 },
  { 3082, 20, 17, 20, 0, -26 },
  { 3125, 19, 5, 19, 0, 2 },
  { 3137, 10, 6, 13, 1, -28 },
  { 3145, 15, 21, 18, 1, -21 },
  { 3185, 16, 28, 19, 2, -28 },
  { 3241, 14, 21, 16, 1, -21 },
  { 3278, 17, 28, 19, 1, -28 },
  { 3338, 16, 21, 18, 1, -21 },
  { 3380, 13, 28, 12, 0, -28 },
  { 3426, 17, 30, 19, 1, -21 },
  { 3490, 16, 28, 20, 2, -28 },
  { 3546, 6, 29, 10, 2, -29 },
  { 3568, 9, 38, 10, -1, -29 },
  { 3611, 17, 28, 19, 2, -28 },
  { 3671, 6, 28, 10, 2, -28 },
  { 3692, 25, 21, 29, 2, -21 },
  { 3758, 16, 21, 20, 2, -21 },
  { 3800, 17, 21, 19, 1, -21 },
  { 3845, 16, 30, 19, 2, -21 },
  { 3905, 17, 30, 19, 1, -21 },
  { 3969, 12, 21, 14, 2, -21 },
  { 4001, 13, 21, 15, 1, -21 },
  { 4036, 12, 25, 13, 0, -25 },
  { 4074, 16, 20, 20, 2, -20 },
  { 4114, 18, 20, 18, 0, -20 },
  { 4159, 27, 20, 27, 0, -20 },
  { 4227, 17, 20, 18, 0, -20 },
  { 4270, 18, 29, 18, 0, -20 },
  { 4336, 13, 20, 15, 1, -20 },
  { 4369, 13, 33, 14, 0, -27 },
  { 4423, 5, 37, 16, 5, -29 },
  { 4447, 12, 33, 14, 1, -27 },
  { 4497, 16, 7, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Black37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK37PT7B_H_
