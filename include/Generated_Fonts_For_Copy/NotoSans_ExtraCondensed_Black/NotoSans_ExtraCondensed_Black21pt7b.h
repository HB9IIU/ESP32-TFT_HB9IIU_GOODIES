#ifndef _NOTOSANS_EXTRACONDENSED_BLACK21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x06, 0xFF, 0xE0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x0D, 0xC1, 0xB8, 0x77, 0x0E, 0xC7, 0xFE, 0xFF, 0xC6, 0x60,
  0xDC, 0x1B, 0x9F, 0xFF, 0xFF, 0x9D, 0x83, 0x30, 0x66, 0x0D, 0xC0, 0x08,
  0x18, 0x7F, 0xFF, 0xEB, 0xE8, 0xF8, 0x7C, 0x3E, 0x0F, 0x0F, 0x8B, 0xCF,
  0xFF, 0xFE, 0x08, 0x08, 0x3C, 0x38, 0x3F, 0x1C, 0x1B, 0x8C, 0x0C, 0xCE,
  0x0E, 0x66, 0x03, 0x37, 0x01, 0xBB, 0x3C, 0xFD, 0xBE, 0x3D, 0xDB, 0x80,
  0xCD, 0xC0, 0xEE, 0x60, 0x63, 0x70, 0x71, 0xB8, 0x38, 0xFC, 0x38, 0x3C,
  0x1F, 0x00, 0xFE, 0x03, 0xBC, 0x0E, 0x70, 0x3B, 0x80, 0xFE, 0x01, 0xF0,
  0x0F, 0xDE, 0x7F, 0x79, 0xDF, 0xCF, 0x3F, 0x3C, 0x78, 0x7F, 0xF1, 0xFF,
  0xC3, 0xF7, 0xC0, 0xFF, 0xFE, 0x3C, 0xE7, 0x1C, 0xF3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x38, 0xF0, 0xF1, 0xC3, 0x8E, 0x38, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x9E, 0x73, 0xC0, 0x1E, 0x03, 0x04,
  0xC9, 0xFE, 0xFF, 0xC7, 0x83, 0xF1, 0xFE, 0x33, 0x00, 0x1C, 0x0E, 0x07,
  0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xEE,
  0xEE, 0xFF, 0xFE, 0x6F, 0xFE, 0x03, 0x83, 0x81, 0xC0, 0xC0, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x3C, 0x3F,
  0x3F, 0xDE, 0xEE, 0x77, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xDE, 0xEF,
  0xF3, 0xF0, 0xF8, 0x0E, 0x3C, 0xFB, 0xFF, 0xED, 0xD3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x80, 0x3E, 0x3F, 0xBF, 0xEC, 0xF0, 0x38, 0x3C,
  0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0xFB, 0xFD, 0xFE, 0x7E, 0x7F,
  0xBF, 0xC8, 0xE0, 0x70, 0x79, 0xF8, 0xFC, 0x7F, 0x03, 0x81, 0xF0, 0xEF,
  0xF7, 0xFB, 0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF9,
  0xDE, 0x77, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0x81, 0xE0, 0x78, 0x7F, 0x7F,
  0x7F, 0xF0, 0xF0, 0xFC, 0xFE, 0xFF, 0x0F, 0x07, 0x07, 0x87, 0xFF, 0xFF,
  0xFC, 0x1F, 0x1F, 0x9F, 0xDE, 0x0E, 0x07, 0x73, 0xFD, 0xFE, 0xE7, 0xF3,
  0xF9, 0xFE, 0xFF, 0xF3, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70,
  0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0x7E,
  0x7F, 0xBF, 0xDC, 0xEE, 0x77, 0xF9, 0xF8, 0xFC, 0xFF, 0x73, 0xB9, 0xFC,
  0xFF, 0xFF, 0xF9, 0xF8, 0x3C, 0x3F, 0x3F, 0xDC, 0xEE, 0x7F, 0x3F, 0x9F,
  0xFF, 0xFF, 0xBB, 0x81, 0xC1, 0xEF, 0xE7, 0xF3, 0xE0, 0x6F, 0xFE, 0x00,
  0x00, 0x6F, 0xFF, 0x6F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xEE, 0xE0, 0x00,
  0x81, 0xC3, 0xE7, 0xEF, 0xC7, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xC0, 0x20,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x60, 0x3E, 0x1F,
  0xC1, 0xF8, 0x3C, 0xFD, 0xF8, 0xF0, 0x60, 0x20, 0x00, 0x7E, 0xFF, 0x7F,
  0x47, 0x07, 0x0F, 0x1E, 0x3C, 0x38, 0x38, 0x00, 0x18, 0x38, 0x3C, 0x38,
  0x0F, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x07, 0xE7, 0xEF, 0xBF, 0x3C, 0xCC,
  0xF3, 0x33, 0xDC, 0xCF, 0x33, 0x3C, 0xFF, 0xFB, 0xDE, 0xE2, 0x31, 0xC0,
  0x03, 0xCF, 0x07, 0xFC, 0x03, 0x80, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xFC, 0x39, 0xC3, 0x9C, 0x39, 0xC7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x70, 0xEF, 0x0F, 0xF0, 0xF0, 0xFF, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC,
  0xEF, 0xFB, 0xFC, 0xFF, 0xBC, 0xFF, 0x3F, 0xCF, 0xFF, 0xBF, 0xEF, 0xE0,
  0x1F, 0x9F, 0xDF, 0xFE, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x17, 0xFB, 0xFC, 0x7C, 0xFE, 0x1F, 0xF3, 0xFE, 0x79, 0xEF, 0x3D,
  0xE3, 0xBC, 0x77, 0x8F, 0xF1, 0xDE, 0x3B, 0xCF, 0x79, 0xEF, 0xF9, 0xFE,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE3, 0xC7,
  0x8F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00, 0x1F, 0xCF, 0xF7, 0xFD, 0xE1, 0xF0,
  0x3C, 0x0F, 0x7F, 0xDF, 0xF7, 0xFC, 0x7F, 0x1F, 0xC7, 0x7F, 0xCF, 0xF1,
  0xFC, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x78, 0xFF, 0xF7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xFF, 0xC0, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xBF, 0xEF,
  0xB8, 0xF1, 0xFE, 0x7B, 0xCF, 0x7B, 0xCF, 0x71, 0xFE, 0x3F, 0x87, 0xF8,
  0xFF, 0x1F, 0xE3, 0xDE, 0x7B, 0xCF, 0x3D, 0xE7, 0xBC, 0x78, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFD, 0xDF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xDF, 0xEF, 0xBF, 0xDF, 0x7F, 0xBE, 0xFF,
  0x79, 0xFE, 0x73, 0xFC, 0xE7, 0x80, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xCF,
  0xFC, 0xFF, 0xEF, 0xEE, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F,
  0xF3, 0xFF, 0x1F, 0xF1, 0xF0, 0x1F, 0x0F, 0xF9, 0xFF, 0x78, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0xFC, 0x7F,
  0x87, 0xC0, 0xFE, 0x7F, 0xBF, 0xFE, 0xFF, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF,
  0x7F, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0xF9, 0xFF, 0x78,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7,
  0xFC, 0x7F, 0x87, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFE, 0x1F,
  0xF3, 0xFE, 0x7B, 0xCF, 0x39, 0xE7, 0x3D, 0xE7, 0xF8, 0xFE, 0x1F, 0xE3,
  0xDC, 0x7B, 0xCF, 0x39, 0xE7, 0xBC, 0xF8, 0x7E, 0xFF, 0xFF, 0xE2, 0xE0,
  0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x0F, 0x8F, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0x7F, 0xDF, 0xE3, 0xF0, 0xF0, 0xFF,
  0x0E, 0x71, 0xE7, 0x1E, 0x79, 0xE7, 0x9C, 0x39, 0xC3, 0xBC, 0x3B, 0xC3,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF1, 0xC7, 0xF8,
  0xE3, 0xFC, 0x71, 0xEE, 0x7C, 0xE7, 0x3E, 0x73, 0x9B, 0x39, 0xED, 0xBC,
  0xF6, 0xDE, 0x3F, 0x6E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE3,
  0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0xF1, 0xCE, 0x79, 0xEE, 0x1D, 0xC3, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x1D, 0xC7, 0xBC, 0xE3,
  0xBC, 0x78, 0xF1, 0xEE, 0x39, 0xE7, 0x3D, 0xE3, 0xB8, 0x7F, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F,
  0xBF, 0xDF, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFF, 0xFE, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0xFF, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0,
  0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xF8, 0x77, 0x0E, 0x73, 0x8E, 0x70,
  0xFC, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF3, 0x8E, 0x3C, 0xFF, 0x7F,
  0x47, 0x07, 0x7F, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0x73, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x67, 0x7B, 0xFF, 0xEF, 0xF3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F,
  0xFF, 0xFD, 0xDE, 0x1C, 0x7F, 0xFE, 0xF2, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1,
  0xFE, 0x7E, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0x3B, 0xDF, 0xFF, 0xEF,
  0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0xFD, 0xFE, 0xF7, 0x3C, 0x3F, 0x3F,
  0xDC, 0xEE, 0x7F, 0xFF, 0xFF, 0xC0, 0xE0, 0x7F, 0x9F, 0xC7, 0xE0, 0x1E,
  0x7C, 0xFB, 0xC7, 0xFF, 0xFF, 0xBC, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x33, 0xBD, 0xFF, 0xFE, 0xFE, 0x7F, 0x1F, 0x8F, 0xC7, 0xE7, 0xFF,
  0xDF, 0xEF, 0x70, 0x3C, 0x3F, 0xFD, 0xFE, 0x7C, 0x00, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0xE7, 0x7B, 0xFF, 0xEF, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xEF, 0xE0, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x38,
  0xF3, 0x80, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xEF, 0xBE, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF8, 0xEE, 0x7B,
  0xBC, 0xEE, 0x3F, 0x8F, 0xE3, 0xFC, 0xF7, 0x39, 0xEE, 0x3B, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x39, 0xFF, 0xFB, 0xFF, 0xF7, 0xBE,
  0xFF, 0x39, 0xFC, 0x73, 0xF8, 0xE7, 0xF1, 0xCF, 0xE3, 0x9F, 0xC7, 0x3F,
  0x8E, 0x7F, 0x1C, 0xF0, 0xEE, 0x7F, 0xBF, 0xFE, 0xFF, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x1C, 0x3F, 0xBF, 0xDE, 0xFE, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xDF, 0xC7, 0xC0, 0xE6, 0x77, 0xBF, 0xFE,
  0xFF, 0x3F, 0x1F, 0x8F, 0xC7, 0xF3, 0xFF, 0xFF, 0xDD, 0xEE, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x33, 0xBD, 0xFF, 0xFE, 0xFE, 0x7F, 0x1F, 0x8F,
  0xC7, 0xE7, 0xFF, 0xDF, 0xEF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0xE7, 0xDF, 0xFF, 0xEF, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x79,
  0xFF, 0xF7, 0x2F, 0x1F, 0x1F, 0x1F, 0x9F, 0xFF, 0xF7, 0xC0, 0x38, 0x70,
  0xFF, 0xFF, 0xEF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xF3, 0xE7, 0xC0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xFF, 0xDF, 0xEF,
  0x70, 0xF1, 0xFC, 0xF7, 0x3D, 0xCE, 0x73, 0x9E, 0xE3, 0xF8, 0xFC, 0x3F,
  0x07, 0xC1, 0xE0, 0x78, 0xF3, 0xCF, 0xE7, 0x9D, 0xDF, 0x3B, 0xBE, 0xF7,
  0x7D, 0xCE, 0xDF, 0x9D, 0xBF, 0x1B, 0x7E, 0x3E, 0xFC, 0x7C, 0xF0, 0xF9,
  0xE1, 0xE3, 0xC0, 0xF3, 0xDC, 0xE7, 0xF8, 0xFC, 0x3F, 0x07, 0x81, 0xE0,
  0xFC, 0x3F, 0x1F, 0xE7, 0x3B, 0xCF, 0xF1, 0xFC, 0xF7, 0x3D, 0xCE, 0x7B,
  0x8E, 0xE3, 0xF8, 0xFC, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x87,
  0xC1, 0xF0, 0x78, 0x00, 0x7F, 0x7F, 0x7F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x7F, 0xFF, 0xFF, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0xF9,
  0xF3, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1E, 0x3C, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xF3, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x1E, 0x3C, 0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0xF9, 0xF3, 0x00, 0xF8, 0xFF,
  0xE7, 0xF0, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_Black21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 11, 15, 11, 0, -15 },
  { 35, 8, 17, 10, 1, -16 },
  { 52, 17, 15, 18, 0, -15 },
  { 84, 14, 15, 14, 0, -15 },
  { 111, 3, 5, 5, 1, -15 },
  { 113, 6, 18, 7, 1, -15 },
  { 127, 6, 18, 7, 0, -15 },
  { 141, 10, 9, 10, 0, -16 },
  { 153, 9, 11, 11, 1, -13 },
  { 166, 4, 6, 6, 1, -3 },
  { 169, 5, 3, 7, 1, -7 },
  { 171, 4, 4, 6, 1, -4 },
  { 173, 9, 15, 9, 0, -15 },
  { 190, 9, 15, 10, 1, -15 },
  { 207, 7, 15, 10, 1, -15 },
  { 221, 9, 15, 10, 0, -15 },
  { 238, 9, 15, 10, 1, -15 },
  { 255, 10, 15, 10, 0, -15 },
  { 274, 8, 15, 10, 1, -15 },
  { 289, 9, 15, 10, 1, -15 },
  { 306, 9, 15, 10, 1, -15 },
  { 323, 9, 15, 10, 1, -15 },
  { 340, 9, 15, 10, 1, -15 },
  { 357, 4, 12, 6, 1, -12 },
  { 363, 4, 15, 6, 1, -12 },
  { 371, 9, 11, 11, 1, -13 },
  { 384, 9, 7, 11, 1, -11 },
  { 392, 9, 11, 11, 1, -13 },
  { 405, 8, 15, 8, 0, -15 },
  { 420, 14, 17, 16, 1, -15 },
  { 450, 12, 15, 12, 0, -15 },
  { 473, 10, 15, 12, 1, -15 },
  { 492, 9, 15, 11, 1, -15 },
  { 509, 11, 15, 12, 1, -15 },
  { 530, 7, 15, 9, 1, -15 },
  { 544, 7, 15, 9, 1, -15 },
  { 558, 10, 15, 12, 1, -15 },
  { 577, 11, 15, 13, 1, -15 },
  { 598, 6, 15, 7, 1, -15 },
  { 610, 6, 20, 6, -1, -15 },
  { 625, 11, 15, 12, 1, -15 },
  { 646, 8, 15, 9, 1, -15 },
  { 661, 15, 15, 17, 1, -15 },
  { 690, 12, 15, 14, 1, -15 },
  { 713, 11, 15, 13, 1, -15 },
  { 734, 9, 15, 11, 1, -15 },
  { 751, 11, 19, 13, 1, -15 },
  { 778, 11, 15, 11, 1, -15 },
  { 799, 8, 15, 10, 1, -15 },
  { 814, 9, 15, 10, 0, -15 },
  { 831, 10, 15, 12, 1, -15 },
  { 850, 12, 15, 12, 0, -15 },
  { 873, 17, 15, 17, 0, -15 },
  { 905, 11, 15, 11, 0, -15 },
  { 926, 11, 15, 11, 0, -15 },
  { 947, 9, 15, 10, 0, -15 },
  { 964, 5, 19, 6, 1, -15 },
  { 976, 9, 15, 9, 0, -15 },
  { 993, 6, 19, 6, 0, -15 },
  { 1008, 11, 10, 11, 0, -15 },
  { 1022, 11, 3, 11, 0, 1 },
  { 1027, 5, 3, 7, 1, -16 },
  { 1029, 8, 12, 10, 1, -12 },
  { 1041, 9, 16, 11, 1, -16 },
  { 1059, 8, 12, 9, 1, -12 },
  { 1071, 9, 16, 11, 1, -16 },
  { 1089, 9, 12, 10, 1, -12 },
  { 1103, 7, 16, 7, 0, -16 },
  { 1117, 9, 17, 11, 1, -12 },
  { 1137, 9, 16, 11, 1, -16 },
  { 1155, 4, 16, 6, 1, -16 },
  { 1163, 6, 21, 6, -1, -16 },
  { 1179, 10, 16, 11, 1, -16 },
  { 1199, 3, 16, 6, 1, -16 },
  { 1205, 15, 12, 17, 1, -12 },
  { 1228, 9, 12, 11, 1, -12 },
  { 1242, 9, 12, 11, 1, -12 },
  { 1256, 9, 17, 11, 1, -12 },
  { 1276, 9, 17, 11, 1, -12 },
  { 1296, 7, 12, 8, 1, -12 },
  { 1307, 7, 12, 8, 1, -12 },
  { 1318, 7, 14, 7, 0, -14 },
  { 1331, 9, 12, 11, 1, -12 },
  { 1345, 10, 12, 10, 0, -12 },
  { 1360, 15, 12, 15, 0, -12 },
  { 1383, 10, 12, 10, 0, -12 },
  { 1398, 10, 17, 10, 0, -12 },
  { 1420, 8, 12, 8, 0, -12 },
  { 1432, 7, 19, 8, 0, -15 },
  { 1449, 3, 21, 9, 3, -16 },
  { 1457, 7, 19, 8, 0, -15 },
  { 1474, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Black21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK21PT7B_H_
