#ifndef _NOTOSANS_EXTRACONDENSED_BLACK23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xFB, 0xFD,
  0xFE, 0x7F, 0x3F, 0x1C, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF1, 0xDC, 0x1D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3B, 0x83,
  0xB8, 0x3B, 0x83, 0xB8, 0x0C, 0x0F, 0x9F, 0xFF, 0xFE, 0xD7, 0x63, 0xF0,
  0xF8, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x0C, 0x06,
  0x00, 0x30, 0x00, 0x1F, 0x0E, 0x0F, 0xC3, 0x83, 0xB9, 0xC0, 0xCE, 0x70,
  0x33, 0x98, 0x0C, 0xEE, 0x03, 0xBB, 0xBC, 0xFD, 0xDF, 0x9F, 0x77, 0xE3,
  0x19, 0x9C, 0x0E, 0xE7, 0x03, 0x39, 0xC1, 0xC6, 0x70, 0x71, 0xF8, 0x38,
  0x7E, 0x0E, 0x0F, 0x00, 0x07, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xEF, 0x03,
  0x9E, 0x07, 0xB8, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x3C, 0xFF, 0x79, 0xFF,
  0xF3, 0x9F, 0xCF, 0x1F, 0x8F, 0x3E, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xBE,
  0xFF, 0xFF, 0xFE, 0x1C, 0xF3, 0x9E, 0x71, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x1C, 0x79, 0xE3, 0x8F, 0x1C, 0xF0, 0xE1, 0xE1, 0xC3, 0xC7,
  0x87, 0x0E, 0x1C, 0x38, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x71, 0xE3,
  0x8F, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x37, 0x67, 0xFD, 0xFF, 0xC7, 0xC1,
  0xFC, 0x7B, 0xC6, 0x70, 0x44, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xEE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x00, 0x1C, 0x0F, 0xC7, 0xF3, 0xFE, 0xF7, 0xBC, 0xEF, 0x3B, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCE, 0xF3, 0xBD, 0xE7, 0xF9, 0xFC, 0x3E, 0x00,
  0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x7F, 0x2F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0xCF, 0xF9, 0xFF, 0x23, 0xC0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0xFD, 0xFF,
  0x7F, 0xC0, 0x1C, 0x7F, 0xBF, 0xEF, 0xF4, 0x78, 0x3C, 0x1E, 0x7E, 0x3E,
  0x1F, 0x83, 0xE0, 0xF0, 0x7C, 0x3F, 0xFF, 0xFE, 0xFE, 0x00, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC, 0x73, 0x8E, 0x73,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x1C, 0x7F, 0xBF, 0xDF, 0xEE,
  0x07, 0x03, 0xF3, 0xFD, 0xFF, 0x6F, 0x83, 0xC1, 0xE0, 0xFC, 0x7F, 0xFF,
  0xFD, 0xFC, 0x07, 0x87, 0xE3, 0xF9, 0xFE, 0x70, 0x3C, 0x0E, 0xF3, 0xBE,
  0xFF, 0xBD, 0xFF, 0x3F, 0xCF, 0xF3, 0xFD, 0xE7, 0xF9, 0xFE, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x1C, 0x1F, 0xCF, 0xFB,
  0xDE, 0xF3, 0xBC, 0xE7, 0xF9, 0xFC, 0x3E, 0x1F, 0xCF, 0x7B, 0xCF, 0xE3,
  0xF8, 0xFF, 0xFB, 0xFE, 0x3F, 0x00, 0x1C, 0x1F, 0xC7, 0xF3, 0xFE, 0xF3,
  0xBC, 0xFE, 0x3F, 0xCF, 0xFF, 0xFF, 0xF7, 0xB8, 0x4E, 0x07, 0x81, 0xEF,
  0xF3, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEE, 0x00, 0x40, 0x70, 0xFC, 0xFE,
  0xFE, 0x3E, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x83, 0xF8,
  0x1F, 0x81, 0xF0, 0xFD, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0x1C, 0x3F, 0xBF,
  0xEF, 0xF4, 0x78, 0x3C, 0x3E, 0x3E, 0x1E, 0x0E, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x38,
  0x1C, 0x70, 0x8E, 0x63, 0xF6, 0xE7, 0xF7, 0xEE, 0x77, 0xEE, 0x67, 0xCE,
  0x67, 0xCE, 0x67, 0xEE, 0xE6, 0xEF, 0xFE, 0xE7, 0xBC, 0x70, 0x00, 0x78,
  0x08, 0x3F, 0x78, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xF0,
  0x3B, 0x81, 0xDC, 0x0E, 0xF0, 0xF7, 0x87, 0xBC, 0x3C, 0xE1, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x3C, 0x3F, 0xE1, 0xFE, 0x0F, 0xFF, 0x9F, 0xFB,
  0xFF, 0x78, 0xFF, 0x1F, 0xE7, 0xBF, 0xF7, 0xFC, 0xFF, 0xDE, 0x7F, 0xC7,
  0xF8, 0xFF, 0x3F, 0xFF, 0xBF, 0xF7, 0xF8, 0x07, 0x07, 0xF3, 0xFD, 0xFE,
  0x78, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E,
  0x37, 0xFC, 0xFF, 0x1F, 0x80, 0xFF, 0x8F, 0xFC, 0xFF, 0xCF, 0x3E, 0xF1,
  0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF7,
  0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0xFE, 0x78, 0x2F, 0x80, 0xF0, 0x0F,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x7F, 0xF3,
  0xFF, 0x1F, 0xE0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xFF, 0xFD, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x9F, 0xBF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xF1, 0xFF, 0x1E,
  0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8,
  0xF7, 0xCF, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x1F, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x77, 0xFF, 0x77, 0xF7, 0x7F, 0xF7, 0x7F, 0xF7, 0xEF, 0xF7,
  0xEF, 0xF3, 0xEF, 0xF3, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF8,
  0x7F, 0xE3, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xFD, 0xFE, 0xEF,
  0xF7, 0xFF, 0xBF, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x1F, 0x07, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x9F, 0x7F, 0xE3,
  0xFC, 0x1F, 0x80, 0xFF, 0xBF, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xFF, 0xFF, 0xBF, 0xCF, 0xC3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07,
  0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x9F, 0x7F, 0xE3, 0xFC, 0x1F,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFC, 0xFF, 0x8F, 0xF8, 0xF7, 0x8F,
  0x78, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1F, 0x1C, 0x3F, 0xFF, 0xFF, 0xEF,
  0x17, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x7E, 0x7F, 0xFD,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x9E, 0xFF, 0xDF, 0xF0, 0xFC, 0xF0, 0x7F, 0x87,
  0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x70, 0xF7, 0x87, 0xBC, 0x3D, 0xE0,
  0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xF0,
  0xE1, 0xFE, 0x3C, 0x79, 0xC7, 0x8F, 0x38, 0xF9, 0xE7, 0x9F, 0x3C, 0xF3,
  0xE7, 0x9E, 0xFC, 0xE1, 0xDD, 0xBC, 0x3B, 0xBF, 0x87, 0x77, 0xF0, 0xEE,
  0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0xF9, 0xE7, 0x9E, 0x7B, 0xC3, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x83, 0xFC, 0x3B, 0xC7, 0x9E, 0x79, 0xEF,
  0x0F, 0xF0, 0xF7, 0x9E, 0x79, 0xE3, 0x9E, 0x3F, 0xC3, 0xFC, 0x1F, 0x81,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x7F, 0xDF, 0xF7, 0xFC, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF,
  0xFC, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xFF,
  0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x7F, 0xFF, 0xFC, 0x07, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0xDC,
  0x39, 0xC3, 0x8E, 0x70, 0xEF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1,
  0xE3, 0x87, 0x3E, 0x3F, 0x9F, 0xE8, 0xF0, 0x39, 0xFF, 0xFF, 0xE7, 0xE3,
  0xF3, 0xFF, 0xFF, 0xF7, 0xB8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF7, 0x3F,
  0xEF, 0xFF, 0xEF, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0xFF,
  0xFE, 0xE7, 0x80, 0x1E, 0x7F, 0x7F, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF1, 0xFF, 0x7F, 0x3F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x3B, 0xDF, 0xFF,
  0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF,
  0x3D, 0xC0, 0x1E, 0x3F, 0x9F, 0xFE, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x78, 0x7F, 0xEF, 0xF3, 0xF0, 0x0C, 0x3F, 0x3F, 0x3E, 0x38, 0x7E, 0xFE,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39,
  0xDF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0xFD, 0xFF, 0x3B, 0xC0, 0xF8, 0x3F, 0xFE, 0xFF, 0xBF, 0xC0, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF7, 0x3F, 0xEF, 0xFF, 0xEF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0x6F, 0xF7, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF3, 0xC7, 0x00, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xEF, 0x88,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x1F, 0xE7, 0xBC, 0xF7, 0xBC, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF9, 0xEF, 0x3C, 0xF7, 0x9E, 0xF1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x9C, 0xEF,
  0xBE, 0xFF, 0xFF, 0xFB, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xE7,
  0x3B, 0xEF, 0xFF, 0xEF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xC0, 0x1E, 0x1F, 0xC7, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0xE7, 0x3F, 0xEF,
  0xFF, 0xCF, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0xFF, 0xFE,
  0xF7, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x39, 0xDF, 0xFF,
  0xFF, 0xDF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF,
  0x3B, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0xE7, 0xDF, 0xFF,
  0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x7C, 0xFE, 0xFE,
  0xE2, 0xF0, 0xFC, 0xFE, 0x3E, 0x1F, 0x8F, 0xFE, 0xFE, 0xFC, 0x38, 0x38,
  0x3F, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3F, 0x3F,
  0x1F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0xFD, 0xF7, 0x3D, 0xC0, 0xF1, 0xFE, 0x3D, 0xC7, 0xBC, 0xE7,
  0xBC, 0x77, 0x8E, 0xE1, 0xDC, 0x3F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xF0,
  0xF3, 0xE7, 0xF9, 0xF3, 0xDC, 0xF9, 0xCE, 0x7C, 0xE7, 0xB6, 0xF3, 0xFB,
  0x79, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x87,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xEF, 0x79, 0xEF, 0x1D, 0xC3, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x87, 0xF1, 0xEF, 0x3D, 0xEF, 0x1E, 0xF1, 0xFE,
  0x3D, 0xC7, 0xBC, 0xE7, 0xBC, 0x77, 0x8E, 0xE1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1C, 0x07, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x80,
  0x00, 0x7F, 0xBF, 0xDF, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x1F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0xFC, 0xF0, 0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0xF8,
  0xFC, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1F, 0x0F, 0x1F, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0xFC, 0xF8, 0xF0, 0xF8, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_Black23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 12, 16, 13, 0, -16 },
  { 40, 9, 18, 11, 1, -17 },
  { 61, 18, 17, 19, 1, -17 },
  { 100, 15, 17, 15, 0, -17 },
  { 132, 4, 6, 6, 1, -16 },
  { 135, 6, 21, 8, 1, -17 },
  { 151, 7, 21, 8, 0, -17 },
  { 170, 11, 11, 11, 0, -18 },
  { 186, 10, 11, 12, 1, -14 },
  { 200, 4, 6, 6, 1, -3 },
  { 203, 6, 4, 7, 1, -8 },
  { 206, 4, 4, 6, 1, -4 },
  { 208, 10, 17, 10, 0, -17 },
  { 230, 10, 17, 11, 1, -17 },
  { 252, 8, 16, 11, 1, -16 },
  { 268, 10, 17, 11, 0, -17 },
  { 290, 9, 17, 11, 1, -17 },
  { 310, 11, 16, 11, 0, -16 },
  { 332, 9, 16, 11, 1, -16 },
  { 350, 10, 17, 11, 1, -17 },
  { 372, 10, 16, 11, 1, -16 },
  { 392, 10, 17, 11, 1, -17 },
  { 414, 10, 17, 11, 1, -17 },
  { 436, 4, 13, 6, 1, -13 },
  { 443, 4, 16, 6, 1, -13 },
  { 451, 10, 11, 12, 1, -14 },
  { 465, 10, 8, 12, 1, -12 },
  { 475, 10, 11, 12, 1, -14 },
  { 489, 9, 17, 9, 0, -17 },
  { 509, 16, 19, 18, 1, -17 },
  { 547, 13, 16, 13, 0, -16 },
  { 573, 11, 16, 13, 1, -16 },
  { 595, 10, 17, 12, 1, -17 },
  { 617, 12, 16, 14, 1, -16 },
  { 641, 8, 16, 10, 1, -16 },
  { 657, 8, 16, 10, 1, -16 },
  { 673, 12, 17, 14, 1, -17 },
  { 699, 12, 16, 14, 1, -16 },
  { 723, 7, 16, 8, 1, -16 },
  { 737, 6, 21, 7, -1, -16 },
  { 753, 12, 16, 13, 1, -16 },
  { 777, 9, 16, 10, 1, -16 },
  { 795, 16, 16, 19, 1, -16 },
  { 827, 13, 16, 15, 1, -16 },
  { 853, 12, 17, 14, 1, -17 },
  { 879, 10, 16, 12, 1, -16 },
  { 899, 12, 21, 14, 1, -17 },
  { 931, 12, 16, 13, 1, -16 },
  { 955, 9, 17, 10, 1, -17 },
  { 975, 10, 16, 11, 0, -16 },
  { 995, 11, 16, 14, 1, -16 },
  { 1017, 13, 16, 13, 0, -16 },
  { 1043, 19, 16, 19, 0, -16 },
  { 1081, 12, 16, 12, 0, -16 },
  { 1105, 12, 16, 12, 0, -16 },
  { 1129, 10, 16, 11, 0, -16 },
  { 1149, 6, 21, 7, 1, -17 },
  { 1165, 10, 17, 10, 0, -17 },
  { 1187, 6, 21, 7, 0, -17 },
  { 1203, 12, 10, 12, 0, -16 },
  { 1218, 12, 3, 12, 0, 1 },
  { 1223, 6, 4, 8, 1, -18 },
  { 1226, 9, 13, 11, 1, -13 },
  { 1241, 10, 17, 12, 1, -17 },
  { 1263, 8, 13, 10, 1, -13 },
  { 1276, 10, 17, 12, 1, -17 },
  { 1298, 9, 13, 11, 1, -13 },
  { 1313, 8, 18, 8, 0, -18 },
  { 1331, 10, 19, 12, 1, -13 },
  { 1355, 10, 17, 12, 1, -17 },
  { 1377, 4, 18, 6, 1, -18 },
  { 1386, 6, 24, 6, -1, -18 },
  { 1404, 11, 17, 12, 1, -17 },
  { 1428, 4, 17, 6, 1, -17 },
  { 1437, 16, 13, 18, 1, -13 },
  { 1463, 10, 13, 12, 1, -13 },
  { 1480, 10, 13, 12, 1, -13 },
  { 1497, 10, 19, 12, 1, -13 },
  { 1521, 10, 19, 12, 1, -13 },
  { 1545, 7, 13, 9, 1, -13 },
  { 1557, 8, 13, 9, 1, -13 },
  { 1570, 8, 15, 8, 0, -15 },
  { 1585, 10, 13, 12, 1, -13 },
  { 1602, 11, 13, 11, 0, -13 },
  { 1620, 17, 13, 17, 0, -13 },
  { 1648, 11, 13, 11, 0, -13 },
  { 1666, 11, 19, 11, 0, -13 },
  { 1693, 9, 13, 9, 0, -13 },
  { 1708, 8, 21, 8, 0, -17 },
  { 1729, 3, 23, 10, 3, -18 },
  { 1738, 8, 21, 8, 0, -17 },
  { 1759, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Black23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK23PT7B_H_
