#ifndef _NOTOSANS_EXTRACONDENSED_BLACK44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x38, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFE, 0x3F, 0xFF,
  0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3,
  0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xE7, 0xE1, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x87, 0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFE, 0xEF, 0x3F, 0x38, 0x4F, 0xCE,
  0x03, 0xF3, 0x80, 0xFE, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3B, 0xF0, 0x0E, 0xFE, 0x03, 0xBF, 0xC0, 0xEF, 0xFC, 0x3F, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x20, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0xFC,
  0x07, 0xC0, 0x07, 0xFF, 0x80, 0xF8, 0x00, 0xF9, 0xF0, 0x3E, 0x00, 0x3F,
  0x3F, 0x07, 0xC0, 0x07, 0xE7, 0xE1, 0xF8, 0x00, 0xFC, 0xFC, 0x3E, 0x00,
  0x1F, 0x8F, 0x87, 0xC0, 0x03, 0xF1, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x3E,
  0x00, 0x0F, 0xCF, 0xCF, 0xC0, 0x01, 0xF9, 0xF9, 0xF0, 0xFC, 0x1F, 0x3E,
  0x7E, 0x7F, 0xC3, 0xFF, 0xCF, 0x8F, 0xFC, 0x7F, 0xF9, 0xF3, 0xFF, 0xC7,
  0xFE, 0x7E, 0x7F, 0xF8, 0x7F, 0x8F, 0x9F, 0x9F, 0x03, 0xC3, 0xF3, 0xF3,
  0xF0, 0x00, 0x7C, 0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF1, 0xF8, 0x00, 0x7C, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xC7, 0xE0, 0x03,
  0xE0, 0xFC, 0xFC, 0x00, 0x7C, 0x1F, 0x9F, 0x00, 0x1F, 0x01, 0xFF, 0xE0,
  0x03, 0xE0, 0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x7F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFD,
  0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xC0, 0xFF, 0xC3,
  0xFC, 0x1F, 0xFE, 0x3F, 0xC3, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0xBF, 0x87,
  0xF7, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0x8F, 0xE1, 0xFF, 0xF0, 0xFE, 0x1F,
  0xFF, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xC3, 0xE1, 0x9F, 0x7D, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x07, 0xEF, 0xC1, 0xFD, 0xFC, 0x7F, 0x1F, 0xC3, 0xE3, 0xE0,
  0x38, 0x38, 0x03, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFC, 0xFE, 0xFE, 0x3F, 0xBF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x9F, 0xCF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0xFF, 0x3C, 0xFF,
  0x18, 0xFF, 0x08, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xF0, 0xFF, 0x38, 0x1F, 0xC4, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFB, 0xF8,
  0x1F, 0xBF, 0x81, 0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xE3, 0xF8, 0x7E, 0x3F,
  0x87, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE6,
  0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFE, 0x11, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x9F, 0x07, 0xE7, 0xF0, 0xFD, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE,
  0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xF3, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xE7, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD,
  0xFE, 0x7F, 0x1F, 0xDF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xDF, 0xE7,
  0xF1, 0xFE, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFD, 0xFE, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xDF, 0xC7, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xF7, 0xF0, 0xFC, 0xFE, 0x06, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x0C, 0x1F,
  0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xF9, 0xFC, 0xFE,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xFD, 0xFB, 0xFE, 0x60, 0x7F, 0x20, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0xFC, 0x7E,
  0x1F, 0xFC, 0xF8, 0xF8, 0x7F, 0xF9, 0xF9, 0xF1, 0xFF, 0xF1, 0xF7, 0xC3,
  0xF3, 0xE3, 0xEF, 0x8F, 0xC7, 0xC7, 0xDF, 0x1F, 0x0F, 0x8F, 0xBE, 0x3E,
  0x1F, 0x1F, 0x7C, 0xFC, 0x3E, 0x3E, 0xF9, 0xF8, 0x7C, 0x7F, 0xF3, 0xF0,
  0xF8, 0xFF, 0xE7, 0xE3, 0xF1, 0xF7, 0xCF, 0xC7, 0xE3, 0xEF, 0x8F, 0x8F,
  0xCF, 0x9F, 0x1F, 0xBF, 0x9F, 0x3E, 0x3F, 0xFF, 0xFC, 0x7C, 0x3F, 0xEF,
  0xF8, 0xFC, 0x3F, 0x9F, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x10, 0x03, 0xFC, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x3F, 0xC0,
  0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE1,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE3, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFE, 0x06, 0x7F, 0x80, 0x4F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x4F, 0xFC,
  0x38, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0xFF, 0xDF, 0xC1, 0xFE,
  0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x07,
  0xFB, 0xF8, 0x3F, 0xDF, 0xC3, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xF0, 0x0C, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFF, 0x07, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xF8, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xF0, 0x7E, 0x00, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x1F,
  0xE3, 0xF8, 0x7F, 0x8F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x7F, 0x83,
  0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x7F, 0x83, 0xF8, 0xFF, 0x0F,
  0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE0,
  0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F,
  0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xDF, 0x87, 0xFF, 0xFF, 0x7E, 0x1F, 0x7F, 0xFD, 0xF8, 0xFD,
  0xFF, 0xF7, 0xE3, 0xF7, 0xFF, 0xEF, 0xCF, 0xDF, 0xFF, 0xBF, 0x3E, 0x7F,
  0xFE, 0xFD, 0xF9, 0xFF, 0xFB, 0xF7, 0xE7, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF,
  0x9F, 0xFC, 0x7F, 0xFE, 0x7F, 0xF1, 0xFF, 0xF9, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFE, 0x3F, 0xE1, 0xFF, 0xF8, 0xFF,
  0x87, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x1F, 0xC1,
  0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0xCF, 0xFF, 0xBF,
  0x9F, 0xFF, 0x3F, 0xBF, 0xFE, 0x7F, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE,
  0xFF, 0xF9, 0xFD, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x8F, 0xF7, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFD, 0xFC, 0x7F,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xF8, 0xFF, 0x9F, 0xC3, 0xFC, 0xFE,
  0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF9, 0xFC, 0x3F, 0xCF, 0xE3, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC3,
  0xF9, 0xFE, 0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0x87,
  0xF9, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x1F, 0xE0,
  0x01, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFE, 0x1C, 0xFF, 0x01, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xBF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0,
  0xFF, 0x7F, 0x8F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE3,
  0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0xC1, 0xFE, 0x7F, 0x03, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xC1, 0xFE,
  0x7F, 0x07, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0xC1, 0xFC, 0x3F, 0x87, 0xFC,
  0x1F, 0xC3, 0xF8, 0x7F, 0xE3, 0xFC, 0x3F, 0x87, 0xFE, 0x3F, 0xC3, 0xF8,
  0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0xE3, 0xF8,
  0x1F, 0xCF, 0xBF, 0x3F, 0x81, 0xFC, 0xFB, 0xF7, 0xF8, 0x1F, 0xDF, 0xBF,
  0x7F, 0x01, 0xFD, 0xF9, 0xF7, 0xF0, 0x0F, 0xDF, 0x9F, 0x7F, 0x00, 0xFD,
  0xF9, 0xF7, 0xF0, 0x0F, 0xDF, 0x1F, 0x7F, 0x00, 0xFF, 0xF1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0xFF, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xFB,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xE3, 0xFC,
  0x1F, 0xC7, 0xF8, 0x3F, 0xCF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0xFE, 0x03, 0xF9, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8,
  0x3F, 0x87, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xEF,
  0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F,
  0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0x07, 0xF0, 0x40, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFD, 0xF9, 0xFF, 0x3F, 0x1F, 0xC7, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1C, 0x0F, 0xE7, 0xF0,
  0xFE, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xBF,
  0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xEF, 0xF8, 0xFC, 0x7F, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF,
  0x3C, 0xFF, 0x04, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x5F, 0xE0, 0xCF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0x87, 0xF0, 0xFE, 0x7F, 0x1F, 0xF7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x7F,
  0x0F, 0xE3, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0x7F, 0x7F, 0x0F,
  0xEF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x01,
  0x3F, 0xE3, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x87, 0xF9, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xF3,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0xFE, 0x3F,
  0x1F, 0xF7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x9F,
  0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xF7, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x60, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x08,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x3C, 0x1F, 0xCF,
  0xE3, 0xFB, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0x38, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC,
  0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xBF, 0x87, 0xF9, 0xFC, 0x3F, 0x8F,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x03, 0xC1, 0xF8, 0xFF, 0x1F, 0xE3, 0xF3, 0xFF, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x8F, 0xF8, 0xFE, 0xFF, 0x0F, 0xE1, 0xFF, 0xFE, 0x1F, 0xC3,
  0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0x83, 0xF8, 0x7F, 0xFF, 0x07, 0xF0, 0xFF,
  0xFE, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0x87, 0xFF,
  0xF0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF,
  0x83, 0xF8, 0x7F, 0xFF, 0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x00,
  0x3C, 0x1F, 0x8F, 0xE3, 0xF3, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x8F, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x1C, 0x0F, 0xC7, 0xF0, 0xFE, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF,
  0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F,
  0xEF, 0xF8, 0xFE, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFE,
  0x3F, 0x1F, 0xF7, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xDF, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xBF, 0x87, 0x7F,
  0x02, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xEF, 0xCF, 0xF9, 0xF8, 0xFE,
  0x3F, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC,
  0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xDF,
  0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x7F,
  0x0F, 0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x7F, 0x7F, 0x1F, 0xF8, 0xFE, 0x7F,
  0x1F, 0xF8, 0xFE, 0x7F, 0x1F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFE, 0x3F,
  0x9F, 0xFC, 0xFE, 0x3F, 0x9F, 0xFC, 0xFC, 0x3F, 0xBF, 0x7D, 0xFC, 0x3F,
  0xBF, 0x7D, 0xFC, 0x1F, 0xBE, 0x7D, 0xFC, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F,
  0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7F, 0xF8, 0x0F, 0xBE, 0x7F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x3F, 0xC3,
  0xF8, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x13, 0xFC, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFC, 0x03, 0xFE, 0x80, 0x03, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 18, 11, 21, 2, -31 },
  { 58, 22, 31, 24, 1, -31 },
  { 144, 18, 36, 22, 2, -33 },
  { 225, 35, 32, 37, 1, -32 },
  { 365, 28, 32, 28, 1, -32 },
  { 477, 7, 11, 11, 2, -31 },
  { 487, 12, 39, 14, 2, -32 },
  { 546, 12, 39, 14, 0, -32 },
  { 605, 19, 20, 21, 1, -34 },
  { 653, 20, 21, 22, 1, -26 },
  { 706, 9, 12, 12, 1, -6 },
  { 720, 12, 7, 14, 1, -15 },
  { 731, 8, 9, 12, 2, -8 },
  { 740, 19, 32, 19, 0, -32 },
  { 816, 18, 32, 22, 2, -32 },
  { 888, 16, 31, 22, 2, -31 },
  { 950, 18, 32, 22, 1, -32 },
  { 1022, 19, 32, 22, 1, -32 },
  { 1098, 20, 31, 22, 1, -31 },
  { 1176, 18, 31, 22, 2, -31 },
  { 1246, 19, 32, 22, 1, -32 },
  { 1322, 18, 31, 22, 2, -31 },
  { 1392, 19, 32, 22, 1, -32 },
  { 1468, 19, 32, 22, 1, -32 },
  { 1544, 8, 26, 12, 2, -25 },
  { 1570, 9, 31, 12, 1, -25 },
  { 1605, 20, 22, 22, 1, -27 },
  { 1660, 20, 15, 22, 1, -23 },
  { 1698, 20, 22, 22, 1, -27 },
  { 1753, 17, 33, 18, 0, -32 },
  { 1824, 31, 35, 34, 1, -32 },
  { 1960, 25, 31, 25, 0, -31 },
  { 2057, 20, 31, 25, 3, -31 },
  { 2135, 19, 32, 22, 2, -32 },
  { 2211, 21, 31, 26, 3, -31 },
  { 2293, 15, 31, 19, 3, -31 },
  { 2352, 15, 31, 19, 3, -31 },
  { 2411, 22, 32, 26, 2, -32 },
  { 2499, 21, 31, 27, 3, -31 },
  { 2581, 13, 31, 16, 1, -31 },
  { 2632, 13, 41, 13, -3, -31 },
  { 2699, 22, 31, 24, 3, -31 },
  { 2785, 15, 31, 19, 3, -31 },
  { 2844, 30, 31, 36, 3, -31 },
  { 2961, 23, 31, 29, 3, -31 },
  { 3051, 24, 32, 27, 2, -32 },
  { 3147, 19, 31, 23, 3, -31 },
  { 3221, 24, 39, 27, 2, -32 },
  { 3338, 21, 31, 24, 3, -31 },
  { 3420, 18, 32, 20, 1, -32 },
  { 3492, 18, 31, 20, 1, -31 },
  { 3562, 21, 31, 26, 2, -31 },
  { 3644, 25, 31, 25, 0, -31 },
  { 3741, 36, 31, 36, 0, -31 },
  { 3881, 23, 31, 23, 0, -31 },
  { 3971, 23, 31, 23, 0, -31 },
  { 4061, 19, 31, 21, 1, -31 },
  { 4135, 11, 39, 13, 2, -32 },
  { 4189, 19, 32, 19, 0, -32 },
  { 4265, 11, 39, 13, 1, -32 },
  { 4319, 24, 20, 24, 0, -31 },
  { 4379, 22, 5, 22, 0, 3 },
  { 4393, 11, 7, 15, 2, -34 },
  { 4403, 19, 25, 22, 1, -25 },
  { 4463, 20, 33, 23, 2, -33 },
  { 4546, 17, 25, 19, 1, -25 },
  { 4600, 20, 33, 23, 1, -33 },
  { 4683, 19, 25, 21, 1, -25 },
  { 4743, 15, 34, 14, 0, -34 },
  { 4807, 20, 36, 23, 1, -25 },
  { 4897, 19, 33, 23, 2, -33 },
  { 4976, 8, 34, 12, 2, -34 },
  { 5010, 12, 45, 12, -2, -34 },
  { 5078, 21, 33, 23, 2, -33 },
  { 5165, 7, 33, 12, 2, -33 },
  { 5194, 31, 25, 35, 2, -25 },
  { 5291, 19, 25, 23, 2, -25 },
  { 5351, 20, 25, 23, 1, -25 },
  { 5414, 20, 36, 23, 2, -25 },
  { 5504, 20, 36, 23, 1, -25 },
  { 5594, 14, 25, 17, 2, -25 },
  { 5638, 15, 25, 17, 1, -25 },
  { 5685, 15, 29, 16, 0, -29 },
  { 5740, 19, 24, 23, 2, -24 },
  { 5797, 22, 24, 22, 0, -24 },
  { 5863, 32, 24, 32, 0, -24 },
  { 5959, 21, 24, 21, 0, -24 },
  { 6022, 22, 35, 22, 0, -24 },
  { 6119, 16, 24, 17, 1, -24 },
  { 6167, 14, 39, 16, 1, -32 },
  { 6236, 6, 44, 18, 6, -34 },
  { 6269, 15, 39, 16, 1, -32 },
  { 6343, 20, 9, 22, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Black44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK44PT7B_H_
