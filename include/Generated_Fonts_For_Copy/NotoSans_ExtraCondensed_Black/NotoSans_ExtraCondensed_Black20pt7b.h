#ifndef _NOTOSANS_EXTRACONDENSED_BLACK20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xE0, 0x4E, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7,
  0xE7, 0x1D, 0x83, 0xB0, 0x76, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xE1, 0xD8,
  0xFF, 0xDF, 0xF8, 0xCC, 0x1B, 0x83, 0x70, 0x6E, 0x00, 0x18, 0x3C, 0x7F,
  0xFE, 0xF9, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F, 0x1F, 0xDF, 0xFE, 0xFE, 0x18,
  0x18, 0x7C, 0x38, 0x7C, 0x70, 0x6E, 0x60, 0xEE, 0x60, 0xEE, 0xE0, 0x6E,
  0xCC, 0x7D, 0xDE, 0x7D, 0xBF, 0x03, 0xBB, 0x03, 0x33, 0x03, 0x33, 0x07,
  0x3B, 0x06, 0x1F, 0x0E, 0x1E, 0x1F, 0x01, 0xFC, 0x0E, 0xE0, 0x77, 0x03,
  0xF8, 0x1F, 0x80, 0xF9, 0xCF, 0xEE, 0x77, 0xF7, 0xBF, 0x3C, 0xF8, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0xFF, 0xFE, 0x39, 0xDC, 0xE7, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x71, 0xCE, 0x39, 0xC0, 0xE1, 0xC7, 0x0E, 0x38, 0xE3, 0x8F,
  0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x9C, 0x73, 0x80, 0x1C, 0x06, 0x1B, 0xFF,
  0xF7, 0xF9, 0xF1, 0xDE, 0x66, 0x12, 0x00, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0xFE, 0xEE, 0xEC, 0xFF, 0xFE, 0x4E, 0xFE,
  0x07, 0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70,
  0x70, 0xE0, 0x7C, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFF, 0x7E, 0x3C, 0x1E, 0x7D, 0xFF, 0xFE, 0xE9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x3E, 0x7F, 0x9D, 0xE4, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0F, 0xF7, 0xFB, 0xFC, 0xFE, 0xFE, 0xCF,
  0x0F, 0x0E, 0x7E, 0x78, 0x7E, 0x0F, 0x07, 0x8F, 0xFF, 0xFE, 0xFC, 0x07,
  0x03, 0xC0, 0xF0, 0x7C, 0x3F, 0x0F, 0xC7, 0x71, 0xDC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x7E, 0xFE, 0xFE, 0xE0, 0xE0, 0xFE, 0xFE,
  0x5F, 0x07, 0x07, 0x8F, 0xFF, 0xFE, 0xFC, 0x3F, 0x7F, 0x79, 0xE0, 0xE4,
  0xFE, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x7E,
  0xFF, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xEF, 0xFF,
  0x7E, 0x7C, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7F, 0x07, 0x0F,
  0xFE, 0xFC, 0xF8, 0xEF, 0xE4, 0x00, 0x04, 0xEF, 0xE0, 0xEF, 0xE4, 0x00,
  0x00, 0xFE, 0xEE, 0xEC, 0x01, 0x07, 0x1F, 0x7C, 0xF0, 0xF8, 0x7E, 0x0F,
  0x03, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0xF8, 0x3E, 0x0F, 0x1F, 0x7E, 0xF0, 0xC0, 0x80, 0x7E, 0xFE, 0x6F, 0x07,
  0x0F, 0x1E, 0x3C, 0x38, 0x38, 0x00, 0x10, 0x38, 0x38, 0x38, 0x1F, 0xE0,
  0xF3, 0xC7, 0x03, 0x99, 0xE6, 0xEF, 0xDB, 0x33, 0x7D, 0xCD, 0xF7, 0x77,
  0xDD, 0xDB, 0x77, 0x6C, 0xFF, 0xB9, 0x98, 0x70, 0x00, 0xF3, 0x81, 0xFE,
  0x00, 0x80, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC3, 0xB8, 0x77, 0x0E, 0xF1,
  0xCE, 0x7F, 0xCF, 0xF9, 0xFF, 0xB8, 0xFF, 0x0F, 0xE1, 0xC0, 0xFF, 0x7F,
  0xFD, 0xFE, 0x7F, 0x3F, 0xFB, 0xF9, 0xFF, 0xF3, 0xF9, 0xFC, 0xFF, 0xFF,
  0xF7, 0xF0, 0x3F, 0xBF, 0x9E, 0xDE, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x3C, 0x2F, 0xE7, 0xF1, 0xF8, 0xFE, 0x3F, 0xCF, 0xFB, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x7B, 0xFE, 0xFF, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE3, 0xC7, 0x8F,
  0x1E, 0x00, 0x3F, 0xDF, 0xE7, 0x9B, 0xC0, 0xF0, 0x38, 0x0E, 0x7F, 0x9F,
  0xE1, 0xFC, 0x7F, 0x1D, 0xFF, 0x7F, 0xC7, 0xE0, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x70, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xCF, 0xFF, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xFE, 0xFB, 0xC0, 0xF3, 0xFC, 0xEF, 0x7B, 0xDC, 0xFF, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFF, 0x3D, 0xCF, 0x7B, 0xDE, 0xF3, 0xFC, 0xF0, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xC0,
  0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xB3, 0x7E, 0xED,
  0xFB, 0xF7, 0xEF, 0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x8C,
  0x70, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xFD, 0xFB, 0xBF, 0x77,
  0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xC0, 0x04, 0x07, 0xE1,
  0xFE, 0x3D, 0xEF, 0x1D, 0xC3, 0xB8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7,
  0x79, 0xE7, 0xFC, 0xFF, 0x0F, 0xC0, 0xFE, 0x7F, 0xBF, 0xFE, 0xFF, 0x7F,
  0xBF, 0xFD, 0xFE, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x04, 0x07,
  0xE1, 0xFE, 0x3D, 0xEF, 0x1D, 0xC3, 0xB8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0xC7, 0x79, 0xE7, 0xFC, 0xFF, 0x0F, 0xC0, 0x3C, 0x03, 0x80, 0x7C, 0xFE,
  0x3F, 0xCF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0xF3, 0xF8, 0xFE, 0x3F, 0xCF,
  0x73, 0xDE, 0xF3, 0xBC, 0xF0, 0x7F, 0xFE, 0xFE, 0xE2, 0xE0, 0xF8, 0x7C,
  0x3E, 0x1E, 0x0F, 0x8F, 0xFE, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xFE, 0x7F, 0x8F, 0xC0, 0xF1, 0xFE, 0x3D, 0xC7, 0x38, 0xE7, 0x9C,
  0xF7, 0x8E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0xE1, 0xC7, 0xF3, 0xC7, 0x73, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73,
  0xEE, 0x77, 0xEE, 0x7F, 0xEE, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x1E, 0x3C, 0xF3, 0xDC, 0xE7, 0xF8, 0xFC, 0x3F, 0x07,
  0xC1, 0xE0, 0x78, 0x3F, 0x0F, 0xC3, 0xF9, 0xEE, 0x73, 0xFC, 0x70, 0xF1,
  0xEE, 0x79, 0xCE, 0x1D, 0xC3, 0xF8, 0x7E, 0x07, 0xC0, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0,
  0xF0, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xE0,
  0x70, 0x70, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x07,
  0x07, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF,
  0xC0, 0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xB0, 0x77, 0x1C, 0x63, 0x8E,
  0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0x8E, 0x7F, 0x1F, 0x8D, 0xE0,
  0x73, 0xFB, 0xFD, 0xCF, 0xE7, 0x77, 0xBF, 0xDE, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0xE7, 0xFB, 0xFD, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF, 0xF7,
  0xFB, 0xB8, 0x3E, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x71, 0xFE, 0xFD, 0xF8,
  0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0xFF, 0x7B, 0x7C, 0x7E, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xE0, 0xF3,
  0x7F, 0x3E, 0x3E, 0x7D, 0xEB, 0xC7, 0xDF, 0xBF, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x00, 0x7B, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0xFF, 0x7F, 0x07, 0x87, 0xFF, 0xFE, 0x78, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0xF7, 0xFB, 0xFD, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9E, 0x5F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x11, 0xCE, 0x70, 0x1C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFE, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE3, 0xB9, 0xCE, 0xF3, 0xB8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC,
  0xE7, 0x39, 0xEE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0x7B,
  0xFF, 0xEF, 0xFF, 0xF9, 0xEF, 0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7,
  0xE7, 0x9F, 0x9E, 0x7E, 0x79, 0xC0, 0xEF, 0x7F, 0xBF, 0xDC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xE0, 0x3E, 0x3F, 0xBD, 0xDC, 0xEE,
  0x7F, 0x3F, 0x9F, 0xCE, 0xFF, 0x3F, 0x8F, 0x80, 0xEE, 0x7F, 0xBD, 0xDC,
  0xFE, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0x7F, 0xBB, 0x9C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x7B, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF,
  0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x00, 0x3E, 0xFD, 0xDF, 0x87, 0xCF, 0xC7, 0x87, 0x7E, 0xFD,
  0xF0, 0x38, 0x71, 0xFF, 0xFF, 0xEF, 0x1E, 0x3C, 0x78, 0xF1, 0xF9, 0xF3,
  0xE0, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xFF,
  0xDE, 0xE0, 0xF3, 0xFC, 0xE7, 0x39, 0xCE, 0x77, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x07, 0x81, 0xE0, 0xE7, 0x9F, 0xEF, 0x39, 0xDF, 0x73, 0xBE, 0xE7,
  0x6D, 0xCE, 0xDB, 0x1F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3,
  0xC0, 0xF3, 0xBB, 0xDF, 0xC7, 0xE3, 0xE0, 0xF0, 0xF8, 0x7E, 0x77, 0x3B,
  0xFC, 0xE0, 0xF3, 0xDC, 0xE7, 0x39, 0xCE, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x1F, 0x07, 0x81, 0xC0, 0x7E, 0x7E,
  0x7E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x7F, 0xFF, 0xFF, 0x1E, 0x7C, 0xE1,
  0xC3, 0x87, 0x0E, 0x7C, 0xF1, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1F, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xF0, 0xE1, 0xC3,
  0x87, 0x0E, 0x1F, 0x0E, 0x7C, 0xE1, 0xC3, 0x87, 0x0E, 0x7C, 0xF0, 0xF1,
  0xFF, 0xFF, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_Black20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 5, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 8, 16, 10, 1, -15 },
  { 49, 16, 14, 17, 0, -14 },
  { 77, 13, 14, 13, 0, -14 },
  { 100, 3, 5, 5, 1, -14 },
  { 102, 5, 18, 7, 1, -15 },
  { 114, 6, 18, 7, 0, -15 },
  { 128, 9, 9, 10, 0, -15 },
  { 139, 8, 10, 10, 1, -12 },
  { 149, 4, 6, 5, 1, -3 },
  { 152, 5, 3, 7, 1, -7 },
  { 154, 4, 4, 5, 1, -4 },
  { 156, 8, 14, 9, 0, -14 },
  { 170, 8, 14, 10, 1, -14 },
  { 184, 7, 14, 10, 1, -14 },
  { 197, 9, 14, 10, 0, -14 },
  { 213, 8, 14, 10, 1, -14 },
  { 227, 10, 14, 10, 0, -14 },
  { 245, 8, 14, 10, 1, -14 },
  { 259, 8, 14, 10, 1, -14 },
  { 273, 8, 14, 10, 1, -14 },
  { 287, 8, 14, 10, 1, -14 },
  { 301, 8, 14, 10, 1, -14 },
  { 315, 4, 11, 6, 1, -11 },
  { 321, 4, 14, 6, 1, -11 },
  { 328, 8, 10, 10, 1, -12 },
  { 338, 8, 8, 10, 1, -11 },
  { 346, 8, 10, 10, 1, -12 },
  { 356, 8, 14, 8, 0, -14 },
  { 370, 14, 16, 15, 1, -14 },
  { 398, 11, 14, 11, 0, -14 },
  { 418, 9, 14, 11, 1, -14 },
  { 434, 9, 14, 10, 1, -14 },
  { 450, 10, 14, 12, 1, -14 },
  { 468, 7, 14, 9, 1, -14 },
  { 481, 7, 14, 9, 1, -14 },
  { 494, 10, 14, 12, 1, -14 },
  { 512, 10, 14, 12, 1, -14 },
  { 530, 7, 14, 7, 0, -14 },
  { 543, 6, 18, 6, -1, -14 },
  { 557, 10, 14, 11, 1, -14 },
  { 575, 7, 14, 9, 1, -14 },
  { 588, 14, 14, 16, 1, -14 },
  { 613, 11, 14, 13, 1, -14 },
  { 633, 11, 15, 12, 1, -15 },
  { 654, 9, 14, 10, 1, -14 },
  { 670, 11, 18, 12, 1, -15 },
  { 695, 10, 14, 11, 1, -14 },
  { 713, 8, 14, 9, 1, -14 },
  { 727, 9, 14, 9, 0, -14 },
  { 743, 10, 14, 12, 1, -14 },
  { 761, 11, 14, 11, 0, -14 },
  { 781, 16, 14, 16, 0, -14 },
  { 809, 10, 14, 10, 0, -14 },
  { 827, 11, 14, 11, 0, -14 },
  { 847, 9, 14, 9, 0, -14 },
  { 863, 5, 18, 6, 1, -15 },
  { 875, 8, 14, 9, 0, -14 },
  { 889, 5, 18, 6, 0, -15 },
  { 901, 11, 9, 11, 0, -14 },
  { 914, 10, 3, 10, 0, 1 },
  { 918, 5, 3, 7, 1, -15 },
  { 920, 9, 11, 10, 0, -11 },
  { 933, 9, 15, 10, 1, -15 },
  { 950, 7, 11, 9, 1, -11 },
  { 960, 8, 15, 10, 1, -15 },
  { 975, 8, 11, 10, 1, -11 },
  { 986, 7, 15, 7, 0, -15 },
  { 1000, 8, 16, 10, 1, -11 },
  { 1016, 9, 15, 11, 1, -15 },
  { 1033, 3, 16, 5, 1, -16 },
  { 1039, 5, 21, 5, -1, -16 },
  { 1053, 10, 15, 10, 1, -15 },
  { 1072, 3, 15, 5, 1, -15 },
  { 1078, 14, 11, 16, 1, -11 },
  { 1098, 9, 11, 11, 1, -11 },
  { 1111, 9, 11, 10, 1, -11 },
  { 1124, 9, 16, 10, 1, -11 },
  { 1142, 8, 16, 10, 1, -11 },
  { 1158, 6, 11, 8, 1, -11 },
  { 1167, 7, 11, 8, 0, -11 },
  { 1177, 7, 13, 7, 0, -13 },
  { 1189, 9, 11, 11, 1, -11 },
  { 1202, 10, 11, 10, 0, -11 },
  { 1216, 15, 11, 15, 0, -11 },
  { 1237, 9, 11, 10, 0, -11 },
  { 1250, 10, 16, 10, 0, -11 },
  { 1270, 8, 11, 8, 0, -11 },
  { 1281, 7, 17, 7, 0, -14 },
  { 1296, 3, 20, 8, 3, -15 },
  { 1304, 7, 17, 7, 0, -14 },
  { 1319, 8, 4, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Black20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK20PT7B_H_
