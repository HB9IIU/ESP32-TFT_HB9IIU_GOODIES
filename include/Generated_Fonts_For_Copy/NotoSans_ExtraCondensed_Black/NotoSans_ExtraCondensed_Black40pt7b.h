#ifndef _NOTOSANS_EXTRACONDENSED_BLACK40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC,
  0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03,
  0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF9, 0xC4, 0xF9, 0xC0, 0xF9, 0xC0,
  0xFD, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xDF, 0x81, 0xDF, 0xC1, 0xDF,
  0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xC0,
  0x1F, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x7F, 0xF0, 0x3E, 0x00, 0x7F, 0xF0,
  0x3C, 0x00, 0xF9, 0xF0, 0x7C, 0x00, 0xF8, 0xF0, 0x7C, 0x00, 0xF8, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0x00, 0xF8, 0xF9,
  0xF0, 0x00, 0xF8, 0xF1, 0xE0, 0xC0, 0xF9, 0xF3, 0xE3, 0xF8, 0x7F, 0xF3,
  0xE7, 0xFC, 0x7F, 0xF7, 0xCF, 0xFC, 0x3F, 0xE7, 0xCF, 0xFE, 0x3F, 0xC7,
  0x9F, 0x3E, 0x0F, 0x8F, 0x9F, 0x3E, 0x00, 0x0F, 0x9F, 0x1E, 0x00, 0x1F,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x1F, 0x00, 0x3E,
  0x1F, 0x1E, 0x00, 0x3E, 0x1F, 0x3E, 0x00, 0x7C, 0x1F, 0xBE, 0x00, 0x7C,
  0x0F, 0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0xF8, 0x07, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE3, 0xF8, 0x7F, 0xE1,
  0xF8, 0x7F, 0xF9, 0xFC, 0x7F, 0xFE, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0x9F,
  0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xE3, 0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xF8,
  0x3F, 0xC1, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x02, 0x1F, 0x08, 0x73, 0xE7, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFC, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xE0, 0xF8, 0xF8, 0x0F,
  0x1E, 0x00, 0xC1, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF9, 0xFC, 0xFC, 0xFE, 0x7F,
  0x7E, 0x3F, 0xBF, 0x0F, 0xDF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF,
  0xC3, 0xF7, 0xE3, 0xFB, 0xF1, 0xFD, 0xFC, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xDF, 0xCE, 0x7F, 0x11, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF,
  0xF9, 0xE1, 0xFC, 0x60, 0xFE, 0x10, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF1, 0xFF, 0xF8, 0xC1, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7D, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0x83,
  0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x20, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xC1, 0xFB, 0xF8, 0x7F,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x3F, 0xBF, 0x87,
  0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xE7, 0xF3, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xE7, 0xE3, 0xF9, 0xF8, 0x7E, 0x7E, 0x3F,
  0x9F, 0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xFB, 0xF8,
  0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xF3, 0xFB, 0xF8, 0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFB, 0xF8,
  0x7E, 0xFE, 0x3F, 0xFF, 0xCF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xF7, 0xE1, 0xF9, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xF1, 0x07, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xC0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0xFC, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x7E, 0x20, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x3E, 0x1F, 0xF9, 0xE3,
  0xC3, 0xFF, 0x9F, 0x7C, 0x7F, 0xF9, 0xF7, 0xC7, 0xCF, 0x8F, 0x78, 0xF8,
  0xF8, 0xF7, 0x8F, 0x8F, 0x8F, 0xF8, 0xF0, 0xF8, 0xFF, 0x9F, 0x0F, 0x8F,
  0xF9, 0xF0, 0xF8, 0xFF, 0x8F, 0x0F, 0x8F, 0xF8, 0xF0, 0xF9, 0xFF, 0x8F,
  0x9F, 0x9E, 0x78, 0xFB, 0xFB, 0xE7, 0xCF, 0xFF, 0xFE, 0x7C, 0x7F, 0xBF,
  0xC7, 0xC3, 0xF1, 0xF8, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x00, 0xFE, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x07, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x8F,
  0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x3F,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF9, 0xFE, 0x1C, 0xFE, 0x02, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x04, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x7F,
  0xCF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE1, 0xFE, 0xFE, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xC0, 0xC7, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x87, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xCF, 0xF1, 0xF8, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xEF, 0xE0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFD, 0xF0, 0xFB, 0xFF, 0xFF, 0x8F, 0xBF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xEF, 0x9F, 0xFF, 0xFE, 0xF9, 0xF7, 0xFF, 0xEF, 0xDF,
  0x7F, 0xFE, 0xFD, 0xF7, 0xFF, 0xE7, 0xFF, 0x7F, 0xFE, 0x7F, 0xE7, 0xFF,
  0xE7, 0xFE, 0x7F, 0xFE, 0x7F, 0xE7, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F,
  0xC7, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE1, 0xF8, 0x7F,
  0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xF0, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0x7E, 0x3F, 0xFD, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xEF, 0xCF, 0xFF, 0xBF, 0xBF, 0xFE, 0x7E, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE,
  0x3F, 0xDF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xE3, 0xFB, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xBF, 0x9F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F,
  0xDF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFE, 0x3F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFE,
  0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xE7, 0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0x1E, 0xFE, 0x06, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC,
  0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFE,
  0x07, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0x7E,
  0x07, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x7F, 0x7E, 0x0F, 0xF0, 0x7E, 0x7F,
  0x0F, 0xF0, 0x7E, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0x0F, 0xF0, 0xFE, 0x3F,
  0x0F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F,
  0x9F, 0xF8, 0xFC, 0x1F, 0x9F, 0xF9, 0xFC, 0x1F, 0x9F, 0x7D, 0xFC, 0x1F,
  0xBF, 0x7D, 0xFC, 0x1F, 0xBF, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F,
  0xBE, 0x7D, 0xF8, 0x0F, 0xFE, 0x7D, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF3, 0xF8, 0x7F,
  0x9F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E,
  0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x8F,
  0xE1, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x80,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0xDF, 0xC0,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0,
  0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x40, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x60, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x83,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFE, 0x7C, 0xFE, 0x3E, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x40, 0xFC,
  0xFC, 0x3F, 0x7F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xCF,
  0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFF,
  0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFD, 0xFE, 0x3E, 0x3F,
  0x00, 0x00, 0x40, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF,
  0x9F, 0xC3, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x02, 0xFF, 0x1D, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x08, 0x7F, 0x0F, 0xCF, 0xC7, 0xFB, 0xF3, 0xFE, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xCF, 0xF7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFD, 0xF8, 0x7F, 0x7F, 0x3F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xEF, 0xC3, 0xF1, 0xF0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x03, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xC0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xE7, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x02,
  0x00, 0x03, 0xF3, 0xF1, 0xFE, 0xFC, 0xFF, 0xBF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xF3, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E,
  0x1F, 0xDF, 0xCF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xEF, 0xC7, 0xFB,
  0xF0, 0xFD, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xD0, 0x07, 0xE7, 0x03, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x20, 0xFC, 0xFC, 0x7E, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x8E,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x81,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x80, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xE7, 0xF8, 0x38, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF,
  0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xEF, 0xE0, 0xFD, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xDF, 0x87, 0xF3, 0xF8, 0xFC, 0x7F, 0x1F, 0x87, 0xF3, 0xF0, 0xFE, 0x7E,
  0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x04, 0x0F, 0x8F, 0xE3,
  0xF8, 0xFD, 0xFF, 0x7F, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0xEF, 0xEF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F,
  0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F,
  0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1,
  0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87,
  0xFF, 0xC1, 0xF8, 0x7F, 0xFC, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x7F, 0xFC,
  0x1F, 0x87, 0xF0, 0x00, 0x10, 0x7C, 0x7E, 0x3F, 0x7F, 0xDF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF1, 0xF9, 0xF8, 0x7F, 0x7E, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x10, 0x3E, 0x3F,
  0x0F, 0xDF, 0xE3, 0xF7, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE3, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0xCF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFD, 0xFF, 0x3F, 0x7F, 0x8F, 0xCF, 0xC3,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x03, 0xF3, 0xF1, 0xFE, 0xFC, 0xFF, 0xBF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xF3, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E,
  0x1F, 0xDF, 0xCF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xEF, 0xC7, 0xFB,
  0xF0, 0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0x27, 0xC7, 0xFE, 0x7F, 0xFB, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFA, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x00, 0x01, 0x00, 0x7F, 0xC3, 0xFF, 0xDF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xC1, 0x3F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE4, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFC, 0xF8, 0xFC, 0x7C, 0xFE, 0x07, 0xF7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8,
  0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x0F, 0xBF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x1F, 0xE1, 0xFB, 0xF0, 0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0xFE, 0xFC, 0x7F,
  0xC7, 0xE7, 0xE3, 0xFE, 0x3F, 0x3F, 0x9F, 0xF1, 0xF8, 0xFC, 0xFF, 0xCF,
  0xC7, 0xE7, 0xBE, 0x7E, 0x3F, 0x7D, 0xF7, 0xE1, 0xFB, 0xEF, 0xBF, 0x0F,
  0xDF, 0x7D, 0xF8, 0x3E, 0xFB, 0xEF, 0xC1, 0xF7, 0xCF, 0x7E, 0x0F, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xEF, 0xE3, 0xF8,
  0xFC, 0x7E, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xBF, 0x07,
  0xF7, 0xF0, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xFD, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF7, 0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC3, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x1F, 0xBF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x87, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0x81, 0xC0, 0x00, 0x1E, 0x00,
  0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8,
  0x0F, 0xFA, 0x00, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Black40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 16, 11, 19, 2, -29 },
  { 49, 20, 29, 22, 1, -29 },
  { 122, 16, 32, 20, 2, -30 },
  { 186, 32, 29, 34, 1, -29 },
  { 302, 25, 29, 26, 1, -29 },
  { 393, 7, 11, 10, 2, -29 },
  { 403, 11, 35, 13, 2, -29 },
  { 452, 11, 35, 13, 0, -29 },
  { 501, 19, 18, 19, 0, -31 },
  { 544, 18, 20, 20, 1, -24 },
  { 589, 8, 12, 11, 1, -6 },
  { 601, 11, 6, 13, 1, -14 },
  { 610, 7, 7, 11, 2, -7 },
  { 617, 17, 29, 17, 0, -29 },
  { 679, 17, 29, 20, 1, -29 },
  { 741, 14, 29, 20, 2, -29 },
  { 792, 17, 29, 20, 1, -29 },
  { 854, 17, 29, 20, 1, -29 },
  { 916, 18, 29, 20, 1, -29 },
  { 982, 16, 29, 20, 2, -29 },
  { 1040, 18, 29, 20, 1, -29 },
  { 1106, 17, 29, 20, 1, -29 },
  { 1168, 18, 29, 20, 1, -29 },
  { 1234, 18, 29, 20, 1, -29 },
  { 1300, 7, 22, 11, 2, -22 },
  { 1320, 8, 28, 11, 1, -22 },
  { 1348, 18, 20, 20, 1, -24 },
  { 1393, 18, 14, 20, 1, -21 },
  { 1425, 18, 20, 20, 1, -24 },
  { 1470, 16, 29, 16, 0, -29 },
  { 1528, 28, 32, 31, 1, -29 },
  { 1640, 23, 29, 23, 0, -29 },
  { 1724, 19, 29, 22, 2, -29 },
  { 1793, 17, 29, 20, 2, -29 },
  { 1855, 20, 29, 23, 2, -29 },
  { 1928, 14, 29, 18, 2, -29 },
  { 1979, 14, 29, 17, 2, -29 },
  { 2030, 20, 29, 24, 2, -29 },
  { 2103, 20, 29, 24, 2, -29 },
  { 2176, 12, 29, 14, 1, -29 },
  { 2220, 11, 38, 12, -2, -29 },
  { 2273, 21, 29, 22, 2, -29 },
  { 2350, 15, 29, 17, 2, -29 },
  { 2405, 28, 29, 32, 2, -29 },
  { 2507, 22, 29, 26, 2, -29 },
  { 2587, 21, 29, 25, 2, -29 },
  { 2664, 18, 29, 21, 2, -29 },
  { 2730, 21, 36, 25, 2, -29 },
  { 2825, 20, 29, 22, 2, -29 },
  { 2898, 16, 29, 18, 1, -29 },
  { 2956, 17, 29, 18, 1, -29 },
  { 3018, 19, 29, 24, 2, -29 },
  { 3087, 22, 29, 22, 0, -29 },
  { 3167, 32, 29, 32, 0, -29 },
  { 3283, 21, 29, 21, 0, -29 },
  { 3360, 21, 29, 21, 0, -29 },
  { 3437, 17, 29, 19, 1, -29 },
  { 3499, 9, 36, 12, 2, -29 },
  { 3540, 17, 29, 17, 0, -29 },
  { 3602, 9, 36, 12, 1, -29 },
  { 3643, 21, 19, 22, 0, -29 },
  { 3693, 20, 4, 20, 0, 3 },
  { 3703, 10, 7, 14, 2, -31 },
  { 3712, 17, 23, 20, 1, -23 },
  { 3761, 18, 30, 21, 2, -30 },
  { 3829, 15, 23, 17, 1, -23 },
  { 3873, 18, 30, 21, 1, -30 },
  { 3941, 17, 22, 19, 1, -22 },
  { 3988, 14, 31, 13, 0, -31 },
  { 4043, 18, 33, 21, 1, -23 },
  { 4118, 17, 30, 21, 2, -30 },
  { 4182, 7, 31, 11, 2, -31 },
  { 4210, 11, 41, 11, -2, -31 },
  { 4267, 19, 30, 21, 2, -30 },
  { 4339, 6, 30, 11, 2, -30 },
  { 4362, 28, 23, 32, 2, -23 },
  { 4443, 17, 23, 21, 2, -23 },
  { 4492, 18, 23, 21, 1, -23 },
  { 4544, 18, 33, 21, 2, -23 },
  { 4619, 18, 33, 21, 1, -23 },
  { 4694, 13, 23, 15, 2, -23 },
  { 4732, 14, 23, 16, 1, -23 },
  { 4773, 13, 27, 14, 0, -27 },
  { 4817, 17, 22, 21, 2, -22 },
  { 4864, 20, 22, 20, 0, -22 },
  { 4919, 29, 22, 29, 0, -22 },
  { 4999, 19, 22, 19, 0, -22 },
  { 5052, 20, 32, 20, 0, -22 },
  { 5132, 14, 22, 16, 1, -22 },
  { 5171, 13, 36, 15, 1, -29 },
  { 5230, 5, 40, 17, 6, -31 },
  { 5255, 13, 36, 15, 1, -29 },
  { 5314, 18, 8, 20, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Black40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK40PT7B_H_
