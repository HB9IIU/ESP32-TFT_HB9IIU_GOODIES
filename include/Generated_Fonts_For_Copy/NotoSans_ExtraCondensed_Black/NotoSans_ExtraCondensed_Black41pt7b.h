#ifndef _NOTOSANS_EXTRACONDENSED_BLACK41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xF0, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x03,
  0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F, 0x8F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE7, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0xFC,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFD, 0xCE, 0xF9, 0xC2,
  0xF9, 0xC0, 0xFD, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xDF, 0x01, 0xDF,
  0x81, 0xDF, 0xE1, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF8, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0,
  0x1E, 0x00, 0x7F, 0xF0, 0x3E, 0x00, 0xFD, 0xF0, 0x3E, 0x00, 0xF8, 0xF8,
  0x7C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0x00, 0xF8, 0xF9,
  0xF1, 0xF0, 0xFD, 0xFB, 0xE3, 0xFC, 0x7F, 0xF3, 0xE7, 0xFE, 0x7F, 0xF3,
  0xEF, 0xFE, 0x3F, 0xE7, 0xCF, 0xFF, 0x1F, 0xC7, 0xCF, 0x9F, 0x07, 0x0F,
  0x8F, 0x9F, 0x00, 0x0F, 0x9F, 0x9F, 0x00, 0x0F, 0x9F, 0x9F, 0x00, 0x1F,
  0x1F, 0x9F, 0x00, 0x1F, 0x1F, 0x9F, 0x00, 0x3E, 0x0F, 0x9F, 0x00, 0x3E,
  0x0F, 0x9F, 0x00, 0x3C, 0x0F, 0x9F, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x7C,
  0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xF0, 0x7F,
  0xF1, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xF9, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x0F, 0xE1, 0xFF,
  0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0xFF, 0x03, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0xFE,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0x1F, 0x1C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0x7F, 0x0F, 0xE7, 0xF0, 0xF8, 0xF8, 0x0F, 0x0E, 0x00, 0x41, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x9F,
  0xC7, 0xE7, 0xE1, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F,
  0x7E, 0x1F, 0xDF, 0xC7, 0xE7, 0xF1, 0xF9, 0xFC, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xCF, 0xCE, 0x3F, 0x10, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xF9, 0xF1, 0xFC, 0x70, 0x7F, 0x30, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x07, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xC7, 0xF8, 0xC0, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xBF, 0x83, 0xF7, 0xF0, 0x7C, 0xFE, 0x1F,
  0x9F, 0xC3, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFB, 0x01, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE3, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE1, 0x01, 0xF9, 0xF8, 0x7E, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xBF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xDF, 0x87, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xF3, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0xC7, 0xE7, 0xF3, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFB, 0xF9, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xF9, 0xF8,
  0xFE, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFB, 0xF1,
  0xFD, 0xFC, 0x3E, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x23, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x1E, 0x3F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x1F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x7C, 0xFF, 0x20,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7C, 0x3E, 0x0F, 0xF1, 0xF1, 0xF0, 0xFF, 0xEF, 0x9F, 0x0F, 0xFE,
  0x3E, 0xF8, 0xFF, 0xF1, 0xF7, 0xC7, 0xC7, 0x8F, 0xBC, 0x7C, 0x3C, 0x7D,
  0xE3, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0x1F, 0xF8, 0xF8, 0xF8, 0xFF, 0xC7,
  0xC7, 0xC7, 0xFE, 0x3E, 0x3E, 0x3F, 0xF1, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F,
  0x8F, 0x3C, 0x7F, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0x8F, 0x8F, 0xF3, 0xF8,
  0x7E, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x02, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0,
  0x07, 0xEF, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0,
  0x0F, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFB,
  0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFC,
  0x71, 0xFE, 0x04, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x06, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE,
  0xFE, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xE3, 0xC7, 0xF8, 0x04,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xF8, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83,
  0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xEF, 0x8F, 0xBF, 0xFF, 0x7E, 0x7D, 0xFF, 0xFB, 0xF7, 0xEF, 0xFF,
  0xDF, 0xBF, 0x7F, 0xFE, 0x7D, 0xF3, 0xFF, 0xF3, 0xFF, 0x9F, 0xFF, 0x9F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xC7, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0x1F, 0xF1,
  0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xC7, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF,
  0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xE0,
  0xF8, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFB, 0xF3, 0xFF, 0xEF, 0xEF, 0xFF, 0x9F, 0xBF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F, 0xC1, 0xFE, 0xFF, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xEF,
  0xF0, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F,
  0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFB, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE7, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xEF,
  0xE0, 0x7F, 0x80, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF9, 0xFE, 0x0C, 0xFE, 0x02, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xDF, 0x81, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xF9, 0xFC,
  0x3F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF0, 0xFE, 0x3F, 0x0F, 0xF8, 0x7F, 0x1F,
  0x87, 0xFC, 0x3F, 0x0F, 0xE3, 0xFE, 0x3F, 0x87, 0xF3, 0xEF, 0x9F, 0xC3,
  0xF9, 0xF7, 0xCF, 0xE0, 0xFC, 0xFB, 0xE7, 0xF0, 0x7E, 0x7D, 0xF3, 0xF0,
  0x3F, 0x3E, 0xF9, 0xF8, 0x1F, 0x9F, 0x7D, 0xFC, 0x0F, 0xFF, 0x9F, 0xFE,
  0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07,
  0xF3, 0xF8, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F,
  0xEF, 0xE0, 0x7F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xF1,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0xF1, 0xFC, 0x40, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFE, 0xFB, 0xFE, 0x7C, 0xFE, 0x3E, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x7C, 0x3F, 0xBF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0x7F, 0xCF, 0xCF, 0xC0, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x04, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x02, 0x7F, 0x8E, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0x8F, 0xC7,
  0xFB, 0xF3, 0xFE, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF1,
  0xFD, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x7F, 0x7F, 0x1F, 0xDF,
  0xCF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0xFC,
  0x7C, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x9F, 0xCF, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x9F, 0xC0, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF8, 0x7F, 0x21, 0xFC, 0x07, 0xE0, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xC7, 0xC7, 0xFB, 0xF3, 0xFE, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x7F,
  0x7F, 0x1F, 0xDF, 0xEF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xD0, 0x07, 0xF7, 0x03,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x7C, 0x3F,
  0x3F, 0xCF, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xF3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFC, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFC,
  0xFF, 0x0F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xDF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x7E, 0x0F, 0x8F, 0xDF, 0xF3, 0xFC, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xC7, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3,
  0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE,
  0x1F, 0xC3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xF0, 0xF8, 0x7C,
  0x3F, 0x7F, 0xCF, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xF3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0x7F, 0x9F, 0xC7, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF,
  0x83, 0xFB, 0xF0, 0x7E, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0xF8, 0x7C, 0x3F,
  0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xCF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xBF, 0xCF, 0xE7,
  0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xC7, 0xC7, 0xFB, 0xF3, 0xFE, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F,
  0x7F, 0x1F, 0xDF, 0xEF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x7F, 0xC7, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDF, 0xFE,
  0xFF, 0xFB, 0xF8, 0xEF, 0xC0, 0xBF, 0x80, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x31, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xEF, 0xCF, 0xFB, 0xF1,
  0xFC, 0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x9F,
  0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0x87, 0xF7, 0xE1, 0xFE, 0x1F, 0xDF,
  0x87, 0xF8, 0x7E, 0x7F, 0x1F, 0xF1, 0xF9, 0xFC, 0xFF, 0xC7, 0xE7, 0xF3,
  0xFF, 0x3F, 0x8F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3F, 0xF3, 0xF0, 0xFC, 0xFF,
  0xCF, 0xC3, 0xF7, 0xEF, 0xBF, 0x07, 0xFF, 0x3E, 0xFC, 0x1F, 0xFC, 0xFB,
  0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xEF, 0xE3, 0xFD, 0xFC, 0x7F, 0x1F, 0xCF,
  0xE3, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xF0, 0xFE, 0xFE,
  0x1F, 0xCF, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0xFF, 0x83, 0xF8, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF0,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F,
  0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0x01,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF8, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Black41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 16, 10, 20, 2, -29 },
  { 47, 21, 29, 22, 1, -29 },
  { 124, 16, 33, 20, 2, -31 },
  { 190, 32, 30, 34, 1, -30 },
  { 310, 26, 30, 26, 1, -30 },
  { 408, 7, 10, 10, 2, -29 },
  { 417, 11, 36, 13, 2, -30 },
  { 467, 12, 36, 13, 0, -30 },
  { 521, 19, 18, 19, 0, -31 },
  { 564, 18, 19, 21, 1, -24 },
  { 607, 8, 12, 11, 1, -6 },
  { 619, 11, 6, 13, 1, -14 },
  { 628, 7, 7, 11, 2, -7 },
  { 635, 17, 30, 17, 0, -30 },
  { 699, 18, 30, 20, 1, -30 },
  { 767, 14, 29, 20, 2, -29 },
  { 818, 17, 30, 20, 1, -30 },
  { 882, 18, 30, 20, 1, -30 },
  { 950, 19, 29, 20, 1, -29 },
  { 1019, 17, 29, 20, 2, -29 },
  { 1081, 18, 30, 20, 1, -30 },
  { 1149, 17, 29, 20, 2, -29 },
  { 1211, 18, 30, 20, 1, -30 },
  { 1279, 18, 30, 20, 1, -30 },
  { 1347, 7, 23, 11, 2, -23 },
  { 1368, 8, 29, 11, 1, -23 },
  { 1397, 18, 20, 21, 1, -25 },
  { 1442, 18, 15, 21, 1, -22 },
  { 1476, 18, 20, 21, 1, -25 },
  { 1521, 16, 30, 16, 0, -30 },
  { 1581, 29, 33, 31, 1, -30 },
  { 1701, 24, 29, 24, 0, -29 },
  { 1788, 19, 29, 23, 2, -29 },
  { 1857, 18, 30, 21, 2, -30 },
  { 1925, 20, 29, 24, 2, -29 },
  { 1998, 15, 29, 18, 2, -29 },
  { 2053, 14, 29, 18, 2, -29 },
  { 2104, 20, 30, 24, 2, -30 },
  { 2179, 21, 29, 25, 2, -29 },
  { 2256, 12, 29, 15, 1, -29 },
  { 2300, 12, 38, 12, -3, -29 },
  { 2357, 21, 29, 23, 2, -29 },
  { 2434, 15, 29, 18, 2, -29 },
  { 2489, 29, 29, 33, 2, -29 },
  { 2595, 22, 29, 27, 2, -29 },
  { 2675, 22, 30, 25, 2, -30 },
  { 2758, 18, 29, 21, 2, -29 },
  { 2824, 22, 37, 25, 2, -30 },
  { 2926, 21, 29, 22, 2, -29 },
  { 3003, 17, 30, 19, 1, -30 },
  { 3067, 17, 29, 19, 1, -29 },
  { 3129, 20, 29, 24, 2, -29 },
  { 3202, 23, 29, 23, 0, -29 },
  { 3286, 33, 29, 33, 0, -29 },
  { 3406, 21, 29, 21, 0, -29 },
  { 3483, 22, 29, 22, 0, -29 },
  { 3563, 17, 29, 19, 1, -29 },
  { 3625, 10, 37, 12, 2, -30 },
  { 3672, 17, 30, 17, 0, -30 },
  { 3736, 10, 37, 12, 1, -30 },
  { 3783, 22, 19, 22, 0, -29 },
  { 3836, 21, 5, 21, 0, 3 },
  { 3850, 10, 6, 14, 2, -31 },
  { 3858, 17, 23, 20, 1, -23 },
  { 3907, 18, 31, 21, 2, -31 },
  { 3977, 16, 23, 18, 1, -23 },
  { 4023, 18, 31, 21, 1, -31 },
  { 4093, 18, 23, 20, 1, -23 },
  { 4145, 14, 31, 13, 0, -31 },
  { 4200, 18, 33, 21, 1, -23 },
  { 4275, 18, 31, 22, 2, -31 },
  { 4345, 7, 32, 11, 2, -32 },
  { 4373, 11, 42, 11, -2, -32 },
  { 4431, 20, 31, 21, 2, -31 },
  { 4509, 7, 31, 11, 2, -31 },
  { 4537, 28, 23, 32, 2, -23 },
  { 4618, 18, 23, 22, 2, -23 },
  { 4670, 19, 23, 21, 1, -23 },
  { 4725, 18, 33, 21, 2, -23 },
  { 4800, 18, 33, 21, 1, -23 },
  { 4875, 13, 23, 15, 2, -23 },
  { 4913, 14, 23, 16, 1, -23 },
  { 4954, 14, 27, 15, 0, -27 },
  { 5002, 18, 23, 22, 2, -23 },
  { 5054, 20, 23, 20, 0, -23 },
  { 5112, 30, 23, 30, 0, -23 },
  { 5199, 19, 23, 19, 0, -23 },
  { 5254, 20, 33, 20, 0, -23 },
  { 5337, 15, 23, 16, 1, -23 },
  { 5381, 13, 37, 15, 1, -30 },
  { 5442, 5, 41, 17, 6, -32 },
  { 5468, 14, 37, 15, 1, -30 },
  { 5533, 18, 7, 21, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Black41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK41PT7B_H_
