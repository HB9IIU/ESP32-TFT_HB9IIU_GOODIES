#ifndef _NOTOSANS_EXTRACONDENSED_BLACK31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xFD, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C,
  0xE0, 0x79, 0xC0, 0xF7, 0x81, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3C, 0xE0, 0x79, 0xC0, 0xF7, 0x81, 0xCF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3C, 0xE0, 0x79, 0xC0, 0xF7, 0x81, 0xCF, 0x03, 0x9E, 0x0F, 0x3C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0xE3, 0xFF, 0xBF, 0xF9, 0xFF,
  0xDF, 0x62, 0xF3, 0x03, 0xD8, 0x1F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0x7C, 0x1B, 0xD8, 0xDE, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF0, 0x7E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3E, 0x03, 0xC0, 0x7F,
  0x03, 0xC0, 0xFF, 0x83, 0x80, 0xF7, 0x87, 0x80, 0xF3, 0x87, 0x00, 0xF3,
  0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xF3, 0xCE, 0x00, 0xF3, 0x9E, 0x10, 0xF7,
  0x9C, 0xFC, 0xFF, 0xBD, 0xFE, 0x7F, 0x3D, 0xFF, 0x3E, 0x79, 0xEF, 0x00,
  0x79, 0xCF, 0x00, 0x73, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xF1, 0xCF, 0x01,
  0xE1, 0xCF, 0x01, 0xE1, 0xEF, 0x01, 0xC1, 0xFE, 0x03, 0xC0, 0xFE, 0x03,
  0xC0, 0x7C, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x1F, 0x3F, 0xF7, 0xE7, 0xFF, 0xFD, 0xF7, 0xFF, 0x3E,
  0x7F, 0xE7, 0xC7, 0xF8, 0xF8, 0x7F, 0x1F, 0x9F, 0xE3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xC0, 0xFF, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F,
  0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x11, 0xE1,
  0x73, 0xBD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0x83, 0xEF,
  0x1F, 0xBE, 0x1C, 0x70, 0x31, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x7D, 0xF7, 0xDF, 0x7D,
  0xEF, 0xBE, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xDF, 0x78,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00,
  0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xDF, 0x3E, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0x7C, 0xFB, 0xEF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFE, 0x07, 0xE0,
  0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0x3B,
  0xE2, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x3F, 0xC3, 0xFF, 0x3F, 0xFD,
  0xFF, 0xE7, 0x1F, 0x30, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE6, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFE, 0x1F,
  0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1E, 0xF8,
  0x3D, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xA0, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF, 0xFF, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x83, 0xFC, 0x3F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x07, 0xF0,
  0xFF, 0x87, 0xFC, 0x7F, 0xE7, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x38, 0xFB,
  0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xFC, 0xFB, 0xEF, 0xDF, 0xFE, 0x7F, 0xE3, 0xFE, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xE1,
  0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xCF, 0xBC, 0x7D, 0xF3, 0xEF, 0xBE, 0x7F,
  0xF1, 0xFF, 0x07, 0xF0, 0x7F, 0xC7, 0xFF, 0x7E, 0xFF, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xFC, 0x33, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x9F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7D, 0xF7, 0xDF,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0xBE,
  0xF0, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x9F, 0xF3, 0xFE,
  0x1F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0x03,
  0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0xE0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x20,
  0x00, 0x3F, 0xCF, 0xFE, 0xFF, 0xE7, 0xFF, 0x61, 0xF4, 0x1F, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x3C, 0x00, 0xF0,
  0xE0, 0xF1, 0xE7, 0x8F, 0xF7, 0x9C, 0x7F, 0xCE, 0x73, 0xEF, 0x3F, 0xCF,
  0x3C, 0xFF, 0x38, 0xF3, 0xFC, 0xE3, 0xCF, 0xF3, 0x8F, 0x3F, 0xCE, 0x3C,
  0xEF, 0x3C, 0xF3, 0xBC, 0xF7, 0xDE, 0xF1, 0xFB, 0xF1, 0xE7, 0xCF, 0x87,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x1F, 0x3C,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xC1, 0xF9, 0xF0,
  0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xF9, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFE, 0x3F, 0xFE, 0xFF, 0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0x19, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x05, 0xFC, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xCF, 0xBF, 0xDF, 0x1F, 0xBE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0x0C, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7E, 0x1F, 0x7F, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFC, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF,
  0xFF, 0xBF, 0xDF, 0xCF, 0x80, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xC7,
  0xEF, 0x9F, 0x9F, 0x3E, 0x3E, 0xFC, 0x7D, 0xF0, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7C, 0x7C, 0xFC, 0xF9,
  0xF9, 0xF1, 0xF3, 0xE3, 0xF7, 0xC3, 0xEF, 0x87, 0xFF, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFE, 0xF7, 0xBF, 0xF7,
  0xBD, 0xFF, 0xBD, 0xEF, 0xFD, 0xFF, 0x7F, 0xE7, 0xF3, 0xFF, 0x3F, 0x9F,
  0xF9, 0xFC, 0xFF, 0xCF, 0xE7, 0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F,
  0x8F, 0xFC, 0x7C, 0x7C, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xF7, 0xCF, 0xFF,
  0xE7, 0xFE, 0xF3, 0xFF, 0x7D, 0xFF, 0xBE, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xE3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xF8,
  0x3F, 0x7E, 0x1F, 0x3F, 0x9F, 0x8F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0x80, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F,
  0xE3, 0xFC, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE3,
  0xF3, 0xF0, 0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3F,
  0x7E, 0x1F, 0x3F, 0x9F, 0x8F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0x9F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF7, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3E, 0xF8, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xF3, 0xE3, 0xE7,
  0xC7, 0xEF, 0x87, 0xDF, 0x0F, 0xC0, 0x1F, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFC, 0xEF, 0x82, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xF9,
  0xFB, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xFE,
  0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xF0, 0xF8, 0xF8, 0xFC,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x07, 0xCF, 0x83, 0xEF, 0x81, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xF8, 0x3E, 0x0F, 0xFC,
  0x1F, 0x07, 0xDF, 0x0F, 0x87, 0xEF, 0x87, 0xC3, 0xE7, 0xC3, 0xF1, 0xF3,
  0xE3, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C, 0xF8, 0xFE, 0x3E, 0x3E, 0x7F, 0x3E,
  0x1F, 0x3B, 0x9F, 0x0F, 0xBD, 0xEF, 0x87, 0xDE, 0xF7, 0xC3, 0xEF, 0x7B,
  0xE0, 0xF7, 0xBD, 0xF0, 0x7B, 0xDF, 0xF0, 0x3D, 0xC7, 0xF8, 0x1F, 0xE3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0xFC, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x3E,
  0x7C, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC,
  0x3F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E, 0x0F,
  0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x3F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xF2, 0x0F, 0x80, 0x7C, 0x7F, 0xEF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xEF, 0x7E, 0x78, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x7C, 0xF7, 0xF7, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDF, 0xDE, 0x7C, 0x1F, 0xE3, 0xFF, 0x7F, 0xE7, 0xFE,
  0x7C, 0x2F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFC, 0x27, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xCF, 0xDF, 0x3F, 0x7D,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF,
  0xC7, 0xDF, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0xC1, 0x3F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x07, 0x83, 0xFC, 0x7F, 0x1F, 0xE3,
  0xFC, 0x7C, 0x0F, 0x83, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x7C, 0xFD, 0xF7, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F,
  0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xDF, 0x1E, 0x7C, 0x01, 0xF0, 0x0F,
  0x90, 0x3E, 0x7F, 0xF9, 0xFF, 0xC7, 0xFF, 0x1F, 0xF0, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0xFC, 0xF7, 0xF7,
  0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0x79, 0xFF, 0xDF, 0x78, 0x00, 0x1F, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x1E, 0x1F, 0x3F, 0x1F, 0x1E, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFE,
  0xFC, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x3F, 0xF8, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0xF8, 0xFF, 0xE3,
  0xDF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xBF, 0x3E, 0x7C,
  0xF9, 0xFB, 0xE3, 0xEF, 0x8F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE3,
  0xE7, 0xBF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0x9F, 0xFC,
  0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7,
  0xFE, 0x3E, 0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3,
  0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xF8, 0xF7, 0xE7, 0xBF, 0xBF, 0xFD,
  0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xF8, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7C, 0xF9, 0xFF, 0xE3,
  0xFF, 0x0F, 0xFC, 0x0F, 0xC0, 0xF3, 0xE7, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDE, 0xFE, 0xFB, 0xE7, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x7C, 0xFD, 0xF7,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xDF,
  0x1E, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x3F, 0x8F,
  0xFB, 0xFF, 0x7F, 0xCF, 0x89, 0xF8, 0x3F, 0x87, 0xFC, 0x7F, 0xC7, 0xF8,
  0x3F, 0x03, 0xFC, 0x7F, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x4F, 0xF3, 0xFC, 0x7F, 0x0F,
  0xC0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xEF, 0x3E, 0x78, 0xF8, 0x3E, 0xF8, 0x7D, 0xF1, 0xF3, 0xE3,
  0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3D, 0xE0,
  0x7B, 0xC0, 0xF7, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xC0, 0xF8, 0xFC, 0x3F, 0xF1, 0xFC, 0xF9, 0xF3, 0xF9, 0xF3, 0xE7, 0xF3,
  0xE7, 0xCF, 0xE7, 0xCF, 0x9D, 0xCF, 0x0F, 0x7B, 0x9E, 0x1E, 0xF7, 0xFC,
  0x3D, 0xEF, 0xF8, 0x7F, 0xDF, 0xF0, 0xFF, 0xBF, 0xC0, 0xFE, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x0F,
  0x87, 0xE0, 0xFC, 0x7C, 0xF9, 0xF9, 0xFB, 0xE1, 0xF7, 0xC3, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x87, 0xDF, 0x1F, 0x3E, 0x3E, 0x3E, 0xFC, 0x7E, 0xF8, 0x3E,
  0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0xBE, 0x1F,
  0x7C, 0x1E, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFE, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x7F, 0x8F, 0xE1, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0x1F, 0xC1,
  0xF1, 0xFC, 0xFE, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE3,
  0xF8, 0xFC, 0x3F, 0x0F, 0x80, 0x3C, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFE, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 22, 8, 1, -22 },
  { 18, 13, 8, 15, 1, -22 },
  { 31, 15, 22, 17, 1, -22 },
  { 73, 13, 26, 15, 1, -24 },
  { 116, 24, 22, 26, 1, -22 },
  { 182, 19, 22, 20, 1, -22 },
  { 235, 6, 8, 8, 1, -22 },
  { 241, 9, 28, 10, 1, -23 },
  { 273, 9, 28, 10, 0, -23 },
  { 305, 14, 14, 15, 0, -24 },
  { 330, 13, 16, 16, 1, -19 },
  { 356, 6, 9, 8, 1, -5 },
  { 363, 8, 5, 10, 1, -11 },
  { 368, 6, 5, 8, 1, -5 },
  { 372, 13, 22, 13, 0, -22 },
  { 408, 13, 22, 15, 1, -22 },
  { 444, 11, 22, 15, 1, -22 },
  { 475, 13, 22, 15, 1, -22 },
  { 511, 13, 22, 15, 1, -22 },
  { 547, 15, 22, 15, 0, -22 },
  { 589, 12, 22, 15, 2, -22 },
  { 622, 13, 22, 15, 1, -22 },
  { 658, 13, 22, 15, 1, -22 },
  { 694, 13, 22, 15, 1, -22 },
  { 730, 13, 22, 15, 1, -22 },
  { 766, 5, 17, 9, 2, -17 },
  { 777, 6, 21, 9, 1, -17 },
  { 793, 13, 16, 16, 1, -19 },
  { 819, 13, 11, 16, 1, -16 },
  { 837, 14, 16, 16, 1, -19 },
  { 865, 12, 22, 12, 0, -22 },
  { 898, 22, 24, 24, 1, -22 },
  { 964, 18, 22, 18, 0, -22 },
  { 1014, 14, 22, 17, 2, -22 },
  { 1053, 14, 22, 16, 1, -22 },
  { 1092, 15, 22, 18, 2, -22 },
  { 1134, 11, 22, 14, 2, -22 },
  { 1165, 10, 22, 14, 2, -22 },
  { 1193, 16, 22, 18, 1, -22 },
  { 1237, 15, 22, 19, 2, -22 },
  { 1279, 9, 22, 11, 1, -22 },
  { 1304, 9, 29, 9, -2, -22 },
  { 1337, 15, 22, 17, 2, -22 },
  { 1379, 11, 22, 13, 2, -22 },
  { 1410, 21, 22, 25, 2, -22 },
  { 1468, 17, 22, 20, 2, -22 },
  { 1515, 17, 22, 19, 1, -22 },
  { 1562, 13, 22, 16, 2, -22 },
  { 1598, 17, 27, 19, 1, -22 },
  { 1656, 15, 22, 17, 2, -22 },
  { 1698, 12, 22, 14, 1, -22 },
  { 1731, 13, 22, 14, 1, -22 },
  { 1767, 15, 22, 18, 2, -22 },
  { 1809, 17, 22, 17, 0, -22 },
  { 1856, 25, 22, 25, 0, -22 },
  { 1925, 16, 22, 16, 0, -22 },
  { 1969, 16, 22, 16, 0, -22 },
  { 2013, 13, 22, 15, 1, -22 },
  { 2049, 8, 28, 9, 1, -23 },
  { 2077, 13, 22, 13, 0, -22 },
  { 2113, 7, 28, 9, 1, -23 },
  { 2138, 17, 15, 17, 0, -22 },
  { 2170, 16, 4, 16, 0, 2 },
  { 2178, 8, 5, 11, 1, -24 },
  { 2183, 13, 17, 15, 1, -17 },
  { 2211, 13, 24, 16, 2, -24 },
  { 2250, 12, 17, 13, 1, -17 },
  { 2276, 14, 24, 16, 1, -24 },
  { 2318, 13, 17, 15, 1, -17 },
  { 2346, 11, 24, 10, 0, -24 },
  { 2379, 14, 24, 16, 1, -17 },
  { 2421, 13, 24, 16, 2, -24 },
  { 2460, 6, 24, 8, 1, -24 },
  { 2478, 8, 31, 8, -1, -24 },
  { 2509, 14, 24, 16, 2, -24 },
  { 2551, 5, 24, 8, 2, -24 },
  { 2566, 21, 17, 24, 2, -17 },
  { 2611, 13, 17, 16, 2, -17 },
  { 2639, 14, 17, 16, 1, -17 },
  { 2669, 13, 24, 16, 2, -17 },
  { 2708, 14, 24, 16, 1, -17 },
  { 2750, 9, 17, 12, 2, -17 },
  { 2770, 11, 17, 12, 1, -17 },
  { 2794, 10, 21, 11, 0, -21 },
  { 2821, 13, 17, 16, 2, -17 },
  { 2849, 15, 17, 15, 0, -17 },
  { 2881, 23, 17, 23, 0, -17 },
  { 2930, 15, 17, 15, 0, -17 },
  { 2962, 15, 24, 15, 0, -17 },
  { 3007, 12, 17, 12, 0, -17 },
  { 3033, 11, 27, 11, 0, -22 },
  { 3071, 5, 31, 13, 4, -24 },
  { 3091, 10, 27, 11, 1, -22 },
  { 3125, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Black31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK31PT7B_H_
