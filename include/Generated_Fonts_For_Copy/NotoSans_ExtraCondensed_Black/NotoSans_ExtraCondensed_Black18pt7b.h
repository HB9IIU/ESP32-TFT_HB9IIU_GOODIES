#ifndef _NOTOSANS_EXTRACONDENSED_BLACK18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0xEF, 0xDF, 0xBF, 0x7C, 0xE0, 0x1B,
  0x86, 0xC1, 0xB0, 0x6C, 0x7F, 0xDF, 0xF3, 0x30, 0xD8, 0xFF, 0xBF, 0xE3,
  0x60, 0xD8, 0x76, 0x00, 0x10, 0x21, 0xFF, 0xFD, 0x3A, 0x3C, 0x3E, 0x1E,
  0x2E, 0x5F, 0xFF, 0xC2, 0x04, 0x00, 0x38, 0x60, 0xF8, 0xC1, 0xB3, 0x07,
  0x66, 0x0E, 0xD8, 0x0D, 0xB7, 0x1F, 0xFF, 0x1D, 0xB6, 0x03, 0x6E, 0x0C,
  0xDC, 0x19, 0xB8, 0x73, 0xE0, 0xC3, 0xC0, 0x1E, 0x03, 0xF0, 0x33, 0x03,
  0x30, 0x3F, 0x03, 0xE0, 0x3E, 0xE7, 0xEE, 0xF7, 0xCE, 0x7C, 0xF7, 0xC7,
  0xFC, 0x3E, 0xF0, 0xFF, 0xFC, 0x3B, 0x99, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x39, 0xC7, 0xE3, 0x9C, 0x63, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x39,
  0xDC, 0x1C, 0x18, 0x5B, 0xFF, 0xFF, 0x3C, 0x77, 0x26, 0x38, 0x70, 0xE7,
  0xFF, 0xFF, 0xCE, 0x1C, 0x38, 0xFF, 0xFD, 0x80, 0xFF, 0xF0, 0xFF, 0x80,
  0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60,
  0xE0, 0x38, 0xFB, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBB, 0xE7,
  0xC0, 0x1C, 0xF7, 0xFF, 0xFD, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x3C,
  0x7E, 0xFF, 0x47, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x78, 0x7F, 0xFF, 0xFF,
  0x79, 0xFB, 0xF8, 0x70, 0xEF, 0x9E, 0x3F, 0x0E, 0x1E, 0x7F, 0xFF, 0x80,
  0x0E, 0x07, 0x07, 0x83, 0xC3, 0x61, 0xF1, 0xB8, 0xDC, 0xFF, 0xFF, 0xFF,
  0xE1, 0xC0, 0xE0, 0xFD, 0xFB, 0xF7, 0x0E, 0x1F, 0xBF, 0x87, 0x0E, 0x1F,
  0x7F, 0xEF, 0x80, 0x3E, 0xFD, 0xEF, 0x0E, 0x9B, 0xFF, 0xF7, 0xEF, 0xDF,
  0xBB, 0xF7, 0xC0, 0xFF, 0xFF, 0xF8, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x71,
  0xE3, 0x87, 0x00, 0x7D, 0xFF, 0xBF, 0x7E, 0xEF, 0x9F, 0x7F, 0xEF, 0x8F,
  0xBF, 0xF7, 0xC0, 0x79, 0xFB, 0xFF, 0x7E, 0xFD, 0xFF, 0xFB, 0x6E, 0x1E,
  0x77, 0xEF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xEC,
  0x02, 0x1C, 0xFF, 0xCE, 0x1F, 0x0F, 0x87, 0x02, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x81, 0xC3, 0xE1, 0xF0, 0xE7, 0xFE, 0x70, 0x80, 0x7D,
  0xFD, 0xFC, 0x70, 0xE3, 0x8E, 0x18, 0x00, 0x00, 0xE3, 0xC3, 0x80, 0x0F,
  0x83, 0xFC, 0x70, 0x6E, 0x77, 0xCF, 0xBD, 0x9B, 0xD9, 0xBD, 0x9B, 0xDB,
  0xBD, 0xFE, 0xCE, 0xE6, 0x00, 0x79, 0xC1, 0xFC, 0x1E, 0x07, 0x81, 0xF0,
  0xFC, 0x3F, 0x0E, 0xC3, 0xB9, 0xCE, 0x7F, 0x9F, 0xE7, 0xFF, 0xC7, 0xE1,
  0xC0, 0xFC, 0xFF, 0xFF, 0xE7, 0xE7, 0xFE, 0xFE, 0xFF, 0xE7, 0xE7, 0xFF,
  0xFF, 0xFC, 0x3E, 0x7F, 0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFE, 0x7E, 0x3E, 0xFC, 0x7F, 0x3F, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xF3, 0xBF, 0xDF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0xFF, 0xFF,
  0xE3, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xE3, 0xFF, 0xFF, 0xE3, 0x8E,
  0x38, 0xE0, 0x1F, 0xBF, 0x9F, 0xDE, 0x0E, 0x07, 0x7F, 0xBF, 0xDF, 0xE3,
  0xF1, 0xFF, 0xEF, 0xF3, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFF, 0xF3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0xBF, 0xFC, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9F, 0xFE, 0xF0, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE7, 0xE3,
  0xF1, 0xFC, 0xEE, 0x77, 0xB9, 0xDC, 0xEE, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F,
  0xF9, 0xFF, 0xDB, 0xFD, 0xBE, 0xFB, 0xEF, 0xBE, 0xF3, 0xEF, 0x3E, 0x73,
  0xE6, 0x30, 0xF1, 0xFC, 0x7F, 0x9F, 0xE7, 0xF9, 0xFF, 0x7F, 0xDF, 0xBF,
  0xEF, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xC0, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xEF, 0xE3, 0xE0, 0xFC, 0xFE,
  0xFF, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE, 0xF8, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E,
  0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xEF,
  0xE3, 0xE0, 0x38, 0x1C, 0x07, 0xFC, 0x7F, 0x3F, 0xDC, 0xEE, 0x77, 0x7B,
  0xF9, 0xF8, 0xEE, 0x77, 0x3B, 0xDC, 0xEE, 0x78, 0x3E, 0x7F, 0x7E, 0x72,
  0x70, 0x78, 0x3E, 0x1E, 0x0F, 0x87, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xFF,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xFF, 0xCF, 0xE3,
  0xE0, 0xE1, 0xF8, 0x77, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0xB0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x00, 0xE3, 0x9F, 0xC7, 0x3B, 0x8E, 0x73,
  0xBC, 0xE7, 0x79, 0xCE, 0xFB, 0x9D, 0xFE, 0x3B, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xC7, 0x00, 0xE3, 0xBB, 0x9D, 0xC7, 0xE3,
  0xE1, 0xF0, 0x70, 0x7C, 0x3E, 0x1F, 0x9D, 0xCE, 0x7E, 0x38, 0xE3, 0xB9,
  0xDC, 0xEE, 0xE3, 0xF1, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xE0, 0x60,
  0x70, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x07, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x07, 0x01,
  0xE0, 0x78, 0x3F, 0x0C, 0xC7, 0x39, 0x8E, 0xE1, 0xC0, 0xFF, 0xFF, 0xC0,
  0xE7, 0x30, 0x3E, 0x7F, 0x27, 0x07, 0x7F, 0x7F, 0xE7, 0xE7, 0x7F, 0x7B,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF,
  0xFE, 0xDE, 0x7F, 0xFE, 0x78, 0xE3, 0x8E, 0x39, 0xFD, 0xF0, 0x07, 0x07,
  0x07, 0x07, 0x77, 0xFF, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77,
  0x7D, 0xFF, 0xBE, 0x7F, 0xFF, 0xF0, 0x71, 0xFE, 0xFC, 0x1C, 0xF7, 0xDC,
  0x7F, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x77, 0xFF, 0xEF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0x06, 0x8E, 0xFE, 0xFC, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFE, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE0, 0xE0, 0xE0, 0xE0, 0xE7, 0xEE,
  0xEE, 0xFC, 0xFC, 0xFC, 0xFE, 0xEE, 0xE7, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xDE, 0xEF, 0xFF, 0xFF, 0x7E, 0x77, 0xE7, 0x7E, 0x77, 0xE7,
  0x7E, 0x77, 0xE7, 0x7E, 0x77, 0xDE, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x7C, 0xFE, 0xEE, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE,
  0x7C, 0xDE, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0x77, 0xFF, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF,
  0x77, 0x07, 0x07, 0x07, 0x07, 0xDF, 0xEF, 0xB8, 0xE3, 0x8E, 0x38, 0xE3,
  0x80, 0x7E, 0xFB, 0x93, 0x87, 0xC7, 0x87, 0xE7, 0xFD, 0xF8, 0x30, 0xC7,
  0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xD7, 0xCF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xEF, 0xFF, 0x77, 0xE3, 0xF3, 0x9D, 0xCE, 0xE7, 0x71, 0xB0,
  0xF8, 0x7C, 0x3C, 0x0E, 0x00, 0xE7, 0x3F, 0x3D, 0xD9, 0xEE, 0xFB, 0x67,
  0xDB, 0x3E, 0xF9, 0xF7, 0xC7, 0xBE, 0x3D, 0xE1, 0xE7, 0x00, 0xE7, 0x77,
  0x7E, 0x3E, 0x3C, 0x3C, 0x3E, 0x7E, 0x77, 0xE7, 0xE3, 0xF3, 0x9D, 0xCE,
  0xE7, 0x71, 0xB0, 0xF8, 0x7C, 0x1C, 0x0E, 0x07, 0x07, 0x87, 0x83, 0x80,
  0xFF, 0xFC, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0xFC, 0x1C, 0xF3, 0x8E,
  0x38, 0xE3, 0xBC, 0xF0, 0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xC7, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xE3,
  0x8E, 0x39, 0xEF, 0x3C, 0x78, 0xFF, 0xF7, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Black18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 10, 13, 10, 0, -13 },
  { 28, 7, 15, 9, 1, -14 },
  { 42, 15, 13, 15, 0, -13 },
  { 67, 12, 13, 12, 0, -13 },
  { 87, 3, 5, 5, 1, -13 },
  { 89, 5, 16, 6, 1, -13 },
  { 99, 5, 16, 6, 0, -13 },
  { 109, 8, 8, 9, 0, -14 },
  { 117, 7, 9, 9, 1, -11 },
  { 125, 3, 6, 5, 1, -3 },
  { 128, 4, 3, 6, 1, -6 },
  { 130, 3, 3, 5, 1, -3 },
  { 132, 8, 13, 8, 0, -13 },
  { 145, 7, 13, 9, 1, -13 },
  { 157, 6, 13, 9, 1, -13 },
  { 167, 8, 13, 9, 0, -13 },
  { 180, 7, 13, 9, 1, -13 },
  { 192, 9, 13, 9, 0, -13 },
  { 207, 7, 13, 9, 1, -13 },
  { 219, 7, 13, 9, 1, -13 },
  { 231, 7, 13, 9, 1, -13 },
  { 243, 7, 13, 9, 1, -13 },
  { 255, 7, 13, 9, 1, -13 },
  { 267, 3, 10, 5, 1, -10 },
  { 271, 3, 13, 5, 1, -10 },
  { 276, 7, 9, 9, 1, -11 },
  { 284, 7, 7, 9, 1, -10 },
  { 291, 7, 9, 9, 1, -11 },
  { 299, 7, 13, 7, 0, -13 },
  { 311, 12, 14, 14, 1, -13 },
  { 332, 10, 13, 10, 0, -13 },
  { 349, 8, 13, 10, 1, -13 },
  { 362, 8, 13, 9, 1, -13 },
  { 375, 9, 13, 11, 1, -13 },
  { 390, 6, 13, 8, 1, -13 },
  { 400, 6, 13, 8, 1, -13 },
  { 410, 9, 13, 11, 1, -13 },
  { 425, 9, 13, 11, 1, -13 },
  { 440, 6, 13, 6, 0, -13 },
  { 450, 5, 17, 5, -1, -13 },
  { 461, 9, 13, 10, 1, -13 },
  { 476, 6, 13, 8, 1, -13 },
  { 486, 12, 13, 15, 1, -13 },
  { 506, 10, 13, 12, 1, -13 },
  { 523, 9, 13, 11, 1, -13 },
  { 538, 8, 13, 9, 1, -13 },
  { 551, 9, 16, 11, 1, -13 },
  { 569, 9, 13, 10, 1, -13 },
  { 584, 8, 13, 8, 0, -13 },
  { 597, 8, 13, 8, 0, -13 },
  { 610, 9, 13, 11, 1, -13 },
  { 625, 10, 13, 10, 0, -13 },
  { 642, 15, 13, 15, 0, -13 },
  { 667, 9, 13, 9, 0, -13 },
  { 682, 9, 13, 9, 0, -13 },
  { 697, 8, 13, 8, 0, -13 },
  { 710, 4, 16, 5, 1, -13 },
  { 718, 8, 13, 8, 0, -13 },
  { 731, 5, 16, 5, 0, -13 },
  { 741, 10, 9, 10, 0, -13 },
  { 753, 9, 2, 9, 0, 1 },
  { 756, 4, 3, 6, 1, -14 },
  { 758, 8, 10, 9, 0, -10 },
  { 768, 8, 14, 9, 1, -14 },
  { 782, 6, 10, 8, 1, -10 },
  { 790, 8, 14, 9, 1, -14 },
  { 804, 7, 10, 9, 1, -10 },
  { 813, 6, 14, 6, 0, -14 },
  { 824, 8, 14, 9, 1, -10 },
  { 838, 8, 14, 10, 1, -14 },
  { 852, 3, 14, 5, 1, -14 },
  { 858, 5, 18, 5, -1, -14 },
  { 870, 8, 14, 9, 1, -14 },
  { 884, 3, 14, 5, 1, -14 },
  { 890, 12, 10, 14, 1, -10 },
  { 905, 8, 10, 10, 1, -10 },
  { 915, 8, 10, 9, 1, -10 },
  { 925, 8, 14, 9, 1, -10 },
  { 939, 8, 14, 9, 1, -10 },
  { 953, 6, 10, 7, 1, -10 },
  { 961, 7, 10, 7, 0, -10 },
  { 970, 6, 12, 6, 0, -12 },
  { 979, 8, 10, 10, 1, -10 },
  { 989, 9, 10, 9, 0, -10 },
  { 1001, 13, 10, 13, 0, -10 },
  { 1018, 8, 10, 9, 0, -10 },
  { 1028, 9, 14, 9, 0, -10 },
  { 1044, 7, 10, 7, 0, -10 },
  { 1053, 6, 16, 7, 0, -13 },
  { 1065, 3, 18, 8, 2, -14 },
  { 1072, 6, 16, 7, 0, -13 },
  { 1084, 9, 3, 9, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Black18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK18PT7B_H_
