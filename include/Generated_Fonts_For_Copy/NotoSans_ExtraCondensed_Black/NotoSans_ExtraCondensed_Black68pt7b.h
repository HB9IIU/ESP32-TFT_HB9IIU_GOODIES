#ifndef _NOTOSANS_EXTRACONDENSED_BLACK68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xCF, 0xFC, 0x3F, 0xC0, 0x78, 0x00, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xBF, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF0,
  0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xCF, 0x8F, 0x8F, 0xF8, 0xF8, 0x18, 0xFF, 0x8F, 0x80, 0x0F, 0xF8,
  0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xFC, 0xF8, 0x00, 0xFF, 0xEF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xBF, 0xF0, 0x00, 0xF9, 0xFF, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0xF9, 0xFF,
  0xE0, 0x0F, 0x9F, 0xFF, 0x80, 0xFB, 0xFE, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFE,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC7,
  0xF8, 0x7F, 0x87, 0xFF, 0xC1, 0xFF, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xF0, 0x7F,
  0x8F, 0xF8, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x7F, 0xC3, 0xFC, 0x00, 0x00,
  0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0E, 0x07, 0xF8,
  0x0C, 0x3E, 0x1F, 0xE1, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x03, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF,
  0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE7, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xCF,
  0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC,
  0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xE1, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE7,
  0xFF, 0x3F, 0xC7, 0xFF, 0x1F, 0x87, 0xFF, 0x0F, 0x07, 0xFF, 0x06, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xF0,
  0x3F, 0xFC, 0x3F, 0x01, 0xFF, 0xE0, 0xF0, 0x07, 0xFF, 0x03, 0x00, 0x3F,
  0xF8, 0x10, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x7F, 0xFC,
  0x18, 0x01, 0xFF, 0xE0, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFE,
  0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xE0, 0x07, 0xFC,
  0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x7C, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE0, 0xC0, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xEC,
  0x00, 0x1F, 0xFE, 0xF0, 0x03, 0xFF, 0xEF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xA0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0x81, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x87, 0xF8, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0xF0,
  0x7F, 0xEF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE,
  0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF,
  0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0xBF,
  0xFC, 0x0F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x5E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFD, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xF1, 0xFF,
  0xFD, 0xFF, 0x87, 0xFF, 0xCF, 0xFC, 0x1F, 0xFE, 0x7F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x00, 0x78, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x84, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x8F,
  0xF8, 0x3F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x1E, 0x00, 0x0F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xFC,
  0x70, 0x07, 0xFF, 0x10, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xE3,
  0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xE1,
  0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFE, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0x87, 0xF8, 0x1F, 0xE0,
  0xFF, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xE1,
  0xFE, 0x7F, 0x07, 0xFC, 0x7F, 0xE1, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xE3,
  0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC1, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xF1, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x02,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC1, 0xFF,
  0xF7, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x03, 0xFF,
  0xBF, 0xFC, 0x07, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD,
  0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x1F, 0xFF, 0xDF, 0xFE,
  0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x1E, 0x0F, 0xFF, 0x80,
  0x18, 0x3F, 0xFC, 0x00, 0x21, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x43, 0xFF, 0xF0, 0x07, 0x0F, 0xFF, 0xF1, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF,
  0xDF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0x83, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0x10, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xE0,
  0x07, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF,
  0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x3F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0x80,
  0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x7F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xEF,
  0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xE7,
  0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0x9F,
  0xFF, 0xFF, 0x9F, 0xFB, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xF7, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xDF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFE, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F,
  0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F,
  0xF8, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0xC7, 0xFF,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC7, 0xFF,
  0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF,
  0xDF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7,
  0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF,
  0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFC, 0xFF,
  0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF8,
  0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x07,
  0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFE,
  0x7F, 0xF8, 0x03, 0xCF, 0xFF, 0x00, 0x11, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xBF, 0xC3, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0x7F, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFE, 0xFF, 0x0F, 0xFE, 0x01,
  0xFF, 0xC3, 0xFD, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFB, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0x1F, 0xF7, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xEF,
  0xF9, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xDF, 0xF3, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0x9F, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFE, 0x3F, 0xCF, 0xFE, 0x00,
  0x7F, 0xF7, 0xFC, 0x7F, 0x9F, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xDF, 0xF1, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x3F,
  0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F,
  0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF,
  0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xFE,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F,
  0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xF0, 0x78, 0x0F, 0xFF, 0x06,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0x7F,
  0xFF, 0x9F, 0xF3, 0xFF, 0xF1, 0xFF, 0x1F, 0xFE, 0x0F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x0F,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF,
  0x8F, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x1F, 0xFE, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xC7, 0xFF, 0x80, 0x21,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x09, 0xFF, 0xE0, 0x06, 0x7F, 0xFC, 0x07, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x1F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x9F, 0xFC, 0x3F,
  0xFF, 0x7F, 0xF1, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFF, 0x7F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFD, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x87, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x3F,
  0xFF, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF,
  0x83, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x47, 0xFF, 0x80, 0x0E, 0x1F,
  0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x88, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xFC, 0xFF, 0xC3,
  0xFF, 0xF3, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF8, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xFF, 0xC3,
  0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0x9F, 0xFC, 0x07, 0xFC, 0x7F, 0xF0, 0x03,
  0x81, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF2, 0x00, 0x03, 0xFF, 0x8E, 0x00, 0x1F, 0xFE, 0x3F, 0x01, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF,
  0xE7, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x0F, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFB, 0x1F,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFD,
  0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF,
  0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xF7, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xF1,
  0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF,
  0xBF, 0xF8, 0x03, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF3, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0xBF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xBF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF3, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF1,
  0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xBF, 0xFF, 0xCF, 0xFE, 0xFF, 0xFE, 0x3F,
  0xF9, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x0F, 0xFE,
  0x03, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xFC, 0xFF, 0xC3, 0xFF,
  0xF3, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xF7, 0xFF, 0x83, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF8, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF,
  0xF7, 0xFF, 0x07, 0xFF, 0x9F, 0xFC, 0x07, 0xFC, 0x7F, 0xF0, 0x03, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0xF3,
  0xFF, 0x00, 0x47, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x30, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0xF8,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFE, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xDF, 0xFC, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xDF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xF9,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0x9F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x3F, 0xDF, 0xF1, 0xFF, 0x81, 0xFF, 0xCF, 0xF7,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFC, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF,
  0x3F, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0x00, 0xFF, 0xCF,
  0xF3, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0xFF, 0x3F, 0xF0, 0x07, 0xFD,
  0xFF, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0x8F, 0xFB, 0xFE, 0x00, 0x7F,
  0xDF, 0xE1, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x37,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xEC, 0x00, 0x3F, 0xFF, 0x20, 0x00, 0x1F,
  0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 50, 18, 3, -49 },
  { 83, 27, 18, 33, 3, -49 },
  { 144, 35, 49, 37, 1, -49 },
  { 359, 28, 56, 34, 3, -52 },
  { 555, 53, 50, 57, 2, -49 },
  { 887, 43, 50, 44, 1, -49 },
  { 1156, 11, 18, 17, 3, -49 },
  { 1181, 19, 61, 22, 3, -50 },
  { 1326, 19, 61, 22, 0, -50 },
  { 1471, 30, 31, 32, 1, -52 },
  { 1588, 30, 33, 34, 2, -41 },
  { 1712, 14, 19, 19, 2, -10 },
  { 1746, 18, 10, 22, 2, -23 },
  { 1769, 13, 13, 19, 3, -12 },
  { 1791, 29, 50, 29, 0, -49 },
  { 1973, 29, 50, 34, 2, -49 },
  { 2155, 24, 49, 34, 3, -49 },
  { 2302, 29, 49, 34, 1, -49 },
  { 2480, 29, 50, 34, 2, -49 },
  { 2662, 32, 49, 34, 1, -49 },
  { 2858, 28, 50, 34, 3, -49 },
  { 3033, 30, 50, 34, 2, -49 },
  { 3221, 28, 49, 34, 3, -49 },
  { 3393, 30, 50, 34, 2, -49 },
  { 3581, 29, 50, 34, 2, -49 },
  { 3763, 13, 39, 19, 3, -38 },
  { 3827, 14, 47, 19, 2, -38 },
  { 3910, 30, 33, 34, 2, -41 },
  { 4034, 30, 24, 34, 2, -36 },
  { 4124, 30, 33, 34, 2, -41 },
  { 4248, 26, 50, 27, 0, -49 },
  { 4411, 48, 54, 52, 2, -49 },
  { 4735, 39, 49, 39, 0, -49 },
  { 4974, 31, 49, 38, 4, -49 },
  { 5164, 30, 50, 34, 3, -49 },
  { 5352, 33, 49, 40, 4, -49 },
  { 5555, 23, 49, 30, 4, -49 },
  { 5696, 23, 49, 30, 4, -49 },
  { 5837, 34, 50, 40, 3, -49 },
  { 6050, 33, 49, 41, 4, -49 },
  { 6253, 20, 49, 24, 2, -49 },
  { 6376, 20, 64, 20, -4, -49 },
  { 6536, 34, 49, 38, 4, -49 },
  { 6745, 24, 49, 29, 4, -49 },
  { 6892, 47, 49, 55, 4, -49 },
  { 7180, 37, 49, 45, 4, -49 },
  { 7407, 37, 50, 42, 3, -49 },
  { 7639, 29, 49, 35, 4, -49 },
  { 7817, 37, 61, 42, 3, -49 },
  { 8100, 33, 49, 37, 4, -49 },
  { 8303, 27, 50, 31, 2, -49 },
  { 8472, 29, 49, 31, 1, -49 },
  { 8650, 32, 50, 40, 4, -49 },
  { 8850, 38, 49, 38, 0, -49 },
  { 9083, 55, 49, 55, 0, -49 },
  { 9420, 36, 49, 35, 0, -49 },
  { 9641, 36, 49, 36, 0, -49 },
  { 9862, 30, 49, 32, 1, -49 },
  { 10046, 16, 61, 21, 3, -50 },
  { 10168, 29, 50, 29, 0, -49 },
  { 10350, 17, 61, 21, 1, -50 },
  { 10480, 36, 33, 37, 0, -49 },
  { 10629, 34, 9, 34, 0, 4 },
  { 10668, 17, 11, 23, 3, -52 },
  { 10692, 28, 39, 34, 2, -38 },
  { 10829, 30, 53, 36, 3, -52 },
  { 11028, 26, 39, 29, 2, -38 },
  { 11155, 30, 53, 36, 2, -52 },
  { 11354, 29, 39, 33, 2, -38 },
  { 11496, 24, 52, 22, 0, -52 },
  { 11652, 30, 54, 36, 2, -38 },
  { 11855, 30, 52, 36, 3, -52 },
  { 12050, 12, 53, 18, 3, -53 },
  { 12130, 18, 69, 18, -3, -53 },
  { 12286, 33, 52, 35, 3, -52 },
  { 12501, 11, 52, 18, 3, -52 },
  { 12573, 47, 38, 54, 3, -38 },
  { 12797, 30, 38, 36, 3, -38 },
  { 12940, 31, 39, 35, 2, -38 },
  { 13092, 30, 54, 36, 3, -38 },
  { 13295, 30, 54, 36, 2, -38 },
  { 13498, 22, 38, 26, 3, -38 },
  { 13603, 23, 39, 27, 2, -38 },
  { 13716, 23, 46, 24, 0, -45 },
  { 13849, 30, 39, 36, 3, -38 },
  { 13996, 33, 38, 33, 0, -38 },
  { 14153, 50, 38, 50, 0, -38 },
  { 14391, 32, 38, 32, 0, -38 },
  { 14543, 33, 54, 33, 0, -38 },
  { 14766, 25, 38, 27, 1, -38 },
  { 14885, 23, 60, 25, 1, -49 },
  { 15058, 10, 68, 28, 9, -52 },
  { 15143, 23, 60, 25, 1, -49 },
  { 15316, 30, 13, 34, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Black68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK68PT7B_H_
