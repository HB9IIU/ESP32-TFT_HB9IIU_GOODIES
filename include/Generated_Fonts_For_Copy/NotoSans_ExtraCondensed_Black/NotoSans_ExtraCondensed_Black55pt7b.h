#ifndef _NOTOSANS_EXTRACONDENSED_BLACK55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x0F, 0xE3, 0xFE, 0x7F, 0xDF, 0xFB,
  0xFF, 0x7F, 0xE7, 0xFC, 0xFF, 0x8F, 0xE0, 0x60, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0x87, 0xFD, 0xFE, 0x1F,
  0xF7, 0xF8, 0x7F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7,
  0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFD, 0xE7, 0xC7, 0xF3, 0xC1, 0x1F, 0xE7, 0x80, 0x3F, 0xCF, 0x00, 0x3F,
  0x9E, 0x00, 0x7F, 0xBC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xEF,
  0xF0, 0x03, 0xCF, 0xE0, 0x07, 0x9F, 0xD0, 0x0F, 0x3F, 0xB0, 0x1E, 0xFF,
  0x7C, 0x3D, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x8F, 0xE0, 0xFC, 0x07,
  0xF3, 0xF8, 0xFE, 0x3F, 0xF0, 0x7F, 0x3F, 0x9F, 0xC7, 0xFF, 0x83, 0xFF,
  0xF9, 0xFC, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF3,
  0xF9, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0x1F, 0xCF, 0xE0, 0x7F, 0xC7, 0xF1,
  0xFC, 0x7E, 0x01, 0xE0, 0x7F, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x03,
  0xF0, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xF8, 0x3F, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE0,
  0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x7E, 0x02, 0x78, 0x7E,
  0x1E, 0x7E, 0x7E, 0x7E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7,
  0xF8, 0x3F, 0xE7, 0xFE, 0x3F, 0xC3, 0xFC, 0x0F, 0xC3, 0xF8, 0x07, 0x81,
  0xE0, 0x03, 0x81, 0xC0, 0x01, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE7, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xE7, 0xFD, 0xFF,
  0xDF, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xEF, 0xFC, 0xFF, 0x8F, 0xF9, 0xFF,
  0x1F, 0xF3, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF8, 0x7F, 0xDF, 0xF1, 0xFF, 0x3F,
  0xE3, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xF7, 0xF9, 0xFF, 0x3F, 0x1F, 0xF1, 0xF1, 0xFF, 0x06, 0x1F, 0xF0, 0x41,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0x8F, 0xFC, 0x7C, 0x0F, 0xFC, 0x70,
  0x1F, 0xF8, 0x40, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3E, 0x1F, 0xFC, 0x30, 0x0F, 0xF8, 0x40, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0x7F, 0xC0,
  0x3F, 0xDF, 0xF0, 0x0F, 0xE7, 0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFC, 0x7F,
  0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0x87, 0xFC, 0x1F, 0xC1, 0xFF, 0x07, 0xF0,
  0x7F, 0xC3, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0xF0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xBF, 0x1F, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xA0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x8F, 0xC0, 0xFF, 0xBF, 0xF0, 0xFF, 0x3F, 0xF8, 0xFF,
  0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xEF, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x83,
  0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xEF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xEF, 0xFC, 0xFF, 0xC7, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFD, 0xFF, 0x0F, 0xFB,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x9F, 0xFE, 0xFF, 0x1F, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x0F, 0x8F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x20, 0x7F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0xF3, 0xFE, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xF0, 0x30, 0x0F, 0x07, 0xF1,
  0xFF, 0x3F, 0xE7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0xC3, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xEF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3E, 0x1F, 0xF9,
  0xC0, 0x7F, 0xC4, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0xFC, 0xFE, 0x3F, 0x03, 0xFF,
  0xF1, 0xF9, 0xFC, 0x1F, 0xFF, 0xC7, 0xF7, 0xF0, 0xFF, 0xFF, 0x1F, 0xDF,
  0x87, 0xF9, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xF0, 0xFF, 0xF8, 0xFE, 0x0F,
  0xC3, 0xFF, 0xE3, 0xF8, 0x3F, 0x0F, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xFC,
  0x3F, 0x07, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF0, 0x7F,
  0x0F, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0xFC, 0x3F, 0x07, 0xF0, 0xFF, 0xF0,
  0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0xBF, 0x0F, 0xE3, 0xFC,
  0x7E, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xE1,
  0xFF, 0xEF, 0xFE, 0x1F, 0xC3, 0xFF, 0x1F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x80, 0xFE, 0x03, 0x80, 0x78, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x3F, 0xE0, 0x00, 0x38,
  0x00, 0x7F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07,
  0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFE, 0x0F,
  0xFB, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFC, 0x3E, 0x1F,
  0xFC, 0x06, 0x0F, 0xFC, 0x00, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x08, 0x7F, 0xF0, 0x1C, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8,
  0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F,
  0xE0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFD, 0xFF, 0x87, 0xFF, 0x3F, 0xF1, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0x83, 0xFF, 0x80, 0x18, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF,
  0x7F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF,
  0x81, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0xFF, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8,
  0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC,
  0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xEF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xBF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xFF,
  0xFB, 0xFC, 0x7F, 0x7F, 0xFF, 0xE7, 0xF3, 0xFD, 0xFF, 0xFF, 0x9F, 0xCF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xBF, 0x9F, 0xFF, 0xF9, 0xFE, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0x81,
  0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xFE, 0xFF, 0x9F, 0xFF,
  0xFB, 0xFE, 0x7F, 0xFF, 0xE7, 0xFD, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0xFE,
  0x3F, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x01, 0xFF,
  0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF,
  0xDF, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x3F,
  0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x3F,
  0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F,
  0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xCF, 0xF8, 0x02,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xBF, 0x07, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xE1, 0xFF, 0x03, 0xFE,
  0x3F, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFD, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xEF, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0x7F, 0x3F, 0xE0, 0x1F, 0xE3, 0xFB,
  0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xDF, 0xCF, 0xF8, 0x07, 0xFD, 0xFC, 0xFE,
  0x7F, 0x80, 0x3F, 0xEF, 0xE7, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x1F, 0xBF,
  0xE0, 0x07, 0xFB, 0xF8, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xC7, 0xFF, 0xF8,
  0x01, 0xFE, 0xFE, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x07,
  0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xC3, 0xFF, 0x06, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xF3, 0xFD, 0xFF, 0x07, 0xFB, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE3,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7,
  0xF3, 0xFF, 0xCF, 0xE3, 0xFF, 0x1F, 0xC3, 0xFC, 0x1F, 0x81, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xC0,
  0xFF, 0x9F, 0xE0, 0xFF, 0xBF, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF8,
  0xFF, 0x3F, 0xF0, 0xFE, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xE0, 0x63, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x0B, 0xFF, 0x00, 0xCF, 0xFC, 0x1E,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x05, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xE1, 0xFF, 0x0F, 0xF9, 0xFF,
  0x1F, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF,
  0x07, 0xF8, 0x7F, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0x83, 0xFD, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0x3F, 0xE0, 0x0C, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE4, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0xFF,
  0x1F, 0xFC, 0xFF, 0x1F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFD, 0xFF, 0x0F, 0xFD, 0xFF,
  0x07, 0xF1, 0xFF, 0x00, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x40, 0x03, 0xFE, 0x70, 0x03, 0xFE, 0x7F, 0x1F, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x7E, 0x0F, 0xF3, 0xFF, 0x1F, 0xEF, 0xFF, 0x3F, 0xDF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFC, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF8,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF3, 0xFE,
  0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0xFF, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xBF,
  0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0xFF, 0xC1, 0xFF,
  0x0F, 0xE7, 0xFF, 0x8F, 0xFE, 0x3F, 0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x7F,
  0xE3, 0xF9, 0xFF, 0xE7, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F,
  0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0xFF, 0xC7, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF,
  0x3F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0x7F, 0xFC, 0xFF, 0x3F, 0xF8, 0xFF, 0xBF, 0xF0, 0xFF,
  0x8F, 0xE0, 0xFF, 0x81, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x1F,
  0xFC, 0xFF, 0x1F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC3, 0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFD, 0xFF, 0x0F, 0xF9, 0xFF, 0x07,
  0xF1, 0xFF, 0x00, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFC, 0x3C, 0xFF, 0x81, 0x9F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x02, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x10, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x0C, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF9, 0xFF,
  0xE7, 0xF1, 0xFF, 0x8F, 0xE1, 0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x7F, 0x81,
  0xFF, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0xC1,
  0xFE, 0x7F, 0xC3, 0xFF, 0xC1, 0xFE, 0x3F, 0xC3, 0xFF, 0xC3, 0xFE, 0x3F,
  0xC3, 0xFF, 0xE3, 0xFE, 0x3F, 0xC3, 0xFF, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF,
  0xE3, 0xFC, 0x3F, 0xE7, 0xFF, 0xE3, 0xFC, 0x1F, 0xE7, 0xF7, 0xE3, 0xFC,
  0x1F, 0xE7, 0xF7, 0xE7, 0xFC, 0x1F, 0xE7, 0xF7, 0xF7, 0xFC, 0x1F, 0xE7,
  0xE7, 0xF7, 0xF8, 0x1F, 0xE7, 0xE7, 0xF7, 0xF8, 0x0F, 0xFF, 0xE7, 0xF7,
  0xF8, 0x0F, 0xFF, 0xE7, 0xF7, 0xF8, 0x0F, 0xFF, 0xE3, 0xF7, 0xF0, 0x0F,
  0xFF, 0xE3, 0xF7, 0xF0, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xDF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0xCF, 0xFC,
  0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x01, 0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Black55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 40, 15, 2, -39 },
  { 56, 22, 14, 27, 2, -39 },
  { 95, 28, 39, 30, 1, -39 },
  { 232, 23, 45, 27, 2, -42 },
  { 362, 44, 40, 46, 1, -40 },
  { 582, 35, 41, 35, 1, -40 },
  { 762, 10, 14, 14, 2, -39 },
  { 780, 16, 49, 18, 2, -40 },
  { 878, 16, 49, 18, 0, -40 },
  { 976, 24, 25, 26, 1, -42 },
  { 1051, 24, 27, 28, 2, -33 },
  { 1132, 11, 16, 15, 2, -8 },
  { 1154, 14, 8, 18, 2, -19 },
  { 1168, 11, 11, 15, 2, -10 },
  { 1184, 23, 41, 23, 0, -40 },
  { 1302, 23, 41, 27, 2, -40 },
  { 1420, 20, 39, 27, 2, -39 },
  { 1518, 23, 40, 27, 1, -40 },
  { 1633, 23, 41, 27, 2, -40 },
  { 1751, 26, 39, 27, 1, -39 },
  { 1878, 22, 40, 27, 3, -39 },
  { 1988, 24, 41, 27, 2, -40 },
  { 2111, 23, 39, 27, 2, -39 },
  { 2224, 24, 41, 27, 2, -40 },
  { 2347, 23, 41, 27, 2, -40 },
  { 2465, 10, 32, 15, 3, -31 },
  { 2505, 11, 39, 15, 2, -31 },
  { 2559, 24, 28, 28, 2, -34 },
  { 2643, 24, 19, 28, 2, -29 },
  { 2700, 24, 28, 28, 2, -34 },
  { 2784, 21, 41, 22, 0, -40 },
  { 2892, 38, 44, 42, 2, -40 },
  { 3101, 32, 39, 32, 0, -39 },
  { 3257, 25, 39, 31, 3, -39 },
  { 3379, 25, 41, 28, 2, -40 },
  { 3508, 27, 39, 32, 3, -39 },
  { 3640, 19, 39, 24, 3, -39 },
  { 3733, 19, 39, 24, 3, -39 },
  { 3826, 28, 41, 33, 2, -40 },
  { 3970, 27, 39, 34, 3, -39 },
  { 4102, 17, 39, 19, 1, -39 },
  { 4185, 16, 51, 16, -3, -39 },
  { 4287, 28, 39, 30, 3, -39 },
  { 4424, 20, 39, 24, 3, -39 },
  { 4522, 38, 39, 44, 3, -39 },
  { 4708, 30, 39, 36, 3, -39 },
  { 4855, 30, 41, 34, 2, -40 },
  { 5009, 24, 39, 29, 3, -39 },
  { 5126, 30, 49, 34, 2, -40 },
  { 5310, 27, 39, 30, 3, -39 },
  { 5442, 22, 41, 25, 2, -40 },
  { 5555, 23, 39, 25, 1, -39 },
  { 5668, 26, 40, 32, 3, -39 },
  { 5798, 31, 39, 31, 0, -39 },
  { 5950, 45, 39, 45, 0, -39 },
  { 6170, 29, 39, 29, 0, -39 },
  { 6312, 29, 39, 29, 0, -39 },
  { 6454, 24, 39, 26, 1, -39 },
  { 6571, 14, 49, 17, 2, -40 },
  { 6657, 23, 41, 23, 0, -40 },
  { 6775, 13, 49, 17, 1, -40 },
  { 6855, 29, 26, 30, 0, -39 },
  { 6950, 28, 6, 28, 0, 4 },
  { 6971, 15, 9, 19, 2, -42 },
  { 6988, 23, 32, 27, 1, -31 },
  { 7080, 24, 43, 29, 3, -42 },
  { 7209, 21, 32, 24, 2, -31 },
  { 7293, 24, 43, 29, 2, -42 },
  { 7422, 23, 32, 27, 2, -31 },
  { 7514, 19, 42, 18, 0, -42 },
  { 7614, 24, 44, 29, 2, -31 },
  { 7746, 23, 42, 29, 3, -42 },
  { 7867, 9, 43, 15, 3, -43 },
  { 7916, 14, 56, 15, -2, -43 },
  { 8014, 26, 42, 29, 3, -42 },
  { 8151, 9, 42, 14, 3, -42 },
  { 8199, 38, 31, 43, 3, -31 },
  { 8347, 23, 31, 29, 3, -31 },
  { 8437, 25, 32, 28, 2, -31 },
  { 8537, 24, 44, 29, 3, -31 },
  { 8669, 24, 44, 29, 2, -31 },
  { 8801, 17, 31, 21, 3, -31 },
  { 8867, 19, 32, 22, 1, -31 },
  { 8943, 18, 38, 19, 0, -37 },
  { 9029, 23, 31, 29, 3, -30 },
  { 9119, 27, 30, 27, 0, -30 },
  { 9221, 40, 30, 40, 0, -30 },
  { 9371, 26, 30, 26, 0, -30 },
  { 9469, 27, 43, 27, 0, -30 },
  { 9615, 20, 30, 22, 1, -30 },
  { 9690, 18, 49, 20, 1, -40 },
  { 9801, 7, 55, 23, 8, -42 },
  { 9850, 18, 49, 20, 1, -40 },
  { 9961, 24, 11, 28, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Black55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK55PT7B_H_
