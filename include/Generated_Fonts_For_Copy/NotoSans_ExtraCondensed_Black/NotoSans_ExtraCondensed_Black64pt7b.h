#ifndef _NOTOSANS_EXTRACONDENSED_BLACK64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x0E, 0x00,
  0xFF, 0xF1, 0xFF, 0xDF, 0xFC, 0x7F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x83,
  0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF,
  0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF7, 0x8F, 0x8F, 0xF9, 0xE0, 0x63, 0xFC, 0x78, 0x00, 0xFF, 0x1E,
  0x00, 0x3F, 0xC7, 0x80, 0x0F, 0xF9, 0xE0, 0x03, 0xFF, 0x78, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7B, 0xFF, 0x00, 0x1E, 0x7F, 0xC0, 0x07, 0x8F, 0xF0, 0x01, 0xE3, 0xFE,
  0x00, 0x78, 0xFF, 0xE0, 0x1E, 0x7F, 0xFE, 0x07, 0x9F, 0xEF, 0xE1, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x7F,
  0x8F, 0xF0, 0x7F, 0xE0, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xC3, 0xFC, 0x7F, 0x9F, 0xE0, 0xFF, 0xE0, 0xFE, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF3, 0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0xFF, 0x00, 0x87, 0x07, 0xF8,
  0x3C, 0x7F, 0x1F, 0xC7, 0xE3, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x87, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x3F, 0xF8, 0x7F,
  0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF,
  0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0,
  0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0xFF, 0xEF,
  0xFC, 0x1F, 0xFD, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F,
  0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F,
  0xE7, 0xFF, 0x1F, 0xC7, 0xFF, 0x0F, 0x87, 0xFF, 0x07, 0x07, 0xFF, 0x02,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xF8, 0x7F, 0xF8, 0x7E, 0x07, 0xFF, 0x87, 0x80, 0x7F, 0xF0, 0xE0, 0x0F,
  0xFE, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xE0, 0x7F, 0xF8, 0x70, 0x07, 0xFF, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0x80,
  0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFE, 0x7F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x80, 0x3F, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xF8,
  0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0xFF,
  0xE0, 0x7F, 0xCF, 0xFF, 0x0F, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x0F, 0xFE, 0xFF, 0xF0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F,
  0xE7, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF9, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE7, 0xFE, 0x07,
  0xFE, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF,
  0xE7, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0,
  0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFB, 0xFE, 0x3F,
  0xFF, 0xBF, 0xE1, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0x7F, 0xE0, 0x7F, 0xC7,
  0xFE, 0x00, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x83, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF1,
  0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0xC7,
  0x00, 0xFF, 0xE2, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xF1, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF,
  0xC7, 0xF8, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0xFF, 0xF0,
  0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0x3F, 0xF3, 0xFC, 0x3F,
  0xDF, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF7,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F,
  0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8,
  0x1F, 0xE1, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0x07,
  0xF8, 0x7F, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFB, 0xFC, 0x3F, 0xC3, 0xFE,
  0x1F, 0xDF, 0xE1, 0xFE, 0x1F, 0xF1, 0xFC, 0x7F, 0x07, 0xF9, 0xFF, 0x9F,
  0xE3, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xFB, 0xFF, 0xF0,
  0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFF,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0x0F, 0xFF, 0xBF, 0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE,
  0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xC1, 0xFF, 0xEF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0x07, 0xFF, 0x80, 0x30, 0x7F, 0xF8, 0x00, 0x83, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x04, 0x7F, 0xFC, 0x00,
  0xC1, 0xFF, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xE7,
  0xFF, 0x03, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFD, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xE7, 0xFF, 0x07, 0xFF,
  0xCF, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x07,
  0xFF, 0xC0, 0x06, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xFB, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F,
  0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xEF, 0xFE, 0x0F,
  0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF,
  0xF0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFA, 0x0F, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xC0,
  0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0x0F, 0xFB, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x0F,
  0xF3, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0x9F, 0xE7,
  0xFF, 0xFF, 0xCF, 0xF9, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x9F, 0xE7, 0xFF,
  0xFF, 0xC7, 0xFB, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF,
  0xFF, 0xF1, 0xFF, 0xBF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFE,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0x07, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD,
  0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF,
  0xF3, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x01, 0xFF,
  0xDF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFC, 0x07, 0x9F, 0xFC, 0x00, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x74, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC7, 0xFB, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0x9F, 0xC7,
  0xFF, 0x00, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x9F,
  0xE7, 0xFE, 0x00, 0x7F, 0xE7, 0xF9, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0xFF,
  0x9F, 0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xF9, 0xFE, 0xFF, 0xE0, 0x07, 0xFE,
  0xFF, 0x1F, 0xEF, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x3F,
  0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0x1F, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xC1,
  0xC0, 0x7F, 0xF0, 0x40, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xCF, 0xFF, 0x8F, 0xF1, 0xFF, 0xC3, 0xFC,
  0x3F, 0xE0, 0x7F, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0x80, 0xFF, 0xC7, 0xFE, 0x0F,
  0xFC, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xDF, 0xFF, 0x0F, 0xF8, 0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xF8, 0x1C, 0x7F, 0xF0, 0x04, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x02, 0x7F, 0xF0, 0x06, 0x7F,
  0xFC, 0x3E, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x1F, 0x83, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0x0F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0,
  0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0x07,
  0xFF, 0x7F, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0x9F, 0xF0, 0x7F, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x81,
  0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x02, 0x3F, 0xFC, 0x01, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0x1F, 0xF0, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF,
  0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x8F, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7,
  0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x20, 0x00, 0x7F, 0xE3, 0xC0, 0x0F, 0xFE, 0x3F,
  0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0xFF, 0xC7, 0xFE, 0x0F,
  0xFC, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF9, 0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x0E,
  0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x03, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF1,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x03, 0xFF,
  0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xBF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x8F, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x8F, 0xFF, 0x0F, 0xF9, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0x9F, 0xFC, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF,
  0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x0F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF, 0xFC, 0xFF, 0xDF, 0xFF, 0x8F, 0xFC,
  0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0xE0, 0x70,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0x1F,
  0xF0, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x8F,
  0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x7F,
  0xF7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFB,
  0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0x00, 0x60, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xE3, 0xF3, 0xFF, 0x03, 0x8F, 0xFC,
  0x02, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x10, 0xFF,
  0xF3, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x03, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0x9F, 0xF0, 0xFF, 0xF1,
  0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF9,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xE7,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFC, 0x3F, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFD, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC3, 0xFB, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xF7, 0xF8, 0xFF, 0x81, 0xFF,
  0x9F, 0xEF, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xDF, 0xE7, 0xFE, 0x07, 0xFE,
  0x7F, 0xBF, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0x7F, 0x9F, 0xF0, 0x0F, 0xF9,
  0xFE, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xF8, 0xFE, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF1, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xE3, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF3, 0xFF,
  0x80, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x1F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03,
  0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x9F, 0xF8,
  0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80,
  0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x11, 0xFF, 0x80, 0x01, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE8, 0x00, 0x1F, 0xF8, 0x80, 0x00,
  0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 47, 17, 3, -46 },
  { 72, 26, 17, 31, 2, -46 },
  { 128, 33, 46, 35, 1, -46 },
  { 318, 26, 53, 32, 3, -49 },
  { 491, 50, 47, 54, 2, -46 },
  { 785, 40, 47, 41, 1, -46 },
  { 1020, 12, 17, 16, 2, -46 },
  { 1046, 18, 57, 21, 3, -47 },
  { 1175, 18, 57, 21, 0, -47 },
  { 1304, 29, 29, 30, 1, -49 },
  { 1410, 28, 31, 32, 2, -38 },
  { 1519, 13, 18, 17, 2, -9 },
  { 1549, 17, 10, 21, 2, -22 },
  { 1571, 12, 12, 17, 3, -11 },
  { 1589, 27, 47, 27, 0, -46 },
  { 1748, 27, 47, 32, 2, -46 },
  { 1907, 24, 46, 32, 2, -46 },
  { 2045, 27, 46, 32, 1, -46 },
  { 2201, 27, 47, 32, 2, -46 },
  { 2360, 30, 46, 32, 1, -46 },
  { 2533, 26, 47, 32, 3, -46 },
  { 2686, 28, 47, 32, 2, -46 },
  { 2851, 27, 46, 32, 2, -46 },
  { 3007, 28, 47, 32, 2, -46 },
  { 3172, 28, 47, 32, 2, -46 },
  { 3337, 12, 37, 18, 3, -36 },
  { 3393, 13, 45, 18, 2, -36 },
  { 3467, 28, 32, 32, 2, -39 },
  { 3579, 28, 23, 32, 2, -34 },
  { 3660, 28, 32, 32, 2, -39 },
  { 3772, 25, 47, 26, 0, -46 },
  { 3919, 45, 51, 49, 2, -46 },
  { 4206, 37, 46, 37, 0, -46 },
  { 4419, 29, 46, 36, 4, -46 },
  { 4586, 29, 47, 32, 2, -46 },
  { 4757, 31, 46, 38, 4, -46 },
  { 4936, 22, 46, 28, 4, -46 },
  { 5063, 22, 46, 28, 4, -46 },
  { 5190, 33, 47, 38, 2, -46 },
  { 5384, 31, 46, 39, 4, -46 },
  { 5563, 19, 46, 23, 2, -46 },
  { 5673, 19, 60, 19, -4, -46 },
  { 5816, 32, 46, 35, 4, -46 },
  { 6000, 23, 46, 27, 4, -46 },
  { 6133, 44, 46, 52, 4, -46 },
  { 6386, 34, 46, 42, 4, -46 },
  { 6582, 35, 47, 40, 2, -46 },
  { 6788, 27, 46, 33, 4, -46 },
  { 6944, 35, 57, 40, 2, -46 },
  { 7194, 31, 46, 35, 4, -46 },
  { 7373, 25, 47, 29, 2, -46 },
  { 7520, 27, 46, 29, 1, -46 },
  { 7676, 30, 47, 38, 4, -46 },
  { 7853, 36, 46, 36, 0, -46 },
  { 8060, 52, 46, 52, 0, -46 },
  { 8359, 33, 46, 33, 0, -46 },
  { 8549, 34, 46, 34, 0, -46 },
  { 8745, 28, 46, 30, 1, -46 },
  { 8906, 15, 58, 19, 3, -47 },
  { 9015, 27, 47, 27, 0, -46 },
  { 9174, 16, 58, 19, 1, -47 },
  { 9290, 34, 31, 35, 0, -46 },
  { 9422, 32, 8, 32, 0, 4 },
  { 9454, 16, 10, 22, 3, -49 },
  { 9474, 26, 37, 32, 2, -36 },
  { 9595, 28, 50, 34, 3, -49 },
  { 9770, 24, 37, 28, 2, -36 },
  { 9881, 28, 50, 34, 2, -49 },
  { 10056, 27, 37, 31, 2, -36 },
  { 10181, 22, 49, 21, 0, -49 },
  { 10316, 28, 51, 34, 2, -36 },
  { 10495, 28, 49, 34, 3, -49 },
  { 10667, 11, 50, 17, 3, -50 },
  { 10736, 16, 65, 17, -2, -50 },
  { 10866, 31, 49, 33, 3, -49 },
  { 11056, 11, 49, 17, 3, -49 },
  { 11124, 44, 36, 51, 3, -36 },
  { 11322, 28, 36, 34, 3, -36 },
  { 11448, 29, 37, 33, 2, -36 },
  { 11583, 28, 51, 34, 3, -36 },
  { 11762, 28, 51, 34, 2, -36 },
  { 11941, 20, 36, 24, 3, -36 },
  { 12031, 22, 37, 25, 2, -36 },
  { 12133, 22, 44, 23, 0, -43 },
  { 12254, 28, 36, 34, 3, -35 },
  { 12380, 31, 35, 31, 0, -35 },
  { 12516, 47, 35, 47, 0, -35 },
  { 12722, 30, 35, 30, 0, -35 },
  { 12854, 31, 50, 31, 0, -35 },
  { 13048, 23, 35, 25, 1, -35 },
  { 13149, 21, 57, 23, 1, -46 },
  { 13299, 9, 64, 27, 9, -49 },
  { 13371, 22, 57, 23, 1, -46 },
  { 13528, 28, 13, 32, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_Black64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK64PT7B_H_
