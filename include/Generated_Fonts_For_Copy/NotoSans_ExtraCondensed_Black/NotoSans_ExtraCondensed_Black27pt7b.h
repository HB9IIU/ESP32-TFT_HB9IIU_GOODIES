#ifndef _NOTOSANS_EXTRACONDENSED_BLACK27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF0, 0x01, 0xDF, 0xFF,
  0xDE, 0xFB, 0xFF, 0x7F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDC, 0x70, 0x0E,
  0x70, 0x77, 0x87, 0xB8, 0x39, 0xC1, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1D, 0xE1, 0xEE, 0x0E, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0x07,
  0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0x06, 0x00, 0xC0, 0x3C, 0x1F, 0xF7,
  0xFF, 0xFF, 0xBD, 0x97, 0xB0, 0xF6, 0x0F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC1, 0xBC, 0x37, 0xE7, 0xFF, 0xFB, 0xFF, 0x1F, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x18, 0x00, 0x03, 0xF0, 0x78, 0x3F, 0x83, 0x81, 0xFE, 0x3C,
  0x0E, 0x71, 0xC0, 0x73, 0x8E, 0x03, 0x9C, 0xF0, 0x1C, 0xE7, 0x00, 0xE7,
  0x79, 0xC7, 0xFB, 0x9F, 0x9F, 0x9D, 0xFC, 0xFD, 0xCE, 0xF1, 0x0E, 0x73,
  0x80, 0xF7, 0x9C, 0x07, 0x3C, 0xE0, 0x38, 0xE7, 0x03, 0x87, 0x78, 0x1C,
  0x3F, 0x81, 0xE0, 0xFC, 0x0E, 0x07, 0xC0, 0x02, 0x00, 0x0F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xCF, 0x9F, 0xE7, 0x9F, 0xFB, 0xCF, 0xFF, 0xE7, 0x9F,
  0xF3, 0xC7, 0xF1, 0xE1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87,
  0xF3, 0xF0, 0xFF, 0xFF, 0xEF, 0x79, 0xC0, 0x0F, 0x1E, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8,
  0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x1F, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0xF8, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0xCE, 0x67, 0xFF, 0x3F, 0xFB, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x1F,
  0x7C, 0x31, 0x80, 0x88, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x7B, 0xDF, 0xFF, 0x7B, 0xDE, 0xFF, 0xFF, 0xFF, 0xF0, 0x37, 0xFF,
  0xF7, 0x80, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x04, 0x07, 0xF0, 0xFF, 0x3F, 0xE7,
  0xBF, 0xF3, 0xFE, 0x7F, 0xCF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xF3, 0xFE, 0x7F, 0xDF, 0x7F, 0xEF, 0xF8, 0xFF, 0x0F, 0xC0, 0x07, 0xC3,
  0xF1, 0xFC, 0xFF, 0x7F, 0xFF, 0xF7, 0xFC, 0xDF, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0C, 0x07,
  0xF3, 0xFF, 0x7F, 0xEF, 0x7E, 0xC7, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x0F, 0xF3, 0xFF, 0x7F, 0xF7, 0x7E, 0x87, 0xC0, 0xF8,
  0x1E, 0x3F, 0xC7, 0xE0, 0xFE, 0x1F, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78,
  0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x80, 0xF0, 0x1F, 0x83, 0xFC,
  0x7F, 0xCF, 0xFC, 0x8F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF9, 0xFC, 0x00, 0x01, 0x80, 0xFE, 0x3F, 0xE3, 0xFE, 0x7E, 0x07,
  0x80, 0xF8, 0x0F, 0x38, 0xF7, 0xCF, 0xFE, 0xFF, 0xEF, 0x9E, 0xF1, 0xEF,
  0x1F, 0xF9, 0xEF, 0x9E, 0x7F, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF0,
  0x00, 0x04, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x9E, 0xF9, 0xE7,
  0xFE, 0x7F, 0xC3, 0xF8, 0x3F, 0x87, 0xFC, 0xFB, 0xEF, 0x1E, 0xF1, 0xFF,
  0x1F, 0xFB, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0x04, 0x03, 0xF8, 0x7F, 0xC7,
  0xFC, 0xFB, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xFF, 0xBE, 0xFF, 0xE7,
  0xFE, 0x7F, 0xE0, 0x9E, 0x01, 0xE0, 0x3C, 0x7F, 0xC7, 0xF8, 0x7F, 0x87,
  0xE0, 0x7F, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFD, 0xE0, 0x7F,
  0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xBF, 0xFE, 0xF7, 0xBC, 0x00,
  0x30, 0x1F, 0x07, 0xF1, 0xFF, 0x7F, 0x8F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF0, 0xFF, 0x7F, 0x8F, 0xE0,
  0xF8, 0x0E, 0x00, 0x80, 0x00, 0x04, 0x1F, 0xEF, 0xFF, 0xFF, 0x77, 0xD0,
  0xF0, 0x3C, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x30, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x38, 0xF0, 0xE3, 0x9C, 0x7F, 0x73, 0x9F,
  0xEF, 0xE7, 0x9C, 0xFC, 0xE3, 0x9F, 0x9C, 0xF3, 0xF3, 0x9E, 0x7E, 0x73,
  0xCF, 0xCE, 0x7B, 0xB9, 0xFF, 0xF7, 0x9F, 0x7C, 0x71, 0xC7, 0x0F, 0x00,
  0x00, 0xF0, 0x08, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0x7F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF,
  0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x03, 0x00, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7E, 0xE7, 0xC2, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC1, 0x7F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFE,
  0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x1F, 0x78, 0xFB, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x78, 0xFB, 0xCF,
  0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x00, 0x00, 0x80, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0x71,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF9, 0xFF, 0xE1, 0xFF, 0x87, 0xDF, 0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFE, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3E, 0xFF, 0xFF, 0xFE,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0xFF, 0x8F, 0xBC, 0x7D, 0xE7, 0xCF,
  0x3E, 0x7B, 0xE3, 0xDF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x8F, 0x3C, 0x79, 0xF3, 0xCF, 0x9E, 0x3E, 0xF1, 0xF7, 0x8F, 0xFC, 0x3E,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3B, 0xFD, 0xDE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xCF, 0xF7, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xCF, 0x8F, 0xF3, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0xBF, 0xDE, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0xC0, 0x03, 0x00, 0x3F, 0xC0, 0xFF, 0xE1, 0xFF, 0xC7, 0xEF,
  0xCF, 0x8F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xBE, 0x1F, 0x3E, 0x3E, 0x7F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0x3F,
  0xE3, 0xFC, 0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xC1, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xC0,
  0xFF, 0xE1, 0xFF, 0xC7, 0xEF, 0xCF, 0x8F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0x9E, 0x1F,
  0x3E, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0xFF, 0x87, 0xFE, 0x3F, 0xF9,
  0xFF, 0xCF, 0x3E, 0x78, 0xF3, 0xC7, 0x9E, 0x7C, 0xFF, 0xE7, 0xFE, 0x3F,
  0xE1, 0xFF, 0x0F, 0x7C, 0x79, 0xE3, 0xCF, 0x9E, 0x7C, 0xF1, 0xF7, 0x8F,
  0xBC, 0x3E, 0x06, 0x07, 0xFD, 0xFF, 0x7F, 0xEF, 0xFD, 0xF0, 0xBE, 0x07,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x1E,
  0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFE, 0x3F, 0x80, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE7,
  0xC7, 0xCF, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0x7B,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE1, 0xF7, 0x87, 0x87,
  0x9E, 0x3E, 0x1E, 0x78, 0xFC, 0xF9, 0xE3, 0xF3, 0xE7, 0xCF, 0xCF, 0x9F,
  0x3F, 0x3C, 0x3D, 0xFC, 0xF0, 0xF7, 0xFB, 0xC3, 0xDD, 0xFF, 0x0F, 0x73,
  0xFC, 0x3D, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x00, 0xF8, 0xF9, 0xF3,
  0xE7, 0xCF, 0x0F, 0x7C, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F,
  0x3C, 0x7C, 0xF9, 0xE1, 0xEF, 0x87, 0xC0, 0xF8, 0x7D, 0xE1, 0xF7, 0xC7,
  0x8F, 0x3E, 0x3C, 0xF0, 0xFB, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFE, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x1E, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xEF, 0x0F, 0x3C, 0x3C, 0x78,
  0xF1, 0xE7, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0xF8, 0xF0, 0xF0, 0xE0, 0x3F, 0x8F, 0xF9, 0xFF, 0x99, 0xF0, 0x1E, 0x03,
  0xDF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF,
  0x38, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFB, 0xCF,
  0xFE, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF9, 0xFF, 0xDF, 0xFF, 0xEF, 0xFE, 0xF3, 0xC0, 0x1F, 0x8F, 0xF7,
  0xFD, 0xFE, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0xF7,
  0x7F, 0xDF, 0xF1, 0xF8, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x3D, 0xF7, 0xEF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF9, 0xFF, 0xBF, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0,
  0x1F, 0x07, 0xF9, 0xFF, 0x7C, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xC0, 0x7C, 0x37, 0xFE, 0xFF, 0xC7, 0xF0, 0x06, 0x0F, 0xCF,
  0xE7, 0xF3, 0xC1, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x3C, 0xF7, 0xEF,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF9, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x3D, 0xF0, 0x1F, 0x01, 0xF6, 0x3E,
  0x7F, 0xE7, 0xFC, 0x7F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFB, 0xCF, 0x7E, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xF0, 0x77, 0xFF, 0xF2, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1C, 0x7C, 0xF9, 0xF0, 0x80, 0x0F, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xDF,
  0xFD, 0xFB, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE3, 0xFF, 0x3E, 0xF9, 0xF7, 0xDF, 0x3E, 0xF1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x1F, 0xFC, 0xFB, 0xE7, 0xCF, 0xBE, 0x7D, 0xF1, 0xEF,
  0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF3, 0xC7, 0x9E, 0xFD, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x3F, 0xF3, 0xE3, 0xFE, 0x7C, 0x7F, 0xCF, 0x8F, 0xF9,
  0xF1, 0xFF, 0x3E, 0x3F, 0xE7, 0xC7, 0xFC, 0xF8, 0xFF, 0x9F, 0x1F, 0xF3,
  0xE3, 0xFE, 0x7C, 0x78, 0xF3, 0xCF, 0x7E, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0xF9, 0xFF, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF9, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xF3, 0xCF, 0x7E, 0xFF, 0xEF, 0xDF, 0xF9, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFB,
  0xCF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0xF7,
  0xEF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF7, 0xEF, 0x3D, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x3F,
  0x7F, 0xFF, 0xDE, 0x6F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xFD,
  0xFF, 0xFF, 0xFB, 0xF8, 0x1C, 0x0E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFE, 0x7F, 0x3F, 0x8F,
  0xC0, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0,
  0xF8, 0x7F, 0xC7, 0xDE, 0x3E, 0xF1, 0xE7, 0xCF, 0x1E, 0xF8, 0xF7, 0x87,
  0xBC, 0x3D, 0xE0, 0xEF, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x00, 0xF9, 0xF9, 0xFF, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79,
  0xF9, 0xE7, 0xBF, 0xBE, 0x7F, 0xFF, 0xC3, 0xFB, 0xFC, 0x3F, 0x9F, 0xC3,
  0xF9, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x80, 0xF8, 0xFB, 0xEF, 0x9F, 0x78, 0x7B, 0xC3, 0xFE, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7B, 0xC7, 0xDF,
  0x3C, 0xFB, 0xE3, 0xE0, 0xF8, 0x7F, 0xC7, 0xDE, 0x3E, 0xF1, 0xE7, 0xCF,
  0x1E, 0xF8, 0xF7, 0x87, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x82, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xC0, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x07, 0x83, 0xE0, 0xF0,
  0x7C, 0x1E, 0x0F, 0x87, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x87,
  0xC7, 0xE3, 0xF1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x9F, 0xCF,
  0x87, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFC, 0x7E,
  0x1F, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x7C, 0x3E, 0x1F, 0x87, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xF0, 0xF9, 0xFC, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0x80, 0x00, 0x7C, 0x1F,
  0xFF, 0xFF, 0xFD, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Black27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 11, 7, 13, 1, -19 },
  { 23, 13, 19, 15, 1, -19 },
  { 54, 11, 23, 13, 1, -21 },
  { 86, 21, 20, 23, 1, -20 },
  { 139, 17, 20, 17, 1, -20 },
  { 182, 5, 7, 7, 1, -19 },
  { 187, 8, 24, 9, 1, -20 },
  { 211, 8, 24, 9, 0, -20 },
  { 235, 13, 13, 13, 0, -21 },
  { 257, 12, 13, 14, 1, -16 },
  { 277, 5, 8, 7, 1, -4 },
  { 282, 7, 4, 9, 1, -9 },
  { 286, 5, 5, 7, 1, -5 },
  { 290, 11, 20, 11, 0, -20 },
  { 318, 11, 20, 13, 1, -20 },
  { 346, 10, 19, 13, 1, -19 },
  { 370, 11, 20, 13, 1, -20 },
  { 398, 11, 20, 13, 1, -20 },
  { 426, 13, 19, 13, 0, -19 },
  { 457, 11, 19, 13, 1, -19 },
  { 484, 12, 20, 13, 1, -20 },
  { 514, 11, 19, 13, 1, -19 },
  { 541, 12, 20, 13, 1, -20 },
  { 571, 12, 20, 13, 1, -20 },
  { 601, 5, 15, 8, 1, -15 },
  { 611, 5, 19, 8, 1, -15 },
  { 623, 12, 13, 14, 1, -16 },
  { 643, 12, 9, 14, 1, -14 },
  { 657, 12, 13, 14, 1, -16 },
  { 677, 10, 20, 11, 0, -20 },
  { 702, 19, 22, 21, 1, -20 },
  { 755, 16, 19, 16, 0, -19 },
  { 793, 12, 19, 15, 2, -19 },
  { 822, 12, 20, 14, 1, -20 },
  { 852, 13, 19, 16, 2, -19 },
  { 883, 9, 19, 12, 2, -19 },
  { 905, 9, 19, 12, 2, -19 },
  { 927, 14, 20, 16, 1, -20 },
  { 962, 13, 19, 16, 2, -19 },
  { 993, 8, 19, 10, 1, -19 },
  { 1012, 8, 25, 8, -2, -19 },
  { 1037, 13, 19, 15, 2, -19 },
  { 1068, 9, 19, 12, 2, -19 },
  { 1090, 18, 19, 22, 2, -19 },
  { 1133, 14, 19, 18, 2, -19 },
  { 1167, 15, 20, 17, 1, -20 },
  { 1205, 11, 19, 14, 2, -19 },
  { 1232, 15, 25, 17, 1, -20 },
  { 1279, 13, 19, 15, 2, -19 },
  { 1310, 11, 20, 12, 1, -20 },
  { 1338, 12, 19, 12, 0, -19 },
  { 1367, 12, 19, 16, 2, -19 },
  { 1396, 15, 19, 15, 0, -19 },
  { 1432, 22, 19, 22, 0, -19 },
  { 1485, 14, 19, 14, 0, -19 },
  { 1519, 14, 19, 14, 0, -19 },
  { 1553, 11, 19, 13, 1, -19 },
  { 1580, 7, 25, 8, 1, -20 },
  { 1602, 11, 20, 11, 0, -20 },
  { 1630, 7, 25, 8, 0, -20 },
  { 1652, 14, 12, 15, 0, -19 },
  { 1673, 14, 3, 14, 0, 2 },
  { 1679, 7, 5, 9, 1, -21 },
  { 1684, 11, 15, 13, 1, -15 },
  { 1705, 12, 21, 14, 1, -21 },
  { 1737, 10, 15, 12, 1, -15 },
  { 1756, 12, 21, 14, 1, -21 },
  { 1788, 11, 15, 13, 1, -15 },
  { 1809, 9, 21, 9, 0, -21 },
  { 1833, 12, 21, 14, 1, -15 },
  { 1865, 12, 21, 14, 1, -21 },
  { 1897, 5, 21, 7, 1, -21 },
  { 1911, 7, 27, 7, -1, -21 },
  { 1935, 13, 21, 14, 1, -21 },
  { 1970, 5, 21, 7, 1, -21 },
  { 1984, 19, 15, 21, 1, -15 },
  { 2020, 12, 15, 14, 1, -15 },
  { 2043, 12, 15, 14, 1, -15 },
  { 2066, 12, 21, 14, 1, -15 },
  { 2098, 12, 21, 14, 1, -15 },
  { 2130, 9, 15, 10, 1, -15 },
  { 2147, 9, 15, 11, 1, -15 },
  { 2164, 9, 18, 10, 0, -18 },
  { 2185, 12, 15, 14, 1, -15 },
  { 2208, 13, 15, 13, 0, -15 },
  { 2233, 20, 15, 20, 0, -15 },
  { 2271, 13, 15, 13, 0, -15 },
  { 2296, 13, 21, 13, 0, -15 },
  { 2331, 10, 15, 11, 0, -15 },
  { 2350, 9, 25, 10, 0, -20 },
  { 2379, 4, 27, 11, 4, -21 },
  { 2393, 9, 25, 10, 1, -20 },
  { 2422, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Black27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK27PT7B_H_
