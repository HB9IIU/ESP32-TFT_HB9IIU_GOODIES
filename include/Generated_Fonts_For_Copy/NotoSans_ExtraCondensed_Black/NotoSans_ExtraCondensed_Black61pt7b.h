#ifndef _NOTOSANS_EXTRACONDENSED_BLACK61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xFE, 0x3F, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0x3F, 0xC0, 0xE0, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xF8, 0x7F,
  0xEF, 0xFC, 0x3F, 0xF7, 0xFE, 0x1F, 0xFB, 0xFF, 0x0F, 0xFD, 0xFF, 0x87,
  0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xF0,
  0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xF9, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFB, 0xE3,
  0xC7, 0xF9, 0xF0, 0x23, 0xFC, 0xF8, 0x01, 0xFE, 0x7C, 0x00, 0xFF, 0x3E,
  0x00, 0x7F, 0xDF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFB, 0xFC, 0x00, 0x7C, 0xFF,
  0x00, 0x3E, 0x7F, 0xE0, 0x1F, 0x3F, 0xB8, 0x0F, 0xBF, 0xDF, 0x87, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x7F,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0xE0, 0x1F,
  0xC3, 0xF8, 0xFF, 0x0F, 0xFC, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xFF, 0x03,
  0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xCF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xE7, 0xFF, 0xFE,
  0x0F, 0xFF, 0x0F, 0xE3, 0xFC, 0xFF, 0x03, 0xFF, 0x07, 0xF1, 0xFE, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xDF,
  0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF1, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x0F, 0xE0, 0x21, 0xC1,
  0xFC, 0x1C, 0x7E, 0x3F, 0x8F, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xF7,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF8, 0x3F, 0xE7, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF,
  0x9F, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFB, 0xFF,
  0x1F, 0xCF, 0xFC, 0x3E, 0x3F, 0xF0, 0x70, 0xFF, 0xC0, 0x83, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xE0,
  0xFF, 0xE1, 0xF0, 0x1F, 0xF8, 0x38, 0x07, 0xFE, 0x0C, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0x80, 0xFF,
  0xE1, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xF0, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xF0, 0x07, 0xFB,
  0xFF, 0x00, 0xFF, 0x3F, 0xF0, 0x0F, 0xF3, 0xFF, 0x01, 0xFE, 0x3F, 0xF0,
  0x1F, 0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xC3, 0xFF, 0x07, 0xF8,
  0x3F, 0xF0, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x88, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1C, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x40, 0x03, 0xFF, 0xB8, 0x01, 0xFF, 0xDF, 0x83, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x7F, 0xCF, 0xFC, 0x3F, 0xF7, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x1F, 0xFD, 0xFF, 0xCF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x05, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0x9F, 0xF8, 0x7F,
  0xE7, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xBF, 0xF8, 0x7F, 0xEF, 0xFE, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0x7F, 0xCF, 0xFF, 0xDF, 0xF1, 0xFF, 0xE7, 0xFC, 0x3F,
  0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x3F, 0x8F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x8F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x38, 0x00, 0x1F,
  0xC3, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F,
  0xE3, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3E, 0x07,
  0xFF, 0x18, 0x03, 0xFF, 0x10, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xFF, 0xE3, 0xF8, 0x7F, 0x83, 0xFF, 0xFC,
  0x7F, 0x8F, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE,
  0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x1F, 0xC3, 0xF9, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0xBF, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xE1, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x3F,
  0x83, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F,
  0xFF, 0xC3, 0xF8, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x7F,
  0x0F, 0xE0, 0xFF, 0x0F, 0xEF, 0xE1, 0xFE, 0x1F, 0xE1, 0xFD, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0x3F, 0x83, 0xF8, 0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFB, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x03,
  0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xC0, 0xF0, 0xFF, 0xF0, 0x06, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x08, 0xFF,
  0xF8, 0x07, 0x0F, 0xFF, 0xC7, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x7F, 0xFF,
  0x3F, 0xF0, 0x7F, 0xFD, 0xFF, 0x81, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xF7,
  0xFE, 0x0F, 0xFF, 0x3F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xE0, 0xFF, 0xF8, 0x00, 0x41, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xFB, 0xFF,
  0x80, 0x3F, 0xF7, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC,
  0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xF8,
  0x0F, 0xFC, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0,
  0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xDF, 0xFC, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x1F, 0xFC,
  0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0xFF,
  0xFB, 0xFC, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0x87, 0xFB, 0xFF, 0xFF, 0x9F,
  0xE3, 0xFC, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x3F,
  0xCF, 0xFF, 0xFE, 0x7F, 0xCF, 0xF3, 0xFF, 0xFF, 0x8F, 0xF7, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFD, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF,
  0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF,
  0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0x87, 0xFD, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F,
  0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x02, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0x1F, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xCF,
  0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF,
  0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0xFC, 0xFF, 0xE0, 0x1C, 0xFF, 0xC0, 0x0C, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x68,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFE,
  0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0x87, 0xFE, 0x07, 0xFE,
  0x1F, 0xDF, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xEF, 0xE1, 0xFF, 0x80, 0xFF,
  0x87, 0xF7, 0xF8, 0xFF, 0xC0, 0x7F, 0xE7, 0xFB, 0xFC, 0x7F, 0xC0, 0x3F,
  0xF3, 0xFD, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFE, 0x7F, 0x3F, 0xF0, 0x07,
  0xFC, 0xFF, 0x3F, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0x9F, 0xCF, 0xFC, 0x01,
  0xFF, 0x3F, 0x8F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xC7, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xE3, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0x03, 0xFF, 0x82, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFD,
  0xFE, 0x7F, 0xFC, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F, 0xF8, 0x1F, 0xC0, 0x60,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0x81, 0xFF, 0x9F,
  0xF8, 0x3F, 0xF7, 0xFF, 0x87, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F,
  0xFD, 0xFF, 0xC1, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFD, 0xFF, 0xE3, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0x0F, 0xF9, 0xFF, 0xC1, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xF8, 0x78, 0xFF, 0xE0, 0x31, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x02, 0x7F, 0xE0, 0x0C, 0xFF, 0xE0, 0x79, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x3F, 0x87, 0xFE, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0xDF,
  0xF8, 0xFF, 0xFB, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F, 0xFE, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7,
  0xFE, 0x0F, 0xFE, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0x9F, 0xF0, 0x7F, 0xE3, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xEF, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x1F, 0xF8,
  0x01, 0xC7, 0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0x9F,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0xFF, 0xEF,
  0xFE, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0x0F,
  0xFE, 0x7F, 0xE0, 0x7F, 0x8F, 0xFC, 0x01, 0x81, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x98, 0x00, 0x3F, 0xF3, 0xE0,
  0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC7, 0xF8, 0x3F, 0xF3, 0xFF, 0x8F, 0xF9, 0xFF, 0xF3, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFB,
  0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF,
  0x80, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xF1, 0xFF, 0xF1, 0xFF, 0xF3,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xFF, 0x8F, 0xF1, 0xFF, 0xF3, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0xCF, 0xFE,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFF, 0x83, 0xFE, 0x7F, 0xF8, 0x7F, 0xCF, 0xFF, 0x8F, 0xFB,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF1, 0xFF, 0xDF, 0xFC, 0x1F, 0xFB, 0xFF, 0x83, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFE, 0x3F,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0xF0, 0xFF, 0xCF, 0xFC,
  0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1,
  0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0xFF, 0xEF, 0xFE, 0x3F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F,
  0x8F, 0xFC, 0x01, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0x81, 0xC7, 0xFC, 0x02, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x18, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x60,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFB, 0xFC, 0x7F, 0xFC, 0xFF, 0x1F, 0xFE, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0,
  0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x87, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0x9F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xE7, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xFC, 0x1F,
  0xF8, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0x07, 0xFC,
  0x3F, 0xF1, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xEF, 0xE3, 0xFF, 0x0F,
  0xFC, 0x7F, 0x7F, 0x1F, 0xF0, 0x3F, 0xE3, 0xFB, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xDF, 0xC7, 0xFC, 0x0F, 0xF9, 0xFE, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF,
  0xF7, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xBF, 0xDF, 0xF0, 0x0F, 0xFB, 0xF9,
  0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xCF, 0xF7, 0xFC, 0x03, 0xFE, 0xFE, 0x3F,
  0xBF, 0xE0, 0x1F, 0xF7, 0xF1, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0x8F, 0xEF,
  0xF0, 0x03, 0xFF, 0xFC, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xC3, 0xFB, 0xFC,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x7F,
  0xE0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFE,
  0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00,
  0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F,
  0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x04, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x2F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xD8, 0x01, 0xFF, 0xF2, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 45, 17, 3, -44 },
  { 63, 25, 16, 30, 2, -44 },
  { 113, 31, 44, 33, 1, -44 },
  { 284, 25, 50, 30, 3, -46 },
  { 441, 49, 44, 51, 1, -44 },
  { 711, 39, 45, 39, 1, -44 },
  { 931, 11, 16, 15, 2, -44 },
  { 953, 17, 55, 20, 3, -45 },
  { 1070, 17, 55, 20, 0, -45 },
  { 1187, 27, 28, 29, 1, -47 },
  { 1282, 26, 29, 31, 2, -36 },
  { 1377, 12, 17, 17, 2, -9 },
  { 1403, 16, 9, 20, 2, -21 },
  { 1421, 11, 12, 17, 3, -11 },
  { 1438, 26, 45, 26, 0, -44 },
  { 1585, 26, 45, 30, 2, -44 },
  { 1732, 22, 44, 30, 2, -44 },
  { 1853, 26, 44, 30, 1, -44 },
  { 1996, 26, 45, 30, 2, -44 },
  { 2143, 28, 44, 30, 1, -44 },
  { 2297, 25, 45, 30, 3, -44 },
  { 2438, 26, 45, 30, 2, -44 },
  { 2585, 26, 44, 30, 2, -44 },
  { 2728, 26, 45, 30, 2, -44 },
  { 2875, 26, 45, 30, 2, -44 },
  { 3022, 11, 35, 17, 3, -34 },
  { 3071, 12, 42, 17, 2, -34 },
  { 3134, 26, 30, 31, 2, -37 },
  { 3232, 26, 21, 31, 2, -32 },
  { 3301, 27, 30, 31, 2, -37 },
  { 3403, 24, 45, 25, 0, -44 },
  { 3538, 43, 49, 47, 2, -44 },
  { 3802, 35, 44, 35, 0, -44 },
  { 3995, 27, 44, 34, 4, -44 },
  { 4144, 27, 45, 31, 2, -44 },
  { 4296, 29, 44, 36, 4, -44 },
  { 4456, 21, 44, 27, 4, -44 },
  { 4572, 20, 44, 27, 4, -44 },
  { 4682, 31, 45, 36, 2, -44 },
  { 4857, 30, 44, 37, 4, -44 },
  { 5022, 18, 44, 22, 2, -44 },
  { 5121, 18, 58, 18, -4, -44 },
  { 5252, 30, 44, 34, 4, -44 },
  { 5417, 21, 44, 26, 4, -44 },
  { 5533, 42, 44, 49, 4, -44 },
  { 5764, 32, 44, 40, 4, -44 },
  { 5940, 34, 45, 38, 2, -44 },
  { 6132, 26, 44, 32, 4, -44 },
  { 6275, 34, 54, 38, 2, -44 },
  { 6505, 30, 44, 33, 4, -44 },
  { 6670, 24, 45, 28, 2, -44 },
  { 6805, 26, 44, 28, 1, -44 },
  { 6948, 30, 45, 36, 3, -44 },
  { 7117, 34, 44, 34, 0, -44 },
  { 7304, 49, 44, 49, 0, -44 },
  { 7574, 32, 44, 32, 0, -44 },
  { 7750, 32, 44, 32, 0, -44 },
  { 7926, 26, 44, 29, 1, -44 },
  { 8069, 15, 55, 18, 2, -45 },
  { 8173, 26, 45, 26, 0, -44 },
  { 8320, 15, 55, 18, 1, -45 },
  { 8424, 33, 29, 33, 0, -44 },
  { 8544, 31, 7, 31, 0, 4 },
  { 8572, 16, 10, 21, 2, -47 },
  { 8592, 25, 35, 30, 2, -34 },
  { 8702, 27, 47, 32, 3, -46 },
  { 8861, 23, 35, 26, 2, -34 },
  { 8962, 27, 47, 32, 2, -46 },
  { 9121, 26, 35, 29, 2, -34 },
  { 9235, 21, 47, 20, 0, -47 },
  { 9359, 27, 49, 32, 2, -34 },
  { 9525, 26, 46, 32, 3, -46 },
  { 9675, 10, 47, 16, 3, -47 },
  { 9734, 15, 62, 16, -2, -47 },
  { 9851, 29, 46, 32, 3, -46 },
  { 10018, 10, 46, 16, 3, -46 },
  { 10076, 42, 34, 48, 3, -34 },
  { 10255, 26, 34, 32, 3, -34 },
  { 10366, 27, 35, 31, 2, -34 },
  { 10485, 27, 49, 32, 3, -34 },
  { 10651, 27, 49, 32, 2, -34 },
  { 10817, 19, 34, 23, 3, -34 },
  { 10898, 21, 35, 24, 2, -34 },
  { 10990, 21, 42, 22, 0, -41 },
  { 11101, 26, 35, 32, 3, -34 },
  { 11215, 30, 34, 30, 0, -34 },
  { 11343, 45, 34, 45, 0, -34 },
  { 11535, 29, 34, 29, 0, -34 },
  { 11659, 30, 49, 30, 0, -34 },
  { 11843, 22, 34, 24, 1, -34 },
  { 11937, 20, 54, 22, 1, -44 },
  { 12072, 9, 61, 26, 8, -47 },
  { 12141, 21, 54, 22, 1, -44 },
  { 12283, 27, 11, 31, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Black61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK61PT7B_H_
