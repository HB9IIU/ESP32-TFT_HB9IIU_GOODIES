#ifndef _NOTOSANS_EXTRACONDENSED_BLACK34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xFF, 0xDF, 0xBE, 0xFC, 0xFF,
  0xF3, 0xF7, 0xCF, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F,
  0x7C, 0x78, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF3,
  0xC0, 0x79, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3,
  0xCF, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xE6, 0xF7, 0x07, 0xB8, 0x3F, 0xC1, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x3B, 0xC1, 0xDF,
  0x0E, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x1F, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x1E, 0x01, 0xFE, 0x07,
  0xC0, 0x3F, 0xE0, 0xF0, 0x0F, 0xBC, 0x1E, 0x01, 0xE7, 0x87, 0x80, 0x3C,
  0xF8, 0xF0, 0x07, 0x9F, 0x3C, 0x00, 0xF3, 0xE7, 0x80, 0x1E, 0x7C, 0xF0,
  0x03, 0xCF, 0x3C, 0x78, 0x7D, 0xE7, 0x9F, 0xC7, 0xFD, 0xE7, 0xF8, 0xFF,
  0x3C, 0xFF, 0x8F, 0xCF, 0xBE, 0xF0, 0x61, 0xE7, 0x9F, 0x00, 0x3C, 0xF3,
  0xE0, 0x0F, 0x1E, 0x7C, 0x01, 0xE3, 0xCF, 0x80, 0x7C, 0x79, 0xF0, 0x0F,
  0x0F, 0x3C, 0x01, 0xE0, 0xFF, 0x80, 0x78, 0x1F, 0xF0, 0x0F, 0x01, 0xFC,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE7, 0xE3,
  0xFE, 0x3F, 0x3F, 0xF9, 0xF9, 0xFF, 0xFF, 0x9F, 0xBF, 0xFC, 0xFC, 0xFF,
  0xE7, 0xC7, 0xFE, 0x3E, 0x1F, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xE3, 0xF8, 0xFF, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x43, 0xC2, 0x7B, 0xCE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7E, 0x1E,
  0x38, 0x0C, 0x30, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0xFD, 0xFB,
  0xE7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7B, 0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x00, 0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC7, 0xFF, 0x8F, 0xDF,
  0x9F, 0x3F, 0x3E, 0x3E, 0xFC, 0x7D, 0xF8, 0xFB, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7D, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE7, 0xE7, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF9, 0xCF, 0xC4, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9,
  0xE7, 0xF7, 0x0F, 0xC8, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0xFF, 0x8F, 0xFF, 0xBF, 0xFE, 0x7F, 0xFD, 0xE7, 0xF2, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xF0, 0xF7, 0xE3, 0xEF, 0xC7, 0x9F, 0x9F, 0x3F, 0x3C, 0x7E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF0, 0x00, 0x70, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xFB, 0xE3, 0xEF, 0xE7, 0xDF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFB, 0xE3, 0xE7, 0xFF, 0xCF, 0xFF,
  0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7E, 0xFC, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0x7E, 0xFC, 0x7D, 0xF8,
  0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xE0, 0x03, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F,
  0xDF, 0xBF, 0x1F, 0x7E, 0x3E, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x9F, 0xBE, 0x1E, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC6, 0x7F, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F,
  0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E,
  0x7C, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xC0, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFE, 0x03, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xBC, 0xFC, 0x83, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8,
  0x1E, 0x00, 0x3C, 0x3C, 0x08, 0x3E, 0x3C, 0x7F, 0xDE, 0x78, 0xFF, 0xDE,
  0x79, 0xFF, 0xCF, 0x79, 0xE3, 0xCF, 0xF1, 0xE3, 0xCF, 0xF3, 0xC7, 0x8F,
  0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8E,
  0xF1, 0xE7, 0xDE, 0x79, 0xFF, 0xFC, 0x78, 0xFD, 0xFC, 0x78, 0x78, 0xF8,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x60, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0xBF, 0x00, 0xF9, 0xF0, 0x1F, 0x9F,
  0x01, 0xF9, 0xF0, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0xFC, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0xFE, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xF3, 0x9F, 0xC1, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x33, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE3, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0xBF, 0x3F,
  0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00,
  0x30, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xF3,
  0xC7, 0xF0, 0x11, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0x7E,
  0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xFC, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF9, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE1, 0xC0, 0xFC, 0x1F, 0xFE,
  0x1F, 0xBF, 0x1F, 0xDF, 0x8F, 0xCF, 0xCF, 0xE7, 0xE7, 0xE3, 0xF7, 0xF1,
  0xFB, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF7, 0x8F, 0xFF, 0xEF, 0x9E, 0xFF, 0xDF, 0x3D, 0xFF, 0x9E,
  0xFB, 0xFF, 0x3D, 0xE7, 0xFE, 0x7F, 0xCF, 0xFC, 0xFF, 0x9F, 0xF8, 0xFF,
  0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x87, 0xE3,
  0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xBE, 0x7F, 0xEF, 0xDF,
  0xF9, 0xF7, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0x7F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F,
  0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xDF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0x7F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x8F, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x7F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0xCF, 0xC7, 0xE7, 0xE3,
  0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0x03, 0x00, 0x7F, 0xC3, 0xFF, 0xDF, 0xFE,
  0x7F, 0xFB, 0xFF, 0xEF, 0xC1, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF8, 0x7E, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xFF, 0x80, 0xFD,
  0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0x83, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xFB, 0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x7E, 0x7C,
  0x1F, 0x87, 0xE7, 0xC1, 0xF8, 0x7E, 0x7C, 0x3F, 0x87, 0xE7, 0xE3, 0xF8,
  0x7C, 0x7E, 0x3F, 0x87, 0xC7, 0xE3, 0xFC, 0xFC, 0x3E, 0x3F, 0xCF, 0xC3,
  0xE7, 0xFC, 0xFC, 0x3E, 0x7F, 0xCF, 0xC3, 0xF7, 0xBC, 0xF8, 0x3F, 0x7B,
  0xCF, 0x81, 0xF7, 0xBF, 0xF8, 0x1F, 0x79, 0xFF, 0x81, 0xFF, 0x9F, 0xF8,
  0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC,
  0xF8, 0x3F, 0x7E, 0x07, 0xDF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xF7, 0xE0, 0xFC,
  0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F,
  0xDF, 0x87, 0xE7, 0xE1, 0xF8, 0xF8, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1,
  0xF3, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xBE, 0x07, 0xCF, 0x81, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x0F, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0xFC,
  0x83, 0xF0, 0x07, 0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xF3, 0xE3,
  0xC0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0xF8, 0xFB, 0xF9, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xC7, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0xC7, 0xDF, 0x9F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9,
  0xE7, 0xE0, 0x0F, 0xE0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0x0B,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x05, 0xF9, 0xCF, 0xFE, 0x3F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0x9F,
  0x3F, 0xBE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7,
  0xEF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x3E, 0x7C, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xFD, 0xF1, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x17, 0xE1,
  0xDF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x3F, 0xE3, 0xF0, 0x3F, 0x03, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x3E, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF,
  0x8F, 0xDF, 0xBF, 0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7C, 0xF8, 0x01,
  0xF0, 0x07, 0xE8, 0x0F, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xE0,
  0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x7C, 0xFB, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFE, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0xFC, 0xF8,
  0xFC, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF9, 0xF8, 0xF8, 0xFC, 0xF8,
  0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF1, 0xF0, 0xF9, 0xE7, 0xF7, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xCF, 0xFF, 0x1F, 0x1F, 0xFC, 0x3E, 0x1F, 0xF8,
  0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87,
  0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C,
  0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xF8, 0xF1, 0xF3, 0xCF, 0xEF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xEF, 0x8F, 0xDF, 0x9F, 0xBF, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0xF1, 0xE1, 0xF7, 0xF3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xBF, 0xBF, 0x7F, 0xFE, 0xFF,
  0xF9, 0xF7, 0xF3, 0xE7, 0xC7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x3E, 0x7F, 0x7C,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xDF, 0xBF,
  0xBF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7C, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xF1,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x1F,
  0x87, 0xFE, 0xFF, 0xEF, 0xFE, 0xF9, 0xCF, 0x84, 0xFC, 0x0F, 0xF0, 0x7F,
  0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xF7, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0xFC, 0x1F,
  0xFE, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0xFC, 0x3F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xDF, 0x1F, 0xC7,
  0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xF3, 0xF7, 0xBC, 0xF9, 0xFB, 0xDE,
  0xFC, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7, 0xBE, 0x1F, 0x7B, 0xDF, 0x0F, 0xBD,
  0xEF, 0x83, 0xDE, 0xF7, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x7E,
  0x7E, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x9F, 0x0F, 0xCF,
  0xC7, 0xE7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF8, 0x7E, 0xFC, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x3F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F,
  0xC7, 0xF8, 0x3F, 0x1F, 0xE3, 0xFC, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x38, 0x00,
  0x7E, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Black34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 24, 9, 1, -24 },
  { 22, 14, 9, 16, 1, -24 },
  { 38, 17, 24, 19, 1, -24 },
  { 89, 13, 28, 17, 2, -26 },
  { 135, 27, 25, 29, 1, -25 },
  { 220, 21, 25, 22, 1, -25 },
  { 286, 6, 9, 9, 1, -24 },
  { 293, 10, 30, 11, 1, -25 },
  { 331, 10, 30, 11, 0, -25 },
  { 369, 16, 15, 16, 0, -26 },
  { 399, 15, 16, 17, 1, -20 },
  { 429, 7, 10, 9, 1, -5 },
  { 438, 9, 5, 11, 1, -12 },
  { 444, 6, 6, 9, 2, -6 },
  { 449, 14, 25, 14, 0, -25 },
  { 493, 15, 25, 17, 1, -25 },
  { 540, 13, 24, 17, 1, -24 },
  { 579, 14, 25, 17, 1, -25 },
  { 623, 14, 25, 17, 1, -25 },
  { 667, 15, 24, 17, 1, -24 },
  { 712, 13, 24, 17, 2, -24 },
  { 751, 15, 25, 17, 1, -25 },
  { 798, 15, 24, 17, 1, -24 },
  { 843, 15, 25, 17, 1, -25 },
  { 890, 15, 25, 17, 1, -25 },
  { 937, 6, 19, 10, 2, -19 },
  { 952, 7, 24, 10, 1, -19 },
  { 973, 15, 17, 17, 1, -21 },
  { 1005, 15, 12, 17, 1, -18 },
  { 1028, 15, 17, 17, 1, -21 },
  { 1060, 13, 25, 14, 0, -25 },
  { 1101, 24, 28, 26, 1, -25 },
  { 1185, 20, 24, 20, 0, -24 },
  { 1245, 16, 24, 19, 2, -24 },
  { 1293, 15, 25, 17, 1, -25 },
  { 1340, 17, 24, 20, 2, -24 },
  { 1391, 12, 24, 15, 2, -24 },
  { 1427, 12, 24, 15, 2, -24 },
  { 1463, 18, 25, 20, 1, -25 },
  { 1520, 17, 24, 21, 2, -24 },
  { 1571, 10, 24, 12, 1, -24 },
  { 1601, 10, 32, 10, -2, -24 },
  { 1641, 17, 24, 19, 2, -24 },
  { 1692, 12, 24, 15, 2, -24 },
  { 1728, 23, 24, 27, 2, -24 },
  { 1797, 18, 24, 22, 2, -24 },
  { 1851, 19, 25, 21, 1, -25 },
  { 1911, 15, 24, 18, 2, -24 },
  { 1956, 19, 31, 21, 1, -25 },
  { 2030, 17, 24, 19, 2, -24 },
  { 2081, 14, 25, 15, 1, -25 },
  { 2125, 14, 24, 16, 1, -24 },
  { 2167, 16, 24, 20, 2, -24 },
  { 2215, 19, 24, 19, 0, -24 },
  { 2272, 28, 24, 28, 0, -24 },
  { 2356, 18, 24, 18, 0, -24 },
  { 2410, 18, 24, 18, 0, -24 },
  { 2464, 14, 24, 16, 1, -24 },
  { 2506, 9, 31, 10, 1, -25 },
  { 2541, 14, 25, 14, 0, -25 },
  { 2585, 8, 31, 10, 1, -25 },
  { 2616, 18, 16, 18, 0, -24 },
  { 2652, 17, 4, 17, 0, 2 },
  { 2661, 9, 5, 12, 1, -26 },
  { 2667, 14, 19, 17, 1, -19 },
  { 2701, 15, 26, 18, 2, -26 },
  { 2750, 13, 19, 15, 1, -19 },
  { 2781, 15, 26, 18, 1, -26 },
  { 2830, 14, 19, 16, 1, -19 },
  { 2864, 12, 26, 11, 0, -26 },
  { 2903, 15, 27, 18, 1, -19 },
  { 2954, 14, 26, 18, 2, -26 },
  { 3000, 5, 26, 9, 2, -26 },
  { 3017, 8, 34, 9, -1, -26 },
  { 3051, 16, 26, 18, 2, -26 },
  { 3103, 5, 26, 9, 2, -26 },
  { 3120, 23, 19, 27, 2, -19 },
  { 3175, 14, 19, 18, 2, -19 },
  { 3209, 15, 19, 18, 1, -19 },
  { 3245, 15, 27, 18, 2, -19 },
  { 3296, 15, 27, 18, 1, -19 },
  { 3347, 10, 19, 13, 2, -19 },
  { 3371, 12, 19, 13, 1, -19 },
  { 3400, 11, 23, 12, 0, -23 },
  { 3432, 14, 19, 18, 2, -19 },
  { 3466, 17, 19, 17, 0, -19 },
  { 3507, 25, 19, 25, 0, -19 },
  { 3567, 16, 19, 16, 0, -19 },
  { 3605, 17, 27, 17, 0, -19 },
  { 3663, 12, 19, 14, 1, -19 },
  { 3692, 12, 31, 12, 0, -25 },
  { 3739, 5, 34, 14, 5, -26 },
  { 3761, 11, 31, 12, 1, -25 },
  { 3804, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Black34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK34PT7B_H_
