#ifndef _NOTOSANS_EXTRACONDENSED_BLACK14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF0, 0xF0, 0xDE, 0xF7, 0xB0, 0x36, 0x68, 0xD3, 0xF3, 0xC5,
  0xBF, 0xB6, 0x68, 0xD0, 0x23, 0xBF, 0xDE, 0x78, 0xE7, 0xBF, 0xC8, 0x40,
  0x71, 0x8B, 0x63, 0x6C, 0x6D, 0x05, 0xEE, 0xEB, 0xC3, 0x68, 0x6D, 0x09,
  0xE3, 0x1C, 0x3C, 0x3E, 0x1B, 0x0F, 0x83, 0xBB, 0xFB, 0xBD, 0xDE, 0x7F,
  0x3F, 0xC0, 0xFF, 0x76, 0xCC, 0xCC, 0xCC, 0xCC, 0x67, 0xE6, 0x63, 0x33,
  0x33, 0x36, 0x6E, 0x30, 0xCF, 0xFF, 0x79, 0xB2, 0x80, 0x10, 0x23, 0xFF,
  0xF1, 0x02, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x61, 0x86, 0x30, 0xC6,
  0x18, 0x63, 0x00, 0x39, 0xF6, 0xDB, 0xEF, 0xB6, 0xDB, 0x7C, 0xE0, 0x3B,
  0xFF, 0xFB, 0x9C, 0xE7, 0x39, 0xC0, 0x7B, 0xF4, 0xC3, 0x1C, 0xE3, 0x18,
  0xFF, 0xF0, 0xF9, 0xF4, 0xC3, 0x38, 0xF0, 0xE3, 0xFF, 0xE0, 0x1C, 0x38,
  0xF1, 0x67, 0xCB, 0xBF, 0xFF, 0x1C, 0x38, 0xFF, 0xF1, 0xCF, 0xDC, 0x73,
  0xFF, 0x80, 0x3C, 0xF9, 0x83, 0x47, 0xDD, 0xBB, 0xB6, 0x7C, 0x70, 0xFF,
  0xC6, 0x33, 0x19, 0xCC, 0x67, 0x00, 0x7C, 0xF9, 0xB3, 0x63, 0x8F, 0x9B,
  0x77, 0x7C, 0xF8, 0x39, 0xFE, 0xFB, 0x6D, 0xF2, 0xC3, 0x7D, 0xE0, 0xFC,
  0x0F, 0x6D, 0x80, 0x1B, 0x78, 0x02, 0x1C, 0xFF, 0x8F, 0x07, 0xC1, 0x80,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0xC3, 0xE0, 0xF1, 0xFF, 0x30, 0x00,
  0xFF, 0xE6, 0x33, 0x99, 0x00, 0x73, 0x80, 0x1F, 0x0C, 0x66, 0x6D, 0x3D,
  0x5B, 0x76, 0xDD, 0xBD, 0x77, 0x60, 0x0C, 0x41, 0xF0, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7E, 0x66, 0x7E, 0x7E, 0xE7, 0xE7, 0xFB, 0xFC, 0xF3, 0xFB, 0xFC,
  0xF3, 0xFF, 0xE0, 0x7F, 0xEE, 0x70, 0xC3, 0x0C, 0x39, 0xF9, 0xE0, 0xF9,
  0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0xE6, 0xFD, 0xF0, 0xFF, 0xF1, 0x8F, 0x7B,
  0x18, 0xFF, 0xC0, 0xFF, 0xF1, 0x8F, 0x7B, 0x18, 0xC6, 0x00, 0x7D, 0xFB,
  0x86, 0x0D, 0xFB, 0xF3, 0xF7, 0xFE, 0xFC, 0xCF, 0x9F, 0x3E, 0x7F, 0xFF,
  0xF3, 0xE7, 0xCF, 0x9C, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x77, 0xC0, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xCF, 0x9B, 0x76, 0xCF, 0x1F, 0x36,
  0x6E, 0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE3, 0xF1,
  0xFC, 0xFE, 0xFF, 0x7E, 0xFF, 0x77, 0xBB, 0xDD, 0xE6, 0xC0, 0xE7, 0xCF,
  0xDF, 0xBF, 0xFB, 0xF7, 0xE7, 0xCF, 0x9C, 0x7D, 0xFB, 0x3E, 0x3C, 0x78,
  0xF1, 0xE7, 0xFC, 0xF8, 0xFB, 0xFD, 0xF3, 0xDF, 0xEF, 0x30, 0xC3, 0x00,
  0x7D, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE7, 0xFC, 0xF8, 0x70, 0x70, 0xF9,
  0xFB, 0x76, 0xEF, 0xDF, 0x36, 0x6E, 0xDD, 0x9C, 0x7D, 0xFE, 0x58, 0x78,
  0xF1, 0xE3, 0xFF, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0, 0xE7, 0xE6, 0x66, 0x66,
  0x6E, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0xC6, 0x7D, 0xCF, 0xB9, 0xB7, 0x76,
  0xEC, 0xD7, 0x9E, 0xF3, 0xDE, 0x3B, 0xC7, 0x38, 0xEE, 0xD9, 0xB1, 0xE3,
  0x87, 0x0F, 0x36, 0x6F, 0xCC, 0xE6, 0xDD, 0xB3, 0xE3, 0xC7, 0x0E, 0x1C,
  0x38, 0x70, 0xFF, 0xF1, 0xC6, 0x38, 0xC7, 0x18, 0xFF, 0xF0, 0xFB, 0x6D,
  0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0x18, 0x70, 0xF1, 0xE6, 0xCC, 0xF1, 0x80,
  0xFF, 0xFC, 0xCC, 0x80, 0x39, 0xF4, 0xDF, 0x7F, 0xBF, 0xDF, 0xC3, 0x0C,
  0x36, 0xFB, 0x7C, 0xF3, 0xDF, 0xFF, 0x80, 0x3D, 0xE6, 0x78, 0xE1, 0x87,
  0xCE, 0x0E, 0x1C, 0x39, 0xF7, 0xED, 0xFB, 0xF7, 0x6E, 0xFD, 0xD8, 0x39,
  0xF6, 0xFF, 0xFD, 0x87, 0xCF, 0x33, 0xD8, 0xEF, 0x31, 0x8C, 0x63, 0x18,
  0x36, 0xFD, 0xBF, 0x7E, 0xED, 0xDF, 0xBF, 0x0E, 0xF9, 0xF0, 0xC3, 0x0C,
  0x3E, 0xFB, 0x7D, 0xF7, 0xDF, 0x7D, 0xC0, 0xFB, 0xFF, 0xFC, 0x33, 0x23,
  0x33, 0x33, 0x33, 0x33, 0xFF, 0xC3, 0x0C, 0x33, 0xDB, 0x6F, 0x3E, 0xDB,
  0x7C, 0xC0, 0xFF, 0xFF, 0xFC, 0xFB, 0xFF, 0xF7, 0x7B, 0xBD, 0xDE, 0xEF,
  0x77, 0xBB, 0xFB, 0xED, 0xF7, 0xDF, 0x7D, 0xF7, 0x38, 0xF9, 0xBF, 0x7E,
  0xED, 0xDF, 0x1E, 0xFB, 0xED, 0xF3, 0xCF, 0x7F, 0xFE, 0xC3, 0x0C, 0x00,
  0x36, 0xFD, 0xBF, 0x7E, 0xED, 0xDF, 0xBF, 0x0E, 0x1C, 0x38, 0xDF, 0xFC,
  0xCC, 0xCC, 0x7F, 0xFA, 0xE7, 0x8F, 0xFF, 0x63, 0xFE, 0xC6, 0x31, 0x8F,
  0x78, 0xDF, 0x7D, 0xF7, 0xDF, 0x7F, 0xFB, 0xCF, 0xD9, 0xB3, 0x66, 0xC7,
  0x0E, 0x1C, 0xCE, 0xFB, 0xB7, 0xED, 0xFF, 0x7F, 0x9E, 0xE7, 0x38, 0xCE,
  0xEE, 0xD9, 0xE1, 0xC3, 0x8F, 0x1B, 0x77, 0xCF, 0xD9, 0xB3, 0x66, 0xC7,
  0x0E, 0x1C, 0x38, 0xE1, 0xC0, 0xFF, 0xCE, 0x67, 0x33, 0xFF, 0x39, 0xCC,
  0x63, 0x73, 0x8E, 0x31, 0x8C, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x1C,
  0xE7, 0x1C, 0xEE, 0x73, 0x9D, 0xC0, 0xFF, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Black14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 7, 10, 8, 0, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 11, 10, 12, 0, -10 },
  { 38, 9, 10, 9, 0, -10 },
  { 50, 2, 4, 4, 1, -10 },
  { 51, 4, 12, 5, 1, -10 },
  { 57, 4, 12, 5, 0, -10 },
  { 63, 6, 7, 7, 0, -11 },
  { 69, 7, 6, 7, 0, -8 },
  { 75, 3, 4, 4, 0, -2 },
  { 77, 4, 2, 5, 0, -5 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 6, 10, 6, 0, -10 },
  { 87, 6, 10, 7, 0, -10 },
  { 95, 5, 10, 7, 1, -10 },
  { 102, 6, 10, 7, 0, -10 },
  { 110, 6, 10, 7, 0, -10 },
  { 118, 7, 10, 7, 0, -10 },
  { 127, 5, 10, 7, 1, -10 },
  { 134, 7, 10, 7, 0, -10 },
  { 143, 5, 10, 7, 1, -10 },
  { 150, 7, 10, 7, 0, -10 },
  { 159, 6, 10, 7, 0, -10 },
  { 167, 2, 8, 4, 1, -8 },
  { 169, 3, 10, 4, 0, -8 },
  { 173, 7, 7, 7, 0, -9 },
  { 180, 7, 5, 7, 0, -7 },
  { 185, 7, 7, 7, 0, -9 },
  { 192, 5, 10, 6, 0, -10 },
  { 199, 10, 11, 11, 0, -10 },
  { 213, 8, 10, 8, 0, -10 },
  { 223, 6, 10, 8, 1, -10 },
  { 231, 6, 10, 7, 1, -10 },
  { 239, 7, 10, 8, 1, -10 },
  { 248, 5, 10, 6, 1, -10 },
  { 255, 5, 10, 6, 1, -10 },
  { 262, 7, 10, 8, 1, -10 },
  { 271, 7, 10, 9, 1, -10 },
  { 280, 5, 10, 5, 0, -10 },
  { 287, 4, 13, 4, -1, -10 },
  { 294, 7, 10, 8, 1, -10 },
  { 303, 5, 10, 6, 1, -10 },
  { 310, 9, 10, 11, 1, -10 },
  { 322, 7, 10, 9, 1, -10 },
  { 331, 7, 10, 9, 1, -10 },
  { 340, 6, 10, 7, 1, -10 },
  { 348, 7, 12, 9, 1, -10 },
  { 359, 7, 10, 8, 1, -10 },
  { 368, 6, 10, 6, 0, -10 },
  { 376, 6, 10, 6, 0, -10 },
  { 384, 6, 10, 8, 1, -10 },
  { 392, 8, 10, 8, 0, -10 },
  { 402, 11, 10, 11, 0, -10 },
  { 416, 7, 10, 7, 0, -10 },
  { 425, 7, 10, 7, 0, -10 },
  { 434, 6, 10, 7, 0, -10 },
  { 442, 3, 12, 4, 1, -10 },
  { 447, 6, 10, 6, 0, -10 },
  { 455, 4, 12, 4, 0, -10 },
  { 461, 7, 7, 8, 0, -10 },
  { 468, 7, 2, 7, 0, 1 },
  { 470, 3, 3, 5, 1, -11 },
  { 472, 6, 8, 7, 0, -8 },
  { 478, 6, 11, 7, 1, -11 },
  { 487, 6, 8, 6, 0, -8 },
  { 493, 7, 11, 7, 0, -11 },
  { 503, 6, 8, 7, 0, -8 },
  { 509, 5, 11, 5, 0, -11 },
  { 516, 7, 11, 7, 0, -8 },
  { 526, 6, 11, 7, 1, -11 },
  { 535, 2, 11, 4, 1, -11 },
  { 538, 4, 14, 4, -1, -11 },
  { 545, 6, 11, 7, 1, -11 },
  { 554, 2, 11, 4, 1, -11 },
  { 557, 9, 8, 11, 1, -8 },
  { 566, 6, 8, 7, 1, -8 },
  { 572, 7, 8, 7, 0, -8 },
  { 579, 6, 11, 7, 1, -8 },
  { 588, 7, 11, 7, 0, -8 },
  { 598, 4, 8, 5, 1, -8 },
  { 602, 5, 8, 6, 0, -8 },
  { 607, 5, 9, 5, 0, -9 },
  { 613, 6, 8, 7, 1, -8 },
  { 619, 7, 8, 7, 0, -8 },
  { 626, 10, 8, 10, 0, -8 },
  { 636, 7, 8, 7, 0, -8 },
  { 643, 7, 11, 7, 0, -8 },
  { 653, 5, 8, 6, 0, -8 },
  { 658, 5, 12, 5, 0, -10 },
  { 666, 2, 14, 6, 2, -11 },
  { 670, 5, 12, 5, 0, -10 },
  { 678, 7, 2, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Black14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK14PT7B_H_
