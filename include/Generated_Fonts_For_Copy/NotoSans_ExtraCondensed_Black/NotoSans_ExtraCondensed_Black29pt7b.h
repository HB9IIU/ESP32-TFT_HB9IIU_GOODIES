#ifndef _NOTOSANS_EXTRACONDENSED_BLACK29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x7B, 0xEF, 0xFE, 0x78, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9,
  0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x0F, 0x78, 0x39, 0xE0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x79, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x78, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x1E, 0x70, 0x7B, 0xC0, 0x06, 0x00, 0x60, 0x1F, 0xC3, 0xFF,
  0x7F, 0xE7, 0xFE, 0xF6, 0x2F, 0x60, 0xFE, 0x07, 0xE0, 0x7F, 0x83, 0xFE,
  0x0F, 0xE0, 0x7F, 0x06, 0xF0, 0x6F, 0xC6, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC,
  0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x03, 0x80, 0xFC, 0x0F, 0x03,
  0xFC, 0x1C, 0x07, 0xB8, 0x78, 0x0E, 0x78, 0xE0, 0x1C, 0xF3, 0xC0, 0x39,
  0xE7, 0x80, 0x73, 0xCE, 0x00, 0xE7, 0xBC, 0xF1, 0xEE, 0x73, 0xF3, 0xFD,
  0xEF, 0xF3, 0xFB, 0xDF, 0xE3, 0xC7, 0x39, 0xC0, 0x1E, 0xF3, 0xC0, 0x39,
  0xE7, 0x80, 0xF3, 0xCF, 0x01, 0xC3, 0x9E, 0x03, 0x87, 0x38, 0x0F, 0x0F,
  0xF0, 0x1C, 0x0F, 0xC0, 0x78, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xDF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xF3, 0xE3, 0xFC, 0xF9, 0xFF, 0x3C, 0xFF, 0xFF,
  0x3E, 0xFF, 0xCF, 0x9F, 0xE3, 0xE3, 0xF8, 0xF8, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xDF, 0xC0, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E,
  0x1F, 0x0F, 0xF8, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x78, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xEF, 0x77, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0xE1, 0xFF, 0x9F, 0x3C, 0x39, 0xC0,
  0x84, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7D, 0xE7, 0x9E, 0xFB, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xEF, 0xFF, 0x78, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x83, 0xFC, 0x3F, 0xE7, 0xFE, 0x7D, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9,
  0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0x79,
  0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x8F,
  0xF3, 0xFE, 0xFF, 0xFF, 0xFB, 0xDF, 0x33, 0xE2, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x1F, 0x07, 0xFC, 0xFF, 0xEF, 0xFE, 0xF3, 0xE6, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xFC, 0xFF,
  0xE7, 0xFE, 0x63, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x3F, 0xE3, 0xF8, 0x3F,
  0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x83, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xF7, 0xC3, 0xDF, 0x1E,
  0x7C, 0x79, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0x80, 0x78, 0x07, 0xB0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F,
  0x80, 0x07, 0xE0, 0xFE, 0x3F, 0xE3, 0xFE, 0x7E, 0x07, 0xC0, 0x78, 0x0F,
  0xB8, 0xFF, 0xEF, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0xF9,
  0xFF, 0x9F, 0x79, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0xC7, 0xFE, 0x7F,
  0xFF, 0x9F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F,
  0xC0, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x8F, 0xF9, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x7E, 0xF3, 0xCF, 0x01, 0xF0,
  0x1F, 0x03, 0xE7, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F, 0x00, 0x79, 0xFF, 0xDF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xDE, 0x79, 0xFF, 0xDF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE7, 0x9E, 0xFB, 0xEF, 0x3C,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x9F, 0xE3, 0xFC, 0x1F,
  0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x06, 0x00, 0x3E, 0x01, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x07, 0xF9, 0xFF, 0x3F, 0xE1,
  0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x0F, 0xFB, 0xFF, 0xBF,
  0xF7, 0x3E, 0x83, 0xC0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x81,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x3C, 0x01,
  0xE7, 0x87, 0x8E, 0x71, 0xFE, 0xF7, 0x3F, 0xE7, 0xF3, 0xDE, 0x7F, 0x79,
  0xE7, 0xE7, 0x9E, 0x7E, 0x79, 0xE7, 0xE7, 0x9E, 0x7E, 0x79, 0xE7, 0xE7,
  0x9E, 0xFF, 0x3F, 0xFE, 0x73, 0xF7, 0xC7, 0x84, 0x38, 0x78, 0x00, 0x03,
  0xE0, 0x10, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xC7, 0x83,
  0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x3E, 0x0F,
  0x9F, 0x07, 0xDF, 0x83, 0xEF, 0x81, 0xF8, 0xFF, 0x07, 0xFF, 0x3F, 0xFD,
  0xFF, 0xEF, 0xBF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3E, 0xFF, 0xF7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xEF, 0x9F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF,
  0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xC7, 0xFE, 0x7F,
  0xE7, 0xF3, 0x3E, 0x09, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x13, 0xFF, 0x8F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC,
  0xFF, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0x3E, 0xFB, 0xFB, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xF1, 0x8F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x07, 0xFF, 0x0F, 0xBE, 0x1F, 0x7E, 0x3E, 0x7F, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3F, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7D, 0xFE, 0xFF, 0x7F, 0x3F, 0x04,
  0x00, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3, 0xEF, 0xCF,
  0xBE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3,
  0xEF, 0x8F, 0xBE, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xEF, 0x8F, 0xBE, 0x3F,
  0xF8, 0x7C, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xF7, 0x9F, 0xFF, 0x79, 0xDF, 0xF7, 0xBD, 0xFF, 0x7B, 0xDF, 0xF3,
  0xFD, 0xFF, 0x3F, 0x9F, 0xF3, 0xF9, 0xFF, 0x3F, 0x9F, 0xF1, 0xF9, 0xFF,
  0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF0, 0xF1, 0xF0, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xEF, 0x3F, 0xDF, 0x7F, 0x9E, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E,
  0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFE, 0x0F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7C, 0x3E,
  0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x3F, 0xFC, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xBE, 0x3E, 0xF8,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0xBE, 0x3E, 0xF8, 0xFC, 0x1F, 0x87, 0xFD,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0xBE, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xE1, 0xFC, 0x00,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78,
  0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x7F,
  0xE1, 0xF0, 0xFB, 0xC3, 0xE1, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xC7, 0xDF,
  0x1F, 0x8F, 0x3E, 0x7F, 0x3E, 0x3C, 0xFE, 0x7C, 0x79, 0xFC, 0xF8, 0xF3,
  0xBD, 0xF1, 0xF7, 0x7B, 0xC3, 0xFE, 0xF7, 0x83, 0xFC, 0xFF, 0x07, 0xF9,
  0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF1, 0xE7, 0xC3, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0x7C, 0x3E, 0xF8, 0x7D, 0xF1, 0xF1, 0xF3, 0xE3, 0xEF, 0x83, 0xE0, 0xF8,
  0x3F, 0xF8, 0x7D, 0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xFF, 0xFF, 0xFC, 0xF0, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0xFF, 0xFF, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x3C, 0x7C, 0x3C, 0x78, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x3F, 0xC7, 0xFE, 0x7F, 0xE3,
  0xBF, 0x21, 0xF0, 0x1F, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF,
  0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xF7, 0xCF, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x9F, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x79, 0xF0, 0x1F, 0xC7, 0xFD, 0xFF, 0x3F,
  0xEF, 0x85, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x17,
  0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0xFB, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x9F, 0x3C, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0xDF, 0xF8,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x81, 0x7E,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3E, 0x0F,
  0x87, 0xFB, 0xFE, 0xFF, 0xBF, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x3E, 0x7B, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE7, 0xDF, 0x00,
  0xF8, 0x07, 0x98, 0x7C, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xEF, 0x9F, 0xFE,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7C, 0x23,
  0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x08, 0x3C, 0xF9, 0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7F, 0xFF, 0xFF, 0xDF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xFE, 0x3E, 0xF8, 0xF3, 0xE7, 0xCF, 0xBE,
  0x3E, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFD, 0xF3, 0xE7,
  0xCF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFF, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xE3,
  0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xFF, 0x8F,
  0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8,
  0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF,
  0x8F, 0x8F, 0xF3, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF7,
  0xFF, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0xF3, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0x7C, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x7B, 0xFF, 0xDF,
  0xFE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE7, 0xDF, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF3, 0xFC,
  0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x3F, 0x9F, 0xFF, 0xFB, 0xEE, 0xF0,
  0xBF, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF0, 0x7E, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFB, 0xFC, 0x1E, 0x07, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0x3F, 0xC7,
  0xF1, 0xFC, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFD, 0xE7, 0xCF, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x9F, 0x1E, 0x7C,
  0xF8, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xF8, 0xF8, 0xFF, 0xC7,
  0xE7, 0xDE, 0x3F, 0x3E, 0xF3, 0xF9, 0xE7, 0xDF, 0xCF, 0x3E, 0xEE, 0x79,
  0xF7, 0x77, 0xC7, 0xBB, 0xFE, 0x3D, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0xFC, 0xF9, 0xF3, 0xE7, 0xDF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xFC, 0x3D,
  0xF1, 0xF3, 0xC7, 0xCF, 0xBE, 0x3F, 0xF8, 0x7D, 0xE1, 0xF7, 0xC7, 0x9F,
  0x1E, 0x7C, 0xF8, 0xF3, 0xE3, 0xEF, 0x0F, 0xBC, 0x1F, 0xF0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC3, 0xF0,
  0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF3, 0xF8,
  0xFC, 0x3F, 0x0F, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x3F,
  0x1F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xF1, 0xF8,
  0xFC, 0xFE, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE3, 0xF1, 0xF8,
  0xF8, 0x78, 0x00, 0x7C, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x40,
  0x20,
};

const GFXglyph NotoSans_ExtraCondensed_Black29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 12, 8, 14, 1, -21 },
  { 29, 14, 21, 16, 1, -21 },
  { 66, 12, 24, 14, 1, -22 },
  { 102, 23, 21, 24, 1, -21 },
  { 163, 18, 21, 19, 1, -21 },
  { 211, 5, 8, 7, 1, -21 },
  { 216, 8, 26, 9, 1, -21 },
  { 242, 8, 26, 9, 0, -21 },
  { 268, 13, 13, 14, 0, -22 },
  { 290, 13, 14, 15, 1, -17 },
  { 313, 6, 8, 8, 1, -4 },
  { 319, 8, 4, 9, 1, -10 },
  { 323, 6, 5, 8, 1, -5 },
  { 327, 12, 21, 12, 0, -21 },
  { 359, 12, 21, 14, 1, -21 },
  { 391, 11, 21, 14, 1, -21 },
  { 420, 12, 21, 14, 1, -21 },
  { 452, 12, 21, 14, 1, -21 },
  { 484, 14, 21, 14, 0, -21 },
  { 521, 12, 21, 14, 1, -21 },
  { 553, 12, 21, 14, 1, -21 },
  { 585, 12, 21, 14, 1, -21 },
  { 617, 12, 21, 14, 1, -21 },
  { 649, 12, 21, 14, 1, -21 },
  { 681, 6, 16, 8, 1, -16 },
  { 693, 6, 20, 8, 1, -16 },
  { 708, 13, 15, 15, 1, -18 },
  { 733, 13, 10, 15, 1, -15 },
  { 750, 13, 15, 15, 1, -18 },
  { 775, 11, 21, 12, 0, -21 },
  { 804, 20, 23, 22, 1, -21 },
  { 862, 17, 21, 17, 0, -21 },
  { 907, 13, 21, 16, 2, -21 },
  { 942, 13, 21, 15, 1, -21 },
  { 977, 14, 21, 17, 2, -21 },
  { 1014, 10, 21, 13, 2, -21 },
  { 1041, 10, 21, 13, 2, -21 },
  { 1068, 15, 21, 17, 1, -21 },
  { 1108, 14, 21, 18, 2, -21 },
  { 1145, 9, 21, 10, 1, -21 },
  { 1169, 9, 28, 8, -2, -21 },
  { 1201, 14, 21, 16, 2, -21 },
  { 1238, 10, 21, 12, 2, -21 },
  { 1265, 20, 21, 23, 2, -21 },
  { 1318, 15, 21, 19, 2, -21 },
  { 1358, 16, 21, 18, 1, -21 },
  { 1400, 12, 21, 15, 2, -21 },
  { 1432, 16, 26, 18, 1, -21 },
  { 1484, 14, 21, 16, 2, -21 },
  { 1521, 11, 21, 13, 1, -21 },
  { 1550, 13, 21, 13, 0, -21 },
  { 1585, 13, 21, 17, 2, -21 },
  { 1620, 16, 21, 16, 0, -21 },
  { 1662, 23, 21, 23, 0, -21 },
  { 1723, 15, 21, 15, 0, -21 },
  { 1763, 15, 21, 15, 0, -21 },
  { 1803, 12, 21, 14, 1, -21 },
  { 1835, 7, 26, 9, 1, -21 },
  { 1858, 12, 21, 12, 0, -21 },
  { 1890, 7, 26, 9, 1, -21 },
  { 1913, 16, 14, 16, 0, -21 },
  { 1941, 15, 3, 15, 0, 2 },
  { 1947, 8, 4, 10, 1, -22 },
  { 1951, 12, 16, 14, 1, -16 },
  { 1975, 13, 22, 15, 1, -22 },
  { 2011, 11, 16, 13, 1, -16 },
  { 2033, 13, 22, 15, 1, -22 },
  { 2069, 12, 16, 14, 1, -16 },
  { 2093, 10, 22, 9, 0, -22 },
  { 2121, 13, 23, 15, 1, -16 },
  { 2159, 13, 22, 15, 1, -22 },
  { 2195, 5, 23, 8, 1, -23 },
  { 2210, 7, 30, 8, -1, -23 },
  { 2237, 14, 22, 15, 1, -22 },
  { 2276, 5, 22, 8, 1, -22 },
  { 2290, 20, 16, 23, 1, -16 },
  { 2330, 13, 16, 15, 1, -16 },
  { 2356, 13, 16, 15, 1, -16 },
  { 2382, 13, 23, 15, 1, -16 },
  { 2420, 13, 23, 15, 1, -16 },
  { 2458, 10, 16, 11, 1, -16 },
  { 2478, 10, 16, 11, 1, -16 },
  { 2498, 10, 19, 10, 0, -19 },
  { 2522, 13, 16, 15, 1, -16 },
  { 2548, 14, 16, 14, 0, -16 },
  { 2576, 21, 16, 21, 0, -16 },
  { 2618, 14, 16, 14, 0, -16 },
  { 2646, 14, 23, 14, 0, -16 },
  { 2687, 11, 16, 12, 0, -16 },
  { 2709, 10, 26, 11, 0, -21 },
  { 2742, 4, 29, 12, 4, -22 },
  { 2757, 9, 26, 11, 1, -21 },
  { 2787, 13, 6, 15, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Black29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK29PT7B_H_
