#ifndef _NOTOSANS_EXTRACONDENSED_BLACK9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x70, 0xFD, 0x77, 0xD5, 0xF5, 0x30, 0x27, 0xE6, 0x3B, 0x62,
  0x45, 0xD2, 0xA7, 0xB5, 0x63, 0xC9, 0x80, 0x21, 0xC5, 0x1B, 0xFB, 0x67,
  0xC0, 0xF0, 0x29, 0x6D, 0x93, 0x89, 0x26, 0x96, 0x6F, 0x6F, 0x2F, 0x22,
  0x70, 0xE0, 0x70, 0x12, 0x26, 0x44, 0xC0, 0x27, 0xDD, 0xDD, 0x70, 0x7F,
  0x33, 0x33, 0x2F, 0x33, 0x64, 0xF0, 0x2F, 0x36, 0x3B, 0xF0, 0x37, 0x7B,
  0xF3, 0x74, 0x73, 0xBF, 0x17, 0xCF, 0xDD, 0x70, 0xF3, 0x32, 0x66, 0x27,
  0xD6, 0xFD, 0x70, 0x27, 0xDF, 0x53, 0x60, 0xD1, 0xC0, 0xD0, 0x70, 0x3E,
  0x71, 0xF0, 0xF0, 0xC3, 0x68, 0x5C, 0xB4, 0x90, 0x10, 0xD9, 0x75, 0x5A,
  0xBF, 0x91, 0x1C, 0x72, 0x94, 0xFF, 0xEC, 0xEB, 0xEB, 0xBE, 0x27, 0x4C,
  0xC5, 0x70, 0xEB, 0xBB, 0xBE, 0xF3, 0xC9, 0xC0, 0xF3, 0x69, 0x00, 0x13,
  0xF1, 0xBD, 0xAD, 0xE0, 0xBB, 0xFB, 0xBB, 0xE9, 0x25, 0xC0, 0x24, 0x92,
  0x5F, 0xBE, 0xEE, 0xAB, 0x92, 0x49, 0xC0, 0xDF, 0x7D, 0xFF, 0xBE, 0xB0,
  0xDD, 0xFB, 0xBB, 0x23, 0xF3, 0x9C, 0xAD, 0xC0, 0xF6, 0xF9, 0x00, 0x23,
  0xF3, 0x9C, 0xAD, 0xC3, 0x18, 0xEA, 0xEE, 0xAB, 0x2F, 0xC6, 0x3B, 0xE0,
  0xF6, 0x66, 0x66, 0xDE, 0xF7, 0xB5, 0xB8, 0xDE, 0xD4, 0xA7, 0x38, 0xD3,
  0xBD, 0xFB, 0x76, 0xCD, 0x80, 0xD3, 0x98, 0xE7, 0x6C, 0xDA, 0x9C, 0x42,
  0x10, 0xF3, 0x64, 0xCF, 0xFF, 0x6D, 0xB7, 0xE0, 0x8C, 0x44, 0x22, 0x30,
  0xF5, 0x57, 0xC0, 0x23, 0x95, 0xB0, 0xF8, 0xC4, 0x71, 0xFD, 0xF0, 0xCC,
  0xFD, 0xDD, 0xF0, 0x7C, 0xCD, 0x70, 0x11, 0x7D, 0xDD, 0x70, 0x7D, 0xFC,
  0x70, 0x6B, 0xA4, 0x90, 0x7D, 0xDD, 0x71, 0xF0, 0xCC, 0xFD, 0xDD, 0xD0,
  0xDF, 0xFC, 0xDF, 0xFF, 0xC0, 0xC6, 0x37, 0xEF, 0x7B, 0x60, 0xFF, 0xFC,
  0xFD, 0xAF, 0x5E, 0xBD, 0x60, 0xFD, 0xDD, 0xD0, 0x7D, 0xDD, 0x70, 0xFD,
  0xDD, 0xFC, 0xC0, 0x7D, 0xDD, 0x71, 0x10, 0xFF, 0x6C, 0xF9, 0xDE, 0x5D,
  0x24, 0xC0, 0xDD, 0xDD, 0x70, 0xDD, 0x76, 0x60, 0xF7, 0xE9, 0xF3, 0x66,
  0xC0, 0xF7, 0x67, 0xF0, 0xDD, 0x76, 0x66, 0xC0, 0xE5, 0xEE, 0x2D, 0x2C,
  0x93, 0x20, 0xFF, 0xFF, 0xC0, 0x99, 0x22, 0x96, 0x80, 0xFB,
};

const GFXglyph NotoSans_ExtraCondensed_Black9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 7, 7, 8, 0, -7 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 2, 2, 2, 0, -6 },
  { 26, 3, 8, 3, 0, -7 },
  { 29, 3, 8, 3, 0, -7 },
  { 32, 4, 4, 4, 0, -7 },
  { 34, 4, 4, 5, 0, -5 },
  { 36, 2, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 2, 2, 0, -2 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 6, 4, 0, -6 },
  { 71, 4, 7, 4, 0, -7 },
  { 75, 4, 7, 4, 0, -7 },
  { 79, 2, 5, 3, 0, -5 },
  { 81, 2, 6, 3, 0, -5 },
  { 83, 4, 4, 5, 0, -5 },
  { 85, 4, 3, 5, 0, -5 },
  { 87, 4, 4, 5, 0, -5 },
  { 89, 3, 7, 4, 0, -7 },
  { 92, 7, 8, 7, 0, -7 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 4, 7, 5, 0, -7 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 5, 7, 5, 0, -7 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 3, 8, 3, -1, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 3, 6, 4, 1, -6 },
  { 139, 6, 6, 7, 1, -6 },
  { 144, 4, 6, 6, 1, -6 },
  { 147, 5, 7, 6, 0, -7 },
  { 152, 3, 6, 5, 1, -6 },
  { 155, 5, 9, 6, 0, -7 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 4, 7, 4, 0, -7 },
  { 168, 4, 6, 4, 0, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 5, 6, 5, 0, -6 },
  { 179, 7, 6, 7, 0, -6 },
  { 185, 5, 6, 5, 0, -6 },
  { 189, 5, 6, 5, 0, -6 },
  { 193, 4, 6, 4, 0, -6 },
  { 196, 3, 9, 3, 0, -7 },
  { 200, 4, 7, 4, 0, -7 },
  { 204, 2, 9, 3, 0, -7 },
  { 207, 5, 4, 5, 0, -6 },
  { 210, 5, 1, 5, 0, 1 },
  { 211, 3, 2, 3, 0, -7 },
  { 212, 4, 5, 4, 0, -5 },
  { 215, 4, 7, 5, 0, -7 },
  { 219, 4, 5, 4, 0, -5 },
  { 222, 4, 7, 5, 0, -7 },
  { 226, 4, 5, 4, 0, -5 },
  { 229, 3, 7, 3, 0, -7 },
  { 232, 4, 7, 5, 0, -5 },
  { 236, 4, 7, 5, 0, -7 },
  { 240, 2, 7, 2, 0, -7 },
  { 242, 2, 9, 2, 0, -7 },
  { 245, 5, 7, 5, 0, -7 },
  { 250, 2, 7, 2, 0, -7 },
  { 252, 7, 5, 7, 0, -5 },
  { 257, 4, 5, 5, 0, -5 },
  { 260, 4, 5, 5, 0, -5 },
  { 263, 4, 7, 5, 0, -5 },
  { 267, 4, 7, 5, 0, -5 },
  { 271, 3, 5, 3, 0, -5 },
  { 273, 3, 5, 4, 0, -5 },
  { 275, 3, 6, 3, 0, -6 },
  { 278, 4, 5, 5, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 7, 5, 7, 0, -5 },
  { 289, 4, 5, 4, 0, -5 },
  { 292, 4, 7, 4, 0, -5 },
  { 296, 3, 5, 4, 0, -5 },
  { 298, 3, 9, 3, 0, -7 },
  { 302, 2, 9, 4, 1, -7 },
  { 305, 3, 9, 3, 0, -7 },
  { 309, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Black9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK9PT7B_H_
