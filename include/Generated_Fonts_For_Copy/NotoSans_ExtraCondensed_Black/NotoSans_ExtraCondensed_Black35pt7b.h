#ifndef _NOTOSANS_EXTRACONDENSED_BLACK35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xEF, 0xFF, 0xBF, 0x7C, 0xFC,
  0xFF, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xE7, 0x80, 0xF9,
  0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xF8, 0x3F, 0xF9, 0xFF, 0xEF,
  0xFF, 0xBE, 0xDC, 0xF3, 0x0B, 0xCC, 0x0F, 0xB0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x37, 0xE0, 0xDF,
  0xC3, 0x7F, 0xEF, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE0, 0x7E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x3F, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0x00, 0x7F,
  0xC0, 0xF0, 0x0F, 0xFC, 0x1E, 0x00, 0xFB, 0xE1, 0xE0, 0x0F, 0x3E, 0x3E,
  0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE7, 0x80, 0x0F,
  0x3E, 0x78, 0x00, 0xF3, 0xEF, 0x9F, 0x8F, 0xFC, 0xF3, 0xFC, 0x7F, 0xCF,
  0x7F, 0xC7, 0xF9, 0xE7, 0xFE, 0x1F, 0x1E, 0x79, 0xE0, 0x03, 0xE7, 0x9E,
  0x00, 0x3C, 0xF9, 0xE0, 0x07, 0xCF, 0x9F, 0x00, 0x78, 0xF9, 0xF0, 0x07,
  0x87, 0x9E, 0x00, 0xF0, 0x79, 0xE0, 0x0F, 0x07, 0xFE, 0x01, 0xF0, 0x3F,
  0xE0, 0x1E, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x7E, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF,
  0xBF, 0x3F, 0x7F, 0xFC, 0xFC, 0xFF, 0xE3, 0xF1, 0xFF, 0x8F, 0xC3, 0xFC,
  0x3F, 0x0F, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF3, 0xFC, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C,
  0x07, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1,
  0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x73, 0xC6, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0x3E, 0x7C,
  0x0E, 0x38, 0x04, 0x10, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x7E, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0xCF, 0x9F, 0x1F, 0xBE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7E, 0xF8, 0xFD, 0xF1, 0xFB, 0xF3, 0xE7, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xFF, 0x7D, 0xF9, 0xEF, 0xC6, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFD, 0xC3, 0xF2, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xC4, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x61, 0xFB, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFB, 0xF3, 0xF7, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xEF, 0xEF,
  0x8F, 0xDF, 0x1F, 0xBF, 0x3E, 0x7E, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF,
  0x81, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xE7, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x1F,
  0xF0, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xDF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF7, 0xF7,
  0xFF, 0xEF, 0xFF, 0xCF, 0xEF, 0x9F, 0xDF, 0x0E, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80,
  0x33, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF,
  0xFF, 0xFF, 0xDE, 0x18, 0xF9, 0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBF, 0x7C,
  0xF8, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x9F, 0xF8, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0,
  0x3F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x7F, 0xF9, 0x83, 0xF4, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xF8, 0x1F, 0x81, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x7E, 0x7C,
  0xF8, 0xFF, 0x9E, 0x78, 0xFF, 0xCF, 0x3C, 0xF9, 0xE7, 0x9E, 0x78, 0xF1,
  0xFE, 0x3C, 0x78, 0xFF, 0x3E, 0x3C, 0x7F, 0x9F, 0x1E, 0x3F, 0xCF, 0x8F,
  0x1D, 0xE7, 0xC7, 0x9E, 0xF1, 0xE7, 0xCF, 0x78, 0xFB, 0xEF, 0x9E, 0x7F,
  0xFF, 0x8F, 0x1F, 0xDF, 0x87, 0xC7, 0x87, 0x81, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x60, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x05, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xFD, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x81, 0xF9, 0xF8,
  0x1F, 0x9F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xF0, 0xFF, 0xE0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFC, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03,
  0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x06, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFC, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xE7, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0x9F, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xE0,
  0x47, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xF7, 0xF0, 0xFD, 0xFC, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x7F,
  0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xF8, 0x00, 0xFC, 0x1F, 0xFF, 0x07, 0xEF,
  0xC3, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xC3, 0xF7,
  0xF0, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0,
  0xFE, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xC3, 0xFF,
  0xFB, 0xE3, 0xDF, 0xFF, 0xE7, 0xDF, 0xFF, 0xE7, 0xDF, 0xFD, 0xE7, 0xBF,
  0xFD, 0xF7, 0xBF, 0xFD, 0xFF, 0xBF, 0xFD, 0xFF, 0xBF, 0xFC, 0xFF, 0x3F,
  0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3C, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xEF, 0x9F, 0xFD, 0xFB, 0xFF, 0xDF, 0x7F, 0xFB, 0xFF, 0xFF, 0x3E, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFE, 0x1F, 0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0x81, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE,
  0x1F, 0x9F, 0x83, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0,
  0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xE7, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x3F,
  0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xF0, 0xFD,
  0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0xCF, 0xC7, 0xE7, 0xE3, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFE, 0xFF, 0xFB, 0xF8, 0xEF, 0xC0, 0xBF, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF9, 0xF8, 0x1F, 0x9F, 0x01, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xF0,
  0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x0F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF7, 0xC1, 0xF8,
  0x3F, 0x7E, 0x1F, 0x83, 0xF7, 0xE1, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7,
  0xE3, 0xFC, 0x7E, 0x3E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC, 0x7E, 0x3F, 0x3F,
  0xC7, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7D, 0xEF, 0xC1, 0xF7, 0xDE, 0xFC,
  0x1F, 0x79, 0xEF, 0xC1, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7,
  0x9F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x9F, 0x87, 0xE7, 0xE3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x07, 0xDF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x0F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7F, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F,
  0xCF, 0xC1, 0xF3, 0xF0, 0x7E, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x01, 0xC0, 0x7F, 0xE1, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC2, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x1F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7D, 0xFE,
  0xF9, 0xF9, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x70, 0xF9, 0xF9, 0xF7, 0xF3, 0xFF, 0xF7,
  0xFF, 0xEF, 0xEF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFD, 0xF7, 0xF3, 0xE7, 0xC0, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F,
  0xF7, 0xFF, 0x3F, 0x19, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x2F, 0xFF, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0E, 0x3F, 0x1F, 0xBF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x7F, 0x7E,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0x9F, 0x03, 0x80, 0x3F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF, 0x8F, 0xBF, 0x0F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F,
  0x01, 0x3F, 0x0E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x03,
  0xC0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x7F,
  0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x9F, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF,
  0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xBF, 0x1F, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x40, 0x7E, 0x7D, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x70, 0xFB, 0xF9, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xF8, 0xFB, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80,
  0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x7E,
  0xF8, 0xFC, 0xF8, 0xFC, 0xF9, 0xF8, 0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFD, 0xF8, 0xF8, 0xFC,
  0xF8, 0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x70, 0xF3, 0xF9, 0xFC, 0xFF, 0xFD, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F,
  0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F,
  0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F,
  0xF8, 0x7E, 0x3F, 0x00, 0xC1, 0xE7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xDF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xF0, 0x01, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3E, 0x7E,
  0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xE1, 0xF3,
  0xF3, 0xEF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xEF, 0xE7, 0xCF, 0x8F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0x06, 0x00, 0x1F, 0x9F, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xBF, 0x1F, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFE,
  0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xCF, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0x86, 0xFC,
  0x0F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFE, 0xFF, 0x7C, 0xFC, 0xF8, 0xFC, 0x1F, 0xBE, 0x0F, 0xDF,
  0x87, 0xCF, 0xC7, 0xE7, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7E, 0xFC,
  0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x7F, 0x0F, 0xDF, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0xF9, 0xF1, 0xFE,
  0x7E, 0x7E, 0x7F, 0x9F, 0x9F, 0x9F, 0xE7, 0xC3, 0xEF, 0xF9, 0xF0, 0xFB,
  0xDE, 0x7C, 0x3E, 0xF7, 0xDF, 0x0F, 0xBD, 0xFF, 0xC3, 0xEF, 0x3F, 0xE0,
  0x7B, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0xFE, 0x3F, 0x7E, 0x7E, 0x3E, 0x7E, 0x3F, 0x7E, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xBE, 0x0F, 0xDF, 0x87, 0xCF, 0xC7,
  0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xFC, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F,
  0xBE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0xC3,
  0xF8, 0x3F, 0x1F, 0xE3, 0xFC, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xF8, 0x3C, 0x00, 0x1C,
  0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x80,
  0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Black35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 25, 9, 1, -25 },
  { 23, 15, 9, 17, 1, -25 },
  { 40, 18, 25, 19, 1, -25 },
  { 97, 14, 29, 17, 2, -27 },
  { 148, 28, 25, 29, 1, -25 },
  { 236, 22, 25, 23, 1, -25 },
  { 305, 6, 9, 9, 1, -25 },
  { 312, 10, 32, 11, 1, -26 },
  { 352, 10, 32, 11, 0, -26 },
  { 392, 16, 16, 17, 0, -27 },
  { 424, 15, 17, 18, 1, -21 },
  { 456, 7, 10, 10, 1, -5 },
  { 465, 9, 5, 11, 1, -12 },
  { 471, 6, 6, 10, 2, -6 },
  { 476, 15, 25, 15, 0, -25 },
  { 523, 15, 25, 17, 1, -25 },
  { 570, 13, 25, 17, 1, -25 },
  { 611, 14, 25, 17, 1, -25 },
  { 655, 15, 25, 17, 1, -25 },
  { 702, 16, 25, 17, 1, -25 },
  { 752, 14, 25, 17, 2, -25 },
  { 796, 15, 25, 17, 1, -25 },
  { 843, 15, 25, 17, 1, -25 },
  { 890, 15, 25, 17, 1, -25 },
  { 937, 15, 25, 17, 1, -25 },
  { 984, 6, 20, 10, 2, -20 },
  { 999, 7, 25, 10, 1, -20 },
  { 1021, 15, 17, 18, 1, -21 },
  { 1053, 15, 13, 18, 1, -19 },
  { 1078, 15, 17, 18, 1, -21 },
  { 1110, 14, 25, 14, 0, -25 },
  { 1154, 25, 28, 27, 1, -25 },
  { 1242, 20, 25, 20, 0, -25 },
  { 1305, 16, 25, 20, 2, -25 },
  { 1355, 16, 25, 18, 1, -25 },
  { 1405, 17, 25, 21, 2, -25 },
  { 1459, 12, 25, 16, 2, -25 },
  { 1497, 12, 25, 15, 2, -25 },
  { 1535, 18, 25, 21, 1, -25 },
  { 1592, 17, 25, 21, 2, -25 },
  { 1646, 11, 25, 12, 1, -25 },
  { 1681, 10, 33, 10, -2, -25 },
  { 1723, 18, 25, 19, 2, -25 },
  { 1780, 13, 25, 15, 2, -25 },
  { 1821, 24, 25, 28, 2, -25 },
  { 1896, 19, 25, 23, 2, -25 },
  { 1956, 19, 25, 22, 1, -25 },
  { 2016, 15, 25, 18, 2, -25 },
  { 2063, 19, 31, 22, 1, -25 },
  { 2137, 17, 25, 19, 2, -25 },
  { 2191, 14, 25, 16, 1, -25 },
  { 2235, 15, 25, 16, 1, -25 },
  { 2282, 17, 25, 21, 2, -25 },
  { 2336, 20, 25, 20, 0, -25 },
  { 2399, 28, 25, 28, 0, -25 },
  { 2487, 18, 25, 18, 0, -25 },
  { 2544, 18, 25, 18, 0, -25 },
  { 2601, 15, 25, 16, 1, -25 },
  { 2648, 9, 32, 11, 1, -26 },
  { 2684, 15, 25, 15, 0, -25 },
  { 2731, 8, 32, 11, 1, -26 },
  { 2763, 19, 17, 19, 0, -25 },
  { 2804, 18, 4, 18, 0, 2 },
  { 2813, 10, 6, 12, 1, -27 },
  { 2821, 15, 20, 17, 1, -20 },
  { 2859, 15, 27, 18, 2, -27 },
  { 2910, 13, 20, 15, 1, -20 },
  { 2943, 16, 27, 18, 1, -27 },
  { 2997, 15, 20, 17, 1, -20 },
  { 3035, 12, 27, 11, 0, -27 },
  { 3076, 16, 28, 18, 1, -20 },
  { 3132, 15, 27, 19, 2, -27 },
  { 3183, 6, 27, 9, 2, -27 },
  { 3204, 9, 35, 9, -1, -27 },
  { 3244, 16, 27, 18, 2, -27 },
  { 3298, 5, 27, 9, 2, -27 },
  { 3315, 24, 20, 28, 2, -20 },
  { 3375, 15, 20, 19, 2, -20 },
  { 3413, 16, 20, 18, 1, -20 },
  { 3453, 15, 28, 18, 2, -20 },
  { 3506, 16, 28, 18, 1, -20 },
  { 3562, 11, 20, 13, 2, -20 },
  { 3590, 12, 20, 14, 1, -20 },
  { 3620, 12, 23, 12, 0, -23 },
  { 3655, 15, 19, 19, 2, -19 },
  { 3691, 17, 19, 17, 0, -19 },
  { 3732, 26, 19, 26, 0, -19 },
  { 3794, 16, 19, 17, 0, -19 },
  { 3832, 17, 27, 17, 0, -19 },
  { 3890, 12, 19, 14, 1, -19 },
  { 3919, 12, 31, 13, 0, -25 },
  { 3966, 5, 35, 15, 5, -27 },
  { 3988, 11, 31, 13, 1, -25 },
  { 4031, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Black35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK35PT7B_H_
