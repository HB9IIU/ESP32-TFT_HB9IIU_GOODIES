#ifndef _NOTOSANS_EXTRACONDENSED_BLACK66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3F, 0xC7, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0,
  0xF0, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC,
  0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xBE, 0x3E, 0x3F, 0xE7, 0xC0, 0xC7, 0xFC, 0xF8, 0x00, 0xFF,
  0x9F, 0x00, 0x1F, 0xF3, 0xE0, 0x03, 0xFE, 0x7C, 0x00, 0x7F, 0xEF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x7F, 0xE0, 0x03, 0xE7, 0xFC,
  0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0x9F, 0xFC, 0x01, 0xF3, 0xFF, 0xE0, 0x3E,
  0x7F, 0xBF, 0x07, 0xDF, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x9F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xFE,
  0x0F, 0xF9, 0xFF, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0x87,
  0xF8, 0xFF, 0xBF, 0xE0, 0xFF, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x07, 0xFE,
  0x0F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xFF, 0xF9, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFC, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0x01, 0xFE, 0x02, 0x0F, 0x07, 0xF8, 0x7C, 0x7F, 0x9F, 0xC7, 0xF1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF9, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE,
  0x01, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFE, 0x7F,
  0xF0, 0x7F, 0xE7, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x07,
  0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x7F,
  0xF7, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x07, 0xFE, 0x7F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF9, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x7F, 0x9F,
  0xFC, 0x7E, 0x3F, 0xF8, 0x78, 0x7F, 0xF0, 0x60, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC1, 0xFF, 0xE1, 0xF8, 0x0F, 0xFE, 0x0F, 0x00, 0xFF, 0xE0, 0x60,
  0x0F, 0xFF, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0x01, 0xFF, 0xE1, 0xC0, 0x0F, 0xFE, 0x08, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x7F,
  0x9F, 0xFC, 0x01, 0xFF, 0x3F, 0xF8, 0x03, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x81, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0xF8,
  0x20, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFD, 0xF8, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x9E, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF,
  0xDF, 0xFF, 0x07, 0xFD, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x3F, 0xFD, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF,
  0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x1F,
  0xF8, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xF1,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF,
  0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xFE, 0x1F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xE1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81,
  0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF,
  0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0,
  0x3F, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xC7, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F,
  0xC0, 0xF0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x3F, 0xF9, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0x70, 0x07, 0xFF, 0x10, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0x8F,
  0xF0, 0x3F, 0xFF, 0xF0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0xFE,
  0x07, 0xFF, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xF3, 0xFC, 0x3F, 0xDF, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFD, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF7, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xC3, 0xFC,
  0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFC, 0x3F, 0xC0,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xC3, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0,
  0xFE, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xF9, 0xFC, 0x1F, 0xE3, 0xFF, 0x1F,
  0xE7, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0x83, 0xFF, 0xF7, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x03,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF,
  0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0,
  0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFE, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x7F,
  0xF8, 0x01, 0x87, 0xFF, 0xC0, 0x04, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x02, 0x3F, 0xFF, 0x00,
  0x70, 0xFF, 0xFC, 0x0F, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF,
  0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F,
  0x07, 0xFF, 0xC0, 0x01, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x3F, 0xF9,
  0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF,
  0xDF, 0xFC, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0x9F,
  0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xF7,
  0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x03,
  0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0x80,
  0x3F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F,
  0xE3, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFC,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0x7F,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFB, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0xFD,
  0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF,
  0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF,
  0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0x80,
  0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE7, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xF3, 0xFF, 0xC0, 0x3C, 0xFF,
  0xF0, 0x03, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xDF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xBF, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFD, 0xFE, 0x1F, 0xFC,
  0x07, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0x7F, 0x8F,
  0xFE, 0x00, 0xFF, 0xC7, 0xFB, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xCF,
  0xF3, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x7F, 0x9F, 0xFC, 0x01, 0xFF, 0x9F,
  0xF3, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x1F, 0xE7, 0xFE, 0x00, 0x7F,
  0xE7, 0xF8, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xBF, 0xC7, 0xFB, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xE0, 0x1F, 0xFE,
  0x7F, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF3,
  0xFF, 0xE0, 0xE0, 0x1F, 0xFC, 0x10, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xEF, 0xFF,
  0xF7, 0xFC, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0x0F, 0xF0, 0xFF, 0x81, 0xFE,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x7E, 0x03, 0xFF, 0x8F, 0xFC, 0x1F, 0xFC,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xE3, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0x7F, 0xFF, 0x1F, 0xF9, 0xFF, 0xF0, 0xFF, 0xC7,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFE, 0x0F, 0x1F, 0xFE, 0x01, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x5F, 0xFC, 0x00, 0xCF, 0xFF, 0x00,
  0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xDF, 0xF8, 0xFF, 0xFE,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE3, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xF8, 0x7F,
  0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF9, 0xFF, 0x07, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x07, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x27,
  0xFF, 0x00, 0x0C, 0x7F, 0xFC, 0x07, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xB8, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xE3,
  0xFE, 0x1F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFD, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xC7, 0xFF, 0xDF, 0xFC, 0x1F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xDF, 0xF8, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xE7, 0xFE, 0x0F, 0xFE, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0x18, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0x00, 0x01, 0xFF, 0x8E, 0x00,
  0x1F, 0xFC, 0x7F, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x1F, 0xFD, 0xFF,
  0xF0, 0xFF, 0xDF, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xF3, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0xE3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF,
  0xF1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x0F, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0x81, 0xFC, 0x07, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE3, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0x8F, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x03,
  0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFB, 0xFF, 0x80, 0x7F,
  0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03,
  0xFF, 0x8F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x2D, 0x00, 0x00, 0xFF, 0x81, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0xE1, 0xFF, 0x9F, 0xFF, 0x8F, 0xFD, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0xBF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x7F, 0xFE, 0x3F, 0xFB,
  0xFF, 0xE1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0x3C,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0xBF, 0xF1, 0xFF,
  0xFD, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xC7, 0xFF, 0xDF, 0xFC, 0x1F, 0xFE,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xF8, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFF, 0xE7, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0x18,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFE, 0x2F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xF7,
  0xF1, 0xFF, 0x80, 0xE3, 0xFF, 0x00, 0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x43, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xE3, 0xFE,
  0x1F, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x38, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x7F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0x7F, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF,
  0x7F, 0x9F, 0xFC, 0x1F, 0xF8, 0xFF, 0x7F, 0x9F, 0xF8, 0x1F, 0xF8, 0xFE,
  0x7F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE, 0x7F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE,
  0x7F, 0x9F, 0xF8, 0x0F, 0xFD, 0xFE, 0x7F, 0x9F, 0xF0, 0x0F, 0xFD, 0xFE,
  0x7F, 0xDF, 0xF0, 0x0F, 0xFD, 0xFE, 0x3F, 0xDF, 0xF0, 0x07, 0xFD, 0xFE,
  0x3F, 0xDF, 0xF0, 0x07, 0xFD, 0xFE, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFC,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC,
  0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF,
  0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF,
  0xF3, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F,
  0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFD, 0x00, 0x03, 0xFF, 0xC8, 0x00, 0x03, 0xF8,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Black66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 48, 18, 3, -47 },
  { 73, 26, 17, 32, 3, -47 },
  { 129, 34, 47, 36, 1, -47 },
  { 329, 27, 54, 33, 3, -50 },
  { 512, 52, 49, 55, 2, -48 },
  { 831, 42, 49, 42, 1, -48 },
  { 1089, 11, 17, 17, 3, -47 },
  { 1113, 18, 58, 22, 3, -48 },
  { 1244, 19, 58, 22, 0, -48 },
  { 1382, 30, 29, 31, 1, -50 },
  { 1491, 29, 32, 33, 2, -39 },
  { 1607, 13, 19, 18, 2, -10 },
  { 1638, 18, 10, 21, 2, -23 },
  { 1661, 12, 13, 18, 3, -12 },
  { 1681, 28, 49, 28, 0, -48 },
  { 1853, 28, 49, 33, 2, -48 },
  { 2025, 23, 47, 33, 3, -47 },
  { 2161, 28, 48, 33, 1, -48 },
  { 2329, 28, 49, 33, 2, -48 },
  { 2501, 31, 47, 33, 1, -47 },
  { 2684, 27, 48, 33, 3, -47 },
  { 2846, 29, 49, 33, 2, -48 },
  { 3024, 28, 47, 33, 2, -47 },
  { 3189, 29, 49, 33, 2, -48 },
  { 3367, 29, 49, 33, 2, -48 },
  { 3545, 12, 38, 18, 3, -37 },
  { 3602, 13, 46, 18, 2, -37 },
  { 3677, 29, 33, 33, 2, -40 },
  { 3797, 29, 23, 33, 2, -35 },
  { 3881, 29, 33, 33, 2, -40 },
  { 4001, 26, 49, 27, 0, -48 },
  { 4161, 46, 53, 51, 2, -48 },
  { 4466, 38, 47, 38, 0, -47 },
  { 4690, 30, 47, 37, 4, -47 },
  { 4867, 29, 49, 33, 3, -48 },
  { 5045, 32, 47, 39, 4, -47 },
  { 5233, 23, 47, 29, 4, -47 },
  { 5369, 22, 47, 29, 4, -47 },
  { 5499, 33, 49, 39, 3, -48 },
  { 5702, 32, 47, 40, 4, -47 },
  { 5890, 20, 47, 23, 2, -47 },
  { 6008, 19, 62, 19, -4, -47 },
  { 6156, 33, 47, 36, 4, -47 },
  { 6350, 23, 47, 28, 4, -47 },
  { 6486, 45, 47, 53, 4, -47 },
  { 6751, 35, 47, 43, 4, -47 },
  { 6957, 35, 49, 41, 3, -48 },
  { 7172, 28, 47, 34, 4, -47 },
  { 7337, 35, 59, 41, 3, -48 },
  { 7596, 32, 47, 36, 4, -47 },
  { 7784, 26, 49, 30, 2, -48 },
  { 7944, 28, 47, 30, 1, -47 },
  { 8109, 31, 48, 39, 4, -47 },
  { 8295, 37, 47, 37, 0, -47 },
  { 8513, 53, 47, 53, 0, -47 },
  { 8825, 34, 47, 34, 0, -47 },
  { 9025, 35, 47, 35, 0, -47 },
  { 9231, 29, 47, 31, 1, -47 },
  { 9402, 16, 59, 20, 3, -48 },
  { 9520, 28, 49, 28, 0, -48 },
  { 9692, 16, 59, 20, 1, -48 },
  { 9810, 35, 31, 36, 0, -47 },
  { 9946, 33, 8, 33, 0, 4 },
  { 9979, 17, 11, 22, 3, -51 },
  { 10003, 27, 38, 33, 2, -37 },
  { 10132, 29, 51, 35, 3, -50 },
  { 10317, 25, 38, 29, 2, -37 },
  { 10436, 29, 51, 35, 2, -50 },
  { 10621, 28, 38, 32, 2, -37 },
  { 10754, 23, 50, 22, 0, -50 },
  { 10898, 29, 53, 35, 2, -37 },
  { 11091, 29, 50, 35, 3, -50 },
  { 11273, 11, 51, 17, 3, -51 },
  { 11344, 17, 67, 17, -3, -51 },
  { 11487, 32, 50, 34, 3, -50 },
  { 11687, 11, 50, 17, 3, -50 },
  { 11756, 46, 37, 52, 3, -37 },
  { 11969, 29, 37, 35, 3, -37 },
  { 12104, 30, 38, 34, 2, -37 },
  { 12247, 29, 53, 35, 3, -37 },
  { 12440, 29, 53, 35, 2, -37 },
  { 12633, 21, 37, 25, 3, -37 },
  { 12731, 23, 38, 26, 2, -37 },
  { 12841, 22, 45, 23, 0, -44 },
  { 12965, 29, 38, 35, 3, -37 },
  { 13103, 32, 37, 32, 0, -37 },
  { 13251, 48, 37, 49, 0, -37 },
  { 13473, 31, 37, 31, 0, -37 },
  { 13617, 32, 53, 32, 0, -37 },
  { 13829, 24, 37, 26, 1, -37 },
  { 13940, 22, 59, 24, 1, -48 },
  { 14103, 9, 66, 28, 9, -51 },
  { 14178, 22, 59, 24, 1, -48 },
  { 14341, 29, 13, 33, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Black66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK66PT7B_H_
