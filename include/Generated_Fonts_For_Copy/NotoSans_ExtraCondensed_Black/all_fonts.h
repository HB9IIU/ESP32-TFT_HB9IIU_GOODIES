#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_Black
// Headers: 67

#include "NotoSans_ExtraCondensed_Black6pt7b.h"
#include "NotoSans_ExtraCondensed_Black7pt7b.h"
#include "NotoSans_ExtraCondensed_Black8pt7b.h"
#include "NotoSans_ExtraCondensed_Black9pt7b.h"
#include "NotoSans_ExtraCondensed_Black10pt7b.h"
#include "NotoSans_ExtraCondensed_Black11pt7b.h"
#include "NotoSans_ExtraCondensed_Black12pt7b.h"
#include "NotoSans_ExtraCondensed_Black13pt7b.h"
#include "NotoSans_ExtraCondensed_Black14pt7b.h"
#include "NotoSans_ExtraCondensed_Black15pt7b.h"
#include "NotoSans_ExtraCondensed_Black16pt7b.h"
#include "NotoSans_ExtraCondensed_Black17pt7b.h"
#include "NotoSans_ExtraCondensed_Black18pt7b.h"
#include "NotoSans_ExtraCondensed_Black19pt7b.h"
#include "NotoSans_ExtraCondensed_Black20pt7b.h"
#include "NotoSans_ExtraCondensed_Black21pt7b.h"
#include "NotoSans_ExtraCondensed_Black22pt7b.h"
#include "NotoSans_ExtraCondensed_Black23pt7b.h"
#include "NotoSans_ExtraCondensed_Black24pt7b.h"
#include "NotoSans_ExtraCondensed_Black25pt7b.h"
#include "NotoSans_ExtraCondensed_Black26pt7b.h"
#include "NotoSans_ExtraCondensed_Black27pt7b.h"
#include "NotoSans_ExtraCondensed_Black28pt7b.h"
#include "NotoSans_ExtraCondensed_Black29pt7b.h"
#include "NotoSans_ExtraCondensed_Black30pt7b.h"
#include "NotoSans_ExtraCondensed_Black31pt7b.h"
#include "NotoSans_ExtraCondensed_Black32pt7b.h"
#include "NotoSans_ExtraCondensed_Black33pt7b.h"
#include "NotoSans_ExtraCondensed_Black34pt7b.h"
#include "NotoSans_ExtraCondensed_Black35pt7b.h"
#include "NotoSans_ExtraCondensed_Black36pt7b.h"
#include "NotoSans_ExtraCondensed_Black37pt7b.h"
#include "NotoSans_ExtraCondensed_Black38pt7b.h"
#include "NotoSans_ExtraCondensed_Black39pt7b.h"
#include "NotoSans_ExtraCondensed_Black40pt7b.h"
#include "NotoSans_ExtraCondensed_Black41pt7b.h"
#include "NotoSans_ExtraCondensed_Black42pt7b.h"
#include "NotoSans_ExtraCondensed_Black43pt7b.h"
#include "NotoSans_ExtraCondensed_Black44pt7b.h"
#include "NotoSans_ExtraCondensed_Black45pt7b.h"
#include "NotoSans_ExtraCondensed_Black46pt7b.h"
#include "NotoSans_ExtraCondensed_Black47pt7b.h"
#include "NotoSans_ExtraCondensed_Black48pt7b.h"
#include "NotoSans_ExtraCondensed_Black49pt7b.h"
#include "NotoSans_ExtraCondensed_Black50pt7b.h"
#include "NotoSans_ExtraCondensed_Black51pt7b.h"
#include "NotoSans_ExtraCondensed_Black52pt7b.h"
#include "NotoSans_ExtraCondensed_Black53pt7b.h"
#include "NotoSans_ExtraCondensed_Black54pt7b.h"
#include "NotoSans_ExtraCondensed_Black55pt7b.h"
#include "NotoSans_ExtraCondensed_Black56pt7b.h"
#include "NotoSans_ExtraCondensed_Black57pt7b.h"
#include "NotoSans_ExtraCondensed_Black58pt7b.h"
#include "NotoSans_ExtraCondensed_Black59pt7b.h"
#include "NotoSans_ExtraCondensed_Black60pt7b.h"
#include "NotoSans_ExtraCondensed_Black61pt7b.h"
#include "NotoSans_ExtraCondensed_Black62pt7b.h"
#include "NotoSans_ExtraCondensed_Black63pt7b.h"
#include "NotoSans_ExtraCondensed_Black64pt7b.h"
#include "NotoSans_ExtraCondensed_Black65pt7b.h"
#include "NotoSans_ExtraCondensed_Black66pt7b.h"
#include "NotoSans_ExtraCondensed_Black67pt7b.h"
#include "NotoSans_ExtraCondensed_Black68pt7b.h"
#include "NotoSans_ExtraCondensed_Black69pt7b.h"
#include "NotoSans_ExtraCondensed_Black70pt7b.h"
#include "NotoSans_ExtraCondensed_Black71pt7b.h"
#include "NotoSans_ExtraCondensed_Black72pt7b.h"
