#ifndef _NOTOSANS_EXTRACONDENSED_BLACK25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF3, 0x9C, 0xE0, 0x03, 0xDF, 0xFB,
  0x80, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3C, 0x1C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xDC, 0x1D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xC3,
  0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x70, 0x0C, 0x03, 0x03, 0xF9, 0xFF, 0xFF, 0xFF, 0x2E, 0xC3, 0xF0, 0x7C,
  0x1F, 0xC1, 0xF8, 0x3F, 0x0D, 0xE3, 0x7C, 0xDF, 0xFF, 0xFF, 0x9F, 0xC0,
  0xC0, 0x30, 0x38, 0x1E, 0x0F, 0x83, 0x83, 0xF8, 0x70, 0x77, 0x1C, 0x0E,
  0xE3, 0x81, 0xDE, 0xE0, 0x3B, 0x9C, 0x07, 0x73, 0x9C, 0xFE, 0xEF, 0xCF,
  0xDD, 0xFC, 0xF7, 0x3B, 0x80, 0xEF, 0x70, 0x1D, 0xEE, 0x07, 0x3D, 0xC0,
  0xE3, 0xB8, 0x38, 0x7F, 0x07, 0x0F, 0xC1, 0xE0, 0xF8, 0x1F, 0x80, 0x7F,
  0x81, 0xFF, 0x03, 0xCE, 0x07, 0x9E, 0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x3C, 0xFF, 0x7B, 0xFE, 0xF7, 0xBF, 0xEF, 0x3F, 0x9E, 0x3F, 0x3E,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7C, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x78, 0xF3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x78, 0xF0, 0xE1, 0xE3, 0xC3, 0xC0, 0xF0, 0xF0, 0xE1, 0xE3, 0xC3,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3,
  0xC7, 0x9E, 0x00, 0x0F, 0x00, 0xF0, 0x4E, 0x27, 0x6E, 0x7F, 0xEF, 0xFF,
  0x1F, 0x01, 0xF8, 0x7F, 0xE3, 0x9C, 0x11, 0x80, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x7B, 0xFD, 0xEF, 0x7B, 0x80, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xE0,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x00, 0x1F, 0x07, 0xF1, 0xFE, 0x3F, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E,
  0xF3, 0xDE, 0x7F, 0xCF, 0x79, 0xEF, 0x3D, 0xE7, 0x9F, 0xF3, 0xFC, 0x3F,
  0x83, 0xE0, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xFD, 0xDE, 0x4F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F,
  0x07, 0xFB, 0xFF, 0x3F, 0xF2, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC,
  0x3F, 0x3F, 0xEF, 0xFD, 0xFF, 0x43, 0xC0, 0xF0, 0x78, 0xFE, 0x3E, 0x0F,
  0xE3, 0xFC, 0x0F, 0x03, 0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3B,
  0xC7, 0xBC, 0x73, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x03,
  0xC0, 0x3C, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x70, 0x1C, 0x07, 0xE1, 0xFE,
  0x7F, 0xBF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xC0, 0x0F, 0xC3, 0xF8, 0xFF, 0x3F, 0x27, 0x81, 0xE0, 0x3D, 0xC7, 0xFC,
  0xFF, 0xDF, 0xFB, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xBE, 0xF3, 0xFE, 0x3F,
  0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x00, 0x3F, 0x0F, 0xF3, 0xFF, 0x7D, 0xEF, 0x3D, 0xE7, 0x9F, 0xF3, 0xFC,
  0x3F, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC, 0xF7, 0xFE, 0x7F,
  0xC7, 0xE0, 0x3E, 0x0F, 0xF1, 0xFE, 0x7F, 0xEF, 0x3D, 0xE7, 0xBC, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFD, 0xF7, 0x1C, 0xE0, 0x3C, 0x07, 0xA3, 0xE3, 0xFC,
  0x7F, 0x0F, 0xC0, 0x77, 0xFF, 0xF3, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8,
  0x77, 0xFF, 0xF3, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0x7B, 0xDE, 0xE0, 0x00,
  0x60, 0x3C, 0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1E, 0x03, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xC1, 0xF9, 0xFE, 0xFF, 0x1F, 0x83, 0x80, 0x40, 0x00, 0x3F, 0x3F,
  0xEF, 0xF9, 0xFF, 0x43, 0xC0, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x81, 0xC0,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0x8F, 0x87, 0x01, 0xE7, 0x0C, 0x73, 0x9F, 0xDF, 0x9F, 0xEF,
  0xCE, 0x77, 0xEF, 0x3B, 0xF7, 0x1D, 0xFB, 0x8E, 0xFD, 0xCE, 0x7E, 0x77,
  0xBF, 0x3F, 0xFB, 0xCF, 0x78, 0xE0, 0x00, 0x78, 0x04, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7B, 0x81, 0xEF, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x8F,
  0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9E, 0x1F, 0xF8, 0x3F, 0xE0, 0xF0,
  0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF9, 0xFF, 0x9F, 0xF9, 0xEF, 0xFE,
  0xFF, 0x8F, 0xFE, 0xFB, 0xEF, 0x9F, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xCF, 0xF8, 0x0F, 0xC3, 0xFC, 0xFF, 0xBF, 0xE7, 0x85, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x5F, 0xB3,
  0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x9F,
  0x7C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF,
  0x8F, 0x7C, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0xFF, 0xE7, 0xC1,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xF1, 0xFF,
  0x8F, 0xBC, 0x7D, 0xFB, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xC0, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x7F, 0xFF, 0xFC, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0x60, 0xF8, 0xFF, 0xC7, 0xBE,
  0x7D, 0xF3, 0xCF, 0xBE, 0x7D, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF1, 0xFF, 0x8F, 0xBE, 0x7C, 0xF3, 0xE7, 0xDF, 0x3E, 0xF8, 0xF7,
  0xC7, 0xC0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFF, 0xDC, 0xEF, 0xF7, 0x3B, 0xFD, 0xFE, 0xFF, 0x3F, 0xBF,
  0xCF, 0xCF, 0xF3, 0xF3, 0xFC, 0xFC, 0xFF, 0x1F, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xF0, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFD, 0xEF, 0xF7, 0xBF, 0xDE, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xF0,
  0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x78, 0xFB, 0xE1, 0xEF, 0x87,
  0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBE, 0x1E, 0xF8, 0x79, 0xE3,
  0xE7, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F,
  0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1F, 0xFE, 0x78, 0xFB, 0xE1, 0xEF, 0x87, 0xBC, 0x1E, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xBE, 0x1E, 0xF8, 0x79, 0xE3, 0xE7, 0xFF, 0x9F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x9E, 0x7C, 0xF3, 0xE7, 0x9F,
  0x7C, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xBC, 0x7D, 0xF3, 0xE7,
  0x9F, 0x3E, 0xF9, 0xF7, 0xC7, 0xC0, 0x3F, 0x1F, 0xFF, 0xFB, 0xFE, 0xF0,
  0xBC, 0x0F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x07, 0xE1, 0xFF,
  0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0xF8, 0x7F, 0xE1,
  0xF7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF8, 0xF0,
  0xF7, 0x8F, 0x1F, 0x78, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x9F,
  0x9E, 0x3D, 0xF9, 0xE3, 0xDF, 0xFE, 0x3F, 0xDF, 0xC3, 0xF9, 0xFC, 0x3F,
  0x9F, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F, 0x81,
  0xF0, 0xF8, 0xF8, 0xF3, 0xC7, 0x9E, 0x7C, 0x7B, 0xC3, 0xDE, 0x1F, 0xE0,
  0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1E,
  0xF0, 0xF7, 0x8F, 0x3E, 0x78, 0xF7, 0xC7, 0xC0, 0xF8, 0x7B, 0xC7, 0xDE,
  0x3C, 0xF9, 0xE3, 0xDE, 0x1E, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x0F,
  0xE0, 0x77, 0x87, 0x9C, 0x38, 0xF3, 0xC3, 0x9E, 0x1F, 0xE0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF0, 0xF0, 0xF0, 0x3F, 0x1F, 0xE7, 0xFC,
  0x8F, 0x03, 0xC7, 0xF7, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFF, 0xFD,
  0xDE, 0x70, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF, 0x3D, 0xF7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF,
  0xFF, 0xFF, 0xFB, 0xDE, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0x6F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x6F, 0xF7, 0xF9, 0xF8, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x7B, 0xDF, 0xFB, 0xFF, 0xFB, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xDF, 0xFF, 0xEF, 0xFC, 0xF7, 0x80,
  0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x85, 0xFF, 0x7F, 0xCF, 0xE0, 0x1F, 0x9F, 0x8F, 0xC7, 0xA3, 0xC3,
  0xFB, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x00, 0x3D, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xF7, 0xFE, 0x7B, 0xC0,
  0x7C, 0x0F, 0xF7, 0xDF, 0xFB, 0xFE, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xEF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0xFF,
  0xF7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xF3, 0xC7,
  0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xFE, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x1F, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFB, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0x8F, 0x3F, 0xF7, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xF9, 0xE7, 0xBC, 0x79, 0xFF, 0x1E, 0x7F, 0xC7,
  0x9F, 0xF1, 0xE7, 0xFC, 0x79, 0xFF, 0x1E, 0x7F, 0xC7, 0x9F, 0xF1, 0xE7,
  0xFC, 0x79, 0xF0, 0xF7, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x1F,
  0x07, 0xF1, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xEF, 0xBF, 0xE7, 0xFC, 0x3E, 0x00, 0xF7, 0x9E, 0xFB, 0xFF, 0xFD,
  0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF,
  0xFD, 0xEF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x3D,
  0xEF, 0xFD, 0xFF, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xEF, 0xFF, 0xF7, 0xFE, 0x7B, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0xE7, 0xF7, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x3E, 0xFF, 0xFF, 0xF2, 0xF0, 0xFC, 0xFE,
  0x7F, 0x1F, 0x0F, 0xCF, 0xFF, 0xFF, 0xFE, 0x1C, 0x1C, 0x3C, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3D, 0x3F, 0x3F, 0x1F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xEF, 0xBF, 0xF7, 0xFE, 0x79, 0xC0, 0xF0, 0xFF, 0x8F, 0x78,
  0xF7, 0x9E, 0x79, 0xE3, 0x9E, 0x3D, 0xC3, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xF0, 0xF1, 0xF3, 0xFC, 0x7C, 0xF7, 0xBF, 0x3D,
  0xEF, 0xCF, 0x7B, 0xF3, 0x9E, 0xFD, 0xE7, 0xBB, 0xF8, 0xEE, 0xFE, 0x3B,
  0xBF, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xC7,
  0xC0, 0xF9, 0xF7, 0x9E, 0x7B, 0xE3, 0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xC7, 0xBE, 0x79, 0xEF, 0x9F, 0xF0, 0xFF,
  0x8F, 0x79, 0xF7, 0x9E, 0x79, 0xE3, 0xDE, 0x3D, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x07,
  0xE0, 0x7C, 0x07, 0x80, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x8F,
  0xC7, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x7E, 0x3F, 0x1F, 0x0F,
  0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xF1, 0xF8, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7E, 0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0xC7,
  0xE1, 0xF1, 0xF8, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x1F, 0x8F, 0xC7,
  0xC0, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_Black25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 10, 7, 12, 1, -18 },
  { 22, 12, 18, 14, 1, -18 },
  { 49, 10, 20, 12, 1, -19 },
  { 74, 19, 18, 21, 1, -18 },
  { 117, 15, 18, 16, 1, -18 },
  { 151, 4, 7, 6, 1, -18 },
  { 155, 7, 22, 8, 1, -18 },
  { 175, 7, 22, 8, 0, -18 },
  { 195, 12, 11, 12, 0, -19 },
  { 212, 11, 12, 13, 1, -15 },
  { 229, 5, 7, 7, 1, -4 },
  { 234, 6, 4, 8, 1, -9 },
  { 237, 5, 4, 7, 1, -4 },
  { 240, 11, 18, 11, 0, -18 },
  { 265, 11, 18, 12, 1, -18 },
  { 290, 9, 18, 12, 1, -18 },
  { 311, 11, 18, 12, 0, -18 },
  { 336, 10, 18, 12, 1, -18 },
  { 359, 12, 18, 12, 0, -18 },
  { 386, 10, 18, 12, 1, -18 },
  { 409, 11, 18, 12, 1, -18 },
  { 434, 10, 18, 12, 1, -18 },
  { 457, 11, 18, 12, 1, -18 },
  { 482, 11, 18, 12, 1, -18 },
  { 507, 5, 14, 7, 1, -14 },
  { 516, 5, 17, 7, 1, -14 },
  { 527, 11, 12, 13, 1, -15 },
  { 544, 11, 9, 13, 1, -13 },
  { 557, 11, 12, 13, 1, -15 },
  { 574, 10, 18, 10, 0, -18 },
  { 597, 17, 20, 19, 1, -18 },
  { 640, 14, 18, 14, 0, -18 },
  { 672, 12, 18, 14, 1, -18 },
  { 699, 11, 18, 13, 1, -18 },
  { 724, 13, 18, 15, 1, -18 },
  { 754, 9, 18, 11, 1, -18 },
  { 775, 9, 18, 11, 1, -18 },
  { 796, 13, 18, 15, 1, -18 },
  { 826, 13, 18, 15, 1, -18 },
  { 856, 7, 18, 9, 1, -18 },
  { 872, 8, 24, 7, -2, -18 },
  { 896, 13, 18, 14, 1, -18 },
  { 926, 9, 18, 11, 1, -18 },
  { 947, 18, 18, 20, 1, -18 },
  { 988, 14, 18, 16, 1, -18 },
  { 1020, 14, 18, 16, 1, -18 },
  { 1052, 11, 18, 13, 1, -18 },
  { 1077, 14, 22, 16, 1, -18 },
  { 1116, 13, 18, 14, 1, -18 },
  { 1146, 10, 18, 11, 1, -18 },
  { 1169, 11, 18, 12, 0, -18 },
  { 1194, 12, 18, 15, 1, -18 },
  { 1221, 14, 18, 14, 0, -18 },
  { 1253, 20, 18, 20, 0, -18 },
  { 1298, 13, 18, 13, 0, -18 },
  { 1328, 13, 18, 13, 0, -18 },
  { 1358, 10, 18, 12, 1, -18 },
  { 1381, 6, 22, 8, 1, -18 },
  { 1398, 11, 18, 11, 0, -18 },
  { 1423, 7, 22, 8, 0, -18 },
  { 1443, 13, 12, 14, 0, -18 },
  { 1463, 13, 3, 13, 0, 2 },
  { 1468, 7, 4, 9, 1, -19 },
  { 1472, 10, 14, 12, 1, -14 },
  { 1490, 11, 19, 13, 1, -19 },
  { 1517, 9, 14, 11, 1, -14 },
  { 1533, 11, 19, 13, 1, -19 },
  { 1560, 10, 14, 12, 1, -14 },
  { 1578, 9, 19, 8, 0, -19 },
  { 1600, 11, 20, 13, 1, -14 },
  { 1628, 11, 19, 13, 1, -19 },
  { 1655, 4, 19, 7, 1, -19 },
  { 1665, 6, 25, 7, -1, -19 },
  { 1684, 12, 19, 13, 1, -19 },
  { 1713, 4, 19, 7, 1, -19 },
  { 1723, 18, 14, 20, 1, -14 },
  { 1755, 11, 14, 13, 1, -14 },
  { 1775, 11, 14, 13, 1, -14 },
  { 1795, 11, 20, 13, 1, -14 },
  { 1823, 11, 20, 13, 1, -14 },
  { 1851, 8, 14, 9, 1, -14 },
  { 1865, 8, 14, 10, 1, -14 },
  { 1879, 8, 17, 9, 0, -17 },
  { 1896, 11, 14, 13, 1, -14 },
  { 1916, 12, 14, 12, 0, -14 },
  { 1937, 18, 14, 18, 0, -14 },
  { 1969, 12, 14, 12, 0, -14 },
  { 1990, 12, 20, 12, 0, -14 },
  { 2020, 10, 14, 10, 0, -14 },
  { 2038, 9, 22, 9, 0, -18 },
  { 2063, 4, 25, 10, 3, -19 },
  { 2076, 9, 22, 9, 0, -18 },
  { 2101, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Black25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK25PT7B_H_
