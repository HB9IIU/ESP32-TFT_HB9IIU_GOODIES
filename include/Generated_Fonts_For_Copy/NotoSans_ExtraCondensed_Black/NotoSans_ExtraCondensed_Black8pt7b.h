#ifndef _NOTOSANS_EXTRACONDENSED_BLACK8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACK8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Black.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Black8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x30, 0xFE, 0x55, 0xF6, 0xF6, 0x3E, 0xC2, 0xB6, 0x49, 0x52,
  0xD2, 0xE2, 0xA5, 0x80, 0x63, 0x99, 0xFF, 0x7C, 0xF0, 0x6B, 0x6C, 0x98,
  0x95, 0x5C, 0x4F, 0xE0, 0x66, 0xF6, 0xF0, 0xC0, 0xC0, 0x25, 0xA5, 0x00,
  0x6E, 0xFF, 0xF6, 0x2F, 0x92, 0x40, 0x6A, 0x26, 0x4F, 0x6B, 0x66, 0x3E,
  0x26, 0x6A, 0xF2, 0x64, 0x6B, 0x3E, 0x64, 0xEF, 0xF6, 0xF3, 0x22, 0x64,
  0x6F, 0x66, 0xF6, 0x6F, 0xF7, 0x26, 0xC3, 0xC3, 0xC0, 0x16, 0xE3, 0xF0,
  0xF0, 0x86, 0x7C, 0xF5, 0xA0, 0x80, 0x31, 0x3B, 0x6D, 0xB9, 0x23, 0x00,
  0x63, 0x1C, 0xAF, 0x6C, 0xEF, 0xFF, 0xDF, 0x75, 0xCC, 0xC7, 0xEF, 0xDD,
  0xDE, 0xFB, 0xFD, 0xC0, 0xFB, 0x7D, 0x80, 0x35, 0xCF, 0xD7, 0xDD, 0xFF,
  0xDD, 0xE9, 0x25, 0xC0, 0xFF, 0xFE, 0xDF, 0xB9, 0xCF, 0x68, 0xDB, 0x6D,
  0xC0, 0xCF, 0xBE, 0xFD, 0xF7, 0x50, 0xDF, 0xFB, 0xDD, 0xEC, 0x72, 0xB7,
  0xBD, 0x38, 0xEF, 0xDF, 0xCC, 0x72, 0xB7, 0xBD, 0x38, 0x60, 0xEF, 0xFE,
  0xFD, 0x7F, 0x3B, 0xC0, 0xF6, 0x66, 0x66, 0xDD, 0xDD, 0xD7, 0x9D, 0x57,
  0x66, 0x97, 0xDF, 0x5D, 0x6D, 0xB0, 0xF6, 0x66, 0x6D, 0x9F, 0x66, 0x66,
  0xF2, 0x24, 0xCF, 0xFF, 0xFC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x79,
  0xF0, 0xC0, 0x26, 0x7F, 0xF0, 0xCE, 0xFD, 0xDF, 0x3F, 0x66, 0x35, 0xFF,
  0xF7, 0x4E, 0xFC, 0x60, 0x6B, 0xA4, 0x80, 0x4F, 0xFF, 0x5B, 0xE0, 0xCE,
  0xFD, 0xDD, 0xCF, 0xF0, 0xCF, 0xFE, 0xCC, 0xFE, 0xED, 0xFF, 0xF0, 0x2B,
  0xFD, 0x75, 0xD4, 0x2F, 0xDD, 0xD0, 0x2F, 0xDF, 0x60, 0x2F, 0xDD, 0xFC,
  0xC0, 0x4F, 0xFF, 0x53, 0x30, 0x3F, 0x6C, 0x5F, 0x1E, 0x5F, 0x66, 0xDD,
  0xF7, 0xF6, 0x66, 0xBF, 0xE7, 0x9E, 0xF6, 0x6F, 0xF6, 0x66, 0x6C, 0xE9,
  0x70, 0x69, 0x64, 0x98, 0xFF, 0xC9, 0x34, 0xB0, 0x5F,
};

const GFXglyph NotoSans_ExtraCondensed_Black8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 7, 6, 7, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 2, 2, 2, 0, -6 },
  { 21, 3, 7, 3, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 4, 3, 4, 0, -6 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 2, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 2, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 2, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 4, 3, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -5 },
  { 75, 3, 6, 3, 0, -6 },
  { 78, 6, 7, 6, 0, -6 },
  { 84, 5, 6, 5, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 5, 0, -6 },
  { 97, 3, 6, 4, 0, -6 },
  { 100, 3, 6, 3, 0, -6 },
  { 103, 4, 6, 5, 0, -6 },
  { 106, 4, 6, 5, 0, -6 },
  { 109, 3, 6, 3, 0, -6 },
  { 112, 2, 8, 2, 0, -6 },
  { 114, 5, 6, 4, 0, -6 },
  { 118, 3, 6, 3, 0, -6 },
  { 121, 6, 6, 6, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 5, 7, 5, 0, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 3, 6, 4, 0, -6 },
  { 148, 4, 6, 4, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 6, 6, 6, 0, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 4, 6, 4, 0, -6 },
  { 171, 2, 7, 2, 0, -6 },
  { 173, 3, 6, 3, 0, -6 },
  { 176, 2, 7, 2, 0, -6 },
  { 178, 4, 4, 4, 0, -6 },
  { 180, 4, 1, 4, 0, 0 },
  { 181, 2, 1, 3, 0, -6 },
  { 182, 4, 5, 4, 0, -5 },
  { 185, 4, 6, 4, 0, -6 },
  { 188, 3, 5, 3, 0, -5 },
  { 190, 4, 6, 4, 0, -6 },
  { 193, 4, 5, 4, 0, -5 },
  { 196, 3, 6, 3, 0, -6 },
  { 199, 4, 7, 4, 0, -5 },
  { 203, 4, 6, 4, 0, -6 },
  { 206, 2, 6, 2, 0, -6 },
  { 208, 2, 8, 2, 0, -6 },
  { 210, 4, 6, 4, 0, -6 },
  { 213, 2, 6, 2, 0, -6 },
  { 215, 6, 5, 6, 0, -5 },
  { 219, 4, 5, 4, 0, -5 },
  { 222, 4, 5, 4, 0, -5 },
  { 225, 4, 7, 4, 0, -5 },
  { 229, 4, 7, 4, 0, -5 },
  { 233, 3, 5, 3, 0, -5 },
  { 235, 3, 5, 3, 0, -5 },
  { 237, 3, 5, 3, 0, -5 },
  { 239, 4, 4, 4, 0, -4 },
  { 241, 4, 4, 4, 0, -4 },
  { 243, 6, 4, 6, 0, -4 },
  { 246, 4, 4, 4, 0, -4 },
  { 248, 4, 6, 4, 0, -4 },
  { 251, 3, 4, 3, 0, -4 },
  { 253, 3, 7, 3, 0, -6 },
  { 256, 1, 8, 3, 1, -6 },
  { 257, 3, 7, 3, 0, -6 },
  { 260, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Black8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Black8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Black8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACK8PT7B_H_
