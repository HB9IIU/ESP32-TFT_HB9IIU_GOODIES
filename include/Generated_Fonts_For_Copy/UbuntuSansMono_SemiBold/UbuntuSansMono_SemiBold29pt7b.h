#ifndef _UBUNTUSANSMONO_SEMIBOLD29PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x00, 0x0C, 0xF7,
  0xFF, 0xE0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xDC, 0x77, 0x1D, 0x86,
  0x61, 0x80, 0x0F, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x38, 0xE0, 0xF3, 0xC1, 0xC7,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C, 0xF0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F,
  0xF8, 0xFF, 0xE7, 0xFF, 0x9E, 0x02, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF4,
  0x03, 0xDF, 0x3F, 0x7F, 0xFB, 0xFF, 0xC0, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x10, 0x00, 0x3C, 0x07, 0x7E, 0x0E, 0x66, 0x0C, 0xE7, 0x1C,
  0xE7, 0x38, 0xE7, 0x30, 0x66, 0x70, 0x7E, 0xE0, 0x3C, 0xC0, 0x09, 0xC0,
  0x03, 0x98, 0x03, 0x3E, 0x07, 0x7E, 0x0E, 0x67, 0x0E, 0x67, 0x1C, 0x67,
  0x18, 0x67, 0x38, 0x67, 0x70, 0x7E, 0xE0, 0x3E, 0x02, 0x00, 0x3F, 0x80,
  0xFF, 0x01, 0xCF, 0x07, 0x0E, 0x0E, 0x1C, 0x1E, 0x38, 0x3C, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0x78, 0x71, 0xF8, 0xE7, 0xFB, 0x9E, 0x7F, 0x38, 0x7E,
  0x70, 0xFC, 0xE0, 0xF1, 0xE1, 0xF3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF1, 0xE0,
  0xFF, 0xFF, 0xF7, 0x77, 0x60, 0x00, 0x80, 0xF0, 0x7C, 0x3E, 0x1F, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x06, 0x60, 0x1C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3E, 0x1F,
  0x0F, 0x81, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xC1, 0xCC, 0x6F, 0xEF, 0x7F,
  0xFC, 0xFF, 0x81, 0xF0, 0x1F, 0xC1, 0xEF, 0x1E, 0x78, 0x31, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xE1, 0xC7, 0x7E, 0x78, 0xC0, 0xFF,
  0xFF, 0xFF, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x3F, 0x83, 0xFF, 0x0F, 0xFC, 0x78,
  0x79, 0xC0, 0xE7, 0x03, 0xFC, 0x0F, 0xF1, 0x3F, 0xCE, 0x7F, 0x79, 0xFD,
  0xE7, 0xF3, 0x1F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x39, 0xE1, 0xE3,
  0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0x03, 0x80, 0x7C, 0x07, 0xE0, 0xFF, 0x0F,
  0xF8, 0x7B, 0xC1, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0x04, 0x01, 0xFE, 0x3F, 0xF9, 0xFF, 0xC6, 0x0F, 0x20, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x04, 0x03, 0xFE, 0x3F, 0xF8, 0xFF, 0xC4, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x03, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x74, 0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0x70, 0x3D, 0xC0, 0xE7,
  0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xC0,
  0x3F, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x40, 0x7B, 0xFF, 0xDF, 0xFD, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0x87,
  0xFC, 0x7E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0xF0, 0xFF, 0xE7, 0xFF,
  0xBC, 0x7D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0E, 0xF0, 0xF3,
  0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xBE, 0x78, 0x79, 0xC0,
  0xE7, 0x03, 0x9E, 0x0E, 0x7C, 0x78, 0xFF, 0xC1, 0xFE, 0x0F, 0xFC, 0x39,
  0xF9, 0xC1, 0xE7, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xE0, 0x06, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0x0F, 0x70,
  0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x1F, 0xE0, 0xFE, 0x07,
  0x80, 0x00, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFF,
  0xF7, 0x80, 0x3C, 0x7D, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF1,
  0xF7, 0xEF, 0xCF, 0x86, 0x1D, 0xF3, 0xC6, 0x00, 0x00, 0x30, 0x07, 0xC0,
  0xFE, 0x3F, 0xE7, 0xF8, 0x7F, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60,
  0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xC0,
  0x3F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x1F, 0x00, 0x70, 0x01, 0x00, 0x00,
  0x04, 0x0F, 0xFC, 0x7F, 0xE7, 0xFE, 0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0x00, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0E, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x7F, 0xE3, 0xFF,
  0x9F, 0xFE, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7,
  0xE7, 0x9F, 0x8F, 0xFE, 0x3F, 0xDC, 0x3E, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x83, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0x3F,
  0xFD, 0xC1, 0xEE, 0x0F, 0x70, 0x3B, 0x83, 0xDC, 0x3C, 0xFF, 0xE7, 0xFE,
  0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF,
  0xFF, 0xBF, 0xF9, 0xFF, 0x80, 0x00, 0x80, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x3C, 0x09, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x23, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xC3,
  0xEE, 0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1E, 0xE1, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x80, 0x1F, 0xE1, 0xFF, 0xCF,
  0xFE, 0x3C, 0x09, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x3D,
  0xF0, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x20, 0xFB, 0xFF, 0xBF, 0xF8, 0x7F, 0x80, 0xE0, 0x7B, 0x83,
  0xCE, 0x0F, 0x38, 0x78, 0xE3, 0xC3, 0x8F, 0x0E, 0x78, 0x3B, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x3B, 0xE0, 0xE7, 0xC3, 0x8F, 0x0E, 0x1E, 0x38,
  0x7C, 0xE0, 0xF3, 0x81, 0xEE, 0x07, 0xB8, 0x0F, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x39, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x7C, 0x7D, 0xB3,
  0xFE, 0xCD, 0xFB, 0xB7, 0xEF, 0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE3,
  0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1,
  0xFD, 0xCF, 0xEE, 0x7F, 0x3B, 0xF9, 0xDF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xF0, 0x01, 0x00,
  0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x78, 0x79, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0x70, 0x3D, 0xE1, 0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xFF, 0xFD, 0xFF, 0xCF, 0xF8, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x3F, 0x83,
  0xFF, 0x0F, 0xFE, 0x78, 0x79, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0x70, 0x3D, 0xE1, 0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x1E, 0x00, 0x3C,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFE, 0x38,
  0x3C, 0xE0, 0xF3, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xF3, 0xFF, 0xCF,
  0xFE, 0x3F, 0xE0, 0xE3, 0xC3, 0x8F, 0x0E, 0x1E, 0x38, 0x38, 0xE0, 0xF3,
  0x81, 0xEE, 0x07, 0xB8, 0x0F, 0x03, 0x00, 0x7F, 0xC3, 0xFF, 0x9F, 0xFC,
  0x78, 0x11, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0x81,
  0xF7, 0xFF, 0xBF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78, 0x79, 0xFF,
  0xE3, 0xFF, 0x07, 0xF8, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E,
  0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38,
  0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xE7, 0xE7, 0x9F,
  0x9E, 0x7E, 0x79, 0xFB, 0xF7, 0xEE, 0xDF, 0xB3, 0x76, 0xCF, 0xDF, 0x1F,
  0x78, 0x7D, 0xE1, 0xE7, 0x83, 0x9C, 0x0E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E,
  0x78, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF8,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E,
  0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x07, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0x9E, 0x0F, 0x1E, 0x3C,
  0x3C, 0x78, 0x3D, 0xE0, 0x7D, 0x80, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x60, 0xE3, 0xF1, 0xF0, 0xC0, 0x0F, 0x07, 0xFC, 0x7F, 0xE7, 0xBF,
  0x00, 0xF0, 0x07, 0x00, 0x73, 0xFF, 0x7F, 0xFF, 0x87, 0xE0, 0x7E, 0x07,
  0xF0, 0x7F, 0xFF, 0x7F, 0xF3, 0xFF, 0x10, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x40, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD,
  0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xC0, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFE, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0x00, 0x08, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0xCF, 0x1F, 0xF9, 0xFF, 0xDF, 0xFE, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF0, 0xF7, 0xFF, 0x9F, 0xFC,
  0x3F, 0xE0, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xBE, 0x78, 0x3B, 0xC0,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x7C,
  0x08, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x20, 0x07, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x01, 0x00, 0xFF, 0xCF, 0xFE, 0xFD, 0xF7, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0xFF, 0x9F,
  0xFC, 0x7E, 0xE0, 0x0F, 0x00, 0x7A, 0x03, 0xDF, 0xFC, 0xFF, 0xE7, 0xFC,
  0x00, 0x10, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x20, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x41, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x08, 0x00, 0x00,
  0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7A, 0x0F,
  0xFF, 0xDF, 0xFB, 0xFE, 0x02, 0x00, 0x10, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xFB, 0xC3, 0xCF,
  0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x83,
  0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x41, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7, 0xE3, 0x9F, 0x8E,
  0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x06, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x04, 0x07, 0xFE,
  0x3F, 0xF9, 0xFF, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xCF,
  0xFE, 0xFF, 0xF7, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x77, 0x87, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x01, 0x07, 0xFF, 0xFF, 0xEF,
  0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x03, 0xFF, 0x7F, 0xEF,
  0xDE, 0xF0, 0x0F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF0,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFC, 0x02, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x04, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF3, 0x81,
  0xC7, 0x87, 0x8F, 0x0F, 0x0E, 0x1C, 0x1E, 0x78, 0x1C, 0xF0, 0x3D, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x73, 0xEE, 0x77, 0xEE, 0x37, 0x6E, 0x36, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x3C, 0xF0, 0x3C, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x81,
  0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x73,
  0xC1, 0xE3, 0xC7, 0x87, 0x8E, 0x07, 0xBC, 0x0F, 0x80, 0xF0, 0x3D, 0xE0,
  0xF7, 0x83, 0x9E, 0x0E, 0x38, 0x78, 0xF1, 0xE3, 0xC7, 0x07, 0x1C, 0x1E,
  0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3F,
  0x01, 0xF0, 0x3F, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x01, 0xF0, 0xFF, 0x0F, 0xE0, 0x3E, 0x0E, 0xFF,
  0x3B, 0xFF, 0xF7, 0x1F, 0xCE, 0x0F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 20, 16, 6, -20 },
  { 14, 10, 9, 16, 3, -22 },
  { 26, 15, 20, 16, 1, -20 },
  { 64, 14, 26, 16, 1, -23 },
  { 110, 16, 21, 16, 0, -21 },
  { 152, 15, 21, 16, 1, -21 },
  { 192, 4, 9, 16, 6, -22 },
  { 197, 10, 28, 16, 3, -23 },
  { 232, 10, 28, 16, 3, -23 },
  { 267, 13, 12, 16, 2, -20 },
  { 287, 14, 15, 16, 1, -16 },
  { 314, 7, 10, 16, 4, -5 },
  { 323, 8, 3, 16, 4, -10 },
  { 326, 6, 5, 16, 5, -5 },
  { 330, 13, 28, 16, 2, -23 },
  { 376, 14, 21, 16, 1, -21 },
  { 413, 13, 20, 16, 2, -20 },
  { 446, 13, 21, 16, 2, -21 },
  { 481, 13, 21, 16, 2, -21 },
  { 516, 14, 20, 16, 1, -20 },
  { 551, 13, 20, 16, 1, -20 },
  { 584, 13, 20, 16, 2, -20 },
  { 617, 13, 20, 16, 2, -20 },
  { 650, 14, 21, 16, 1, -21 },
  { 687, 13, 21, 16, 2, -21 },
  { 722, 6, 15, 16, 5, -15 },
  { 734, 7, 20, 16, 4, -15 },
  { 752, 13, 14, 16, 2, -15 },
  { 775, 14, 9, 16, 1, -13 },
  { 791, 14, 14, 16, 1, -15 },
  { 816, 12, 21, 16, 2, -21 },
  { 848, 14, 25, 16, 1, -21 },
  { 892, 16, 20, 16, 0, -20 },
  { 932, 13, 20, 16, 2, -20 },
  { 965, 14, 21, 16, 1, -21 },
  { 1002, 13, 20, 16, 2, -20 },
  { 1035, 13, 20, 16, 2, -20 },
  { 1068, 12, 20, 16, 2, -20 },
  { 1098, 14, 21, 16, 1, -21 },
  { 1135, 14, 20, 16, 1, -20 },
  { 1170, 12, 20, 16, 2, -20 },
  { 1200, 13, 20, 16, 1, -20 },
  { 1233, 14, 20, 16, 2, -20 },
  { 1268, 12, 20, 16, 3, -20 },
  { 1298, 14, 20, 16, 1, -20 },
  { 1333, 13, 20, 16, 2, -20 },
  { 1366, 14, 21, 16, 1, -21 },
  { 1403, 13, 20, 16, 2, -20 },
  { 1436, 14, 26, 16, 1, -21 },
  { 1482, 14, 20, 16, 2, -20 },
  { 1517, 14, 21, 16, 1, -21 },
  { 1554, 14, 20, 16, 1, -20 },
  { 1589, 14, 20, 16, 1, -20 },
  { 1624, 16, 20, 16, 0, -20 },
  { 1664, 14, 20, 16, 1, -20 },
  { 1699, 16, 20, 16, 0, -20 },
  { 1739, 16, 20, 16, 0, -20 },
  { 1779, 13, 20, 16, 2, -20 },
  { 1812, 9, 28, 16, 4, -23 },
  { 1844, 13, 28, 16, 2, -23 },
  { 1890, 8, 28, 16, 4, -23 },
  { 1918, 15, 11, 16, 1, -20 },
  { 1939, 16, 3, 16, 0, 2 },
  { 1945, 7, 5, 16, 5, -22 },
  { 1950, 12, 16, 16, 2, -16 },
  { 1974, 13, 23, 16, 2, -23 },
  { 2012, 14, 16, 16, 1, -16 },
  { 2040, 13, 23, 16, 1, -23 },
  { 2078, 14, 16, 16, 1, -16 },
  { 2106, 15, 23, 16, 1, -23 },
  { 2150, 13, 21, 16, 1, -16 },
  { 2185, 12, 23, 16, 2, -23 },
  { 2220, 14, 22, 16, 1, -22 },
  { 2259, 11, 28, 16, 2, -22 },
  { 2298, 14, 23, 16, 2, -23 },
  { 2339, 14, 22, 16, 1, -22 },
  { 2378, 14, 15, 16, 1, -15 },
  { 2405, 12, 16, 16, 2, -16 },
  { 2429, 14, 16, 16, 1, -16 },
  { 2457, 13, 21, 16, 2, -16 },
  { 2492, 13, 21, 16, 1, -16 },
  { 2527, 12, 16, 16, 3, -16 },
  { 2551, 12, 16, 16, 2, -16 },
  { 2575, 14, 20, 16, 1, -20 },
  { 2610, 12, 15, 16, 2, -15 },
  { 2633, 15, 15, 16, 1, -15 },
  { 2662, 16, 15, 16, 0, -15 },
  { 2692, 15, 15, 16, 1, -15 },
  { 2721, 14, 20, 16, 1, -15 },
  { 2756, 12, 15, 16, 2, -15 },
  { 2779, 12, 28, 16, 2, -23 },
  { 2821, 4, 28, 16, 6, -23 },
  { 2835, 12, 28, 16, 2, -23 },
  { 2877, 15, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_SEMIBOLD29PT7B_H_
