#ifndef _UBUNTUSANSMONO_SEMIBOLD51PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0x83, 0x80, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xE7, 0x81, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0, 0x7C, 0x3F, 0x80,
  0x04, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x30, 0x00,
  0x7F, 0x3E, 0x00, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7D, 0xFF,
  0x80, 0x1F, 0x3F, 0xF0, 0x07, 0xCF, 0x9F, 0x00, 0xF9, 0xE1, 0xE0, 0x3E,
  0x3C, 0x3C, 0x0F, 0x87, 0x87, 0x81, 0xF0, 0xF0, 0xF0, 0x7C, 0x1E, 0x1E,
  0x0F, 0x03, 0xC3, 0xC3, 0xE0, 0x78, 0x78, 0xF8, 0x0F, 0x9F, 0x1E, 0x01,
  0xFF, 0xE7, 0xC0, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x3C, 0x00, 0x1F, 0xCF,
  0x80, 0x00, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xF0, 0x00, 0xF9, 0xFF, 0x00, 0x3E, 0x7F, 0xF0, 0x07, 0x8F,
  0x3E, 0x01, 0xF3, 0xE3, 0xE0, 0x7C, 0x7C, 0x7C, 0x0F, 0x0F, 0x07, 0x83,
  0xE1, 0xE0, 0xF0, 0xF8, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0xC7, 0xC0, 0xF8,
  0xF9, 0xF0, 0x0F, 0x1E, 0x3E, 0x01, 0xF7, 0xCF, 0x80, 0x3F, 0xFB, 0xE0,
  0x03, 0xFE, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0xFF, 0xC1, 0xF8, 0x7F,
  0xF8, 0x7E, 0x3F, 0xFF, 0x1F, 0x8F, 0xCF, 0xE7, 0xC7, 0xE3, 0xFD, 0xF1,
  0xF8, 0x7F, 0x7C, 0x7C, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x3F,
  0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x87, 0xF0,
  0x3F, 0xF1, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xE0,
  0xFF, 0xF8, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFD, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0x00, 0x06, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x04, 0x07, 0xC0, 0x4F, 0x0F, 0x87, 0x1F, 0x9F, 0x3F, 0x3F, 0x9C, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFB, 0xE0, 0x07, 0xF7, 0xE0, 0x1F,
  0xCF, 0xE0, 0x7F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7C, 0x1E, 0x00, 0x30,
  0x18, 0x00, 0x20, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0x81, 0xFE, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE,
  0x3F, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFE,
  0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x3E, 0x3F,
  0xFC, 0x7E, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x3C, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0x7E, 0x00, 0xF0, 0xFC, 0x01, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFB,
  0xFF, 0x1F, 0x01, 0xFE, 0x18, 0x01, 0xFC, 0x20, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xE3, 0xFE, 0x0E, 0x01, 0xFE,
  0x10, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xD0, 0x00, 0x3F, 0x9C, 0x01, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE6, 0x00, 0x7F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xBF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F,
  0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x3F,
  0xE1, 0xFC, 0x1F, 0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xDF, 0xFC, 0x3F, 0x03, 0xFE, 0x3F,
  0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F,
  0x80, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0xFF, 0xDF, 0xFD,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x3E, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF,
  0xE3, 0xF0, 0x10, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFF,
  0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF,
  0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3E, 0x03, 0xE0, 0x7E,
  0x1F, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x78, 0x08, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xE1, 0xFF,
  0x30, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xF8,
  0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x0F, 0xFF, 0x7C, 0x0F, 0xFF,
  0xDF, 0x07, 0xFF, 0xF7, 0xC1, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0x7C, 0x3F,
  0x8F, 0xDF, 0x1F, 0xC3, 0xFF, 0xC7, 0xE0, 0xFF, 0xE1, 0xF8, 0x3F, 0xF8,
  0x7E, 0x0F, 0xFE, 0x1F, 0x03, 0xFF, 0x87, 0xC0, 0xFF, 0xE1, 0xF0, 0x3F,
  0xF8, 0x7E, 0x0F, 0xDF, 0x1F, 0x83, 0xF7, 0xC7, 0xE0, 0xFD, 0xF1, 0xFC,
  0x3F, 0x7C, 0x3F, 0x8F, 0xDF, 0x0F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFC, 0xF8,
  0x3F, 0xFF, 0x3E, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0x81, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x10, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x03, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xC0, 0x7F, 0xDF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xF0, 0x7F, 0x80, 0x18, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x10, 0x7F, 0xC0,
  0x38, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC,
  0x07, 0xF8, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFE, 0x7E, 0x1F,
  0xE0, 0x06, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x3F, 0x1F,
  0xE0, 0x3F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x30, 0x03, 0xF9, 0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0x1F, 0xE0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xBF, 0xE0, 0x0F, 0xCF, 0xF0, 0x07, 0xE3, 0xFC, 0x03, 0xF0, 0xFF, 0x01,
  0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF8, 0x3F, 0x01, 0xFE,
  0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0xC7, 0xE0, 0x0F, 0xF3, 0xF0, 0x03,
  0xF9, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x0F, 0xF8, 0xF7, 0x83, 0xFE, 0x3D, 0xE0, 0xFF, 0x8F, 0x78, 0x7B, 0xE3,
  0xDE, 0x1E, 0xF8, 0xF3, 0xC7, 0xBE, 0x3C, 0xF3, 0xEF, 0x9F, 0x3C, 0xF3,
  0xE7, 0xC7, 0xBC, 0xF9, 0xF1, 0xFF, 0x3E, 0x7C, 0x7F, 0x8F, 0x9F, 0x1F,
  0xE3, 0xE7, 0xC3, 0xF8, 0xF9, 0xF0, 0xFE, 0x3E, 0x7C, 0x3F, 0x0F, 0xDF,
  0x07, 0xC3, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0xBF,
  0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0x7C, 0x7F, 0xF8, 0xFC,
  0xFF, 0xF0, 0xF9, 0xFF, 0xE1, 0xF3, 0xFF, 0xC1, 0xF7, 0xFF, 0x83, 0xEF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF,
  0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF0,
  0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x10, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x07,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x8F, 0xF8, 0x3E, 0x1F, 0xC0, 0x0C, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE8, 0x00, 0x1F,
  0xDE, 0x00, 0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0x7C, 0x1F, 0x0F, 0xDF, 0x07, 0xC3, 0xE7, 0xC3, 0xF0, 0xF9, 0xF0,
  0xFE, 0x3E, 0x7C, 0x3F, 0x8F, 0x9F, 0x1F, 0xE3, 0xE7, 0xC7, 0xF8, 0xF9,
  0xF1, 0xEF, 0x3E, 0x7C, 0xFB, 0xCF, 0x9F, 0x3C, 0xF3, 0xE3, 0xCF, 0x1E,
  0xF8, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1, 0xEF, 0x8F, 0x78, 0x7F, 0xE3, 0xDE,
  0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xC3,
  0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFC, 0x78, 0x00, 0x3C, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x03, 0x80, 0x3C, 0x07, 0xE0, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xE0, 0x1C, 0x00, 0x80, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x60,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x0E, 0x80, 0x04, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xE7, 0xE0, 0x1F, 0xCF,
  0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01,
  0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFE, 0x03, 0x9F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0xDF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0x0F, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFF,
  0x03, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x1C, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x38, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0xDF, 0xE0,
  0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB,
  0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x03, 0xFF, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x8E, 0x00, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE2, 0x00, 0xFE, 0x3C, 0x1F,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0xFC, 0x03,
  0xFC, 0xFC, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC,
  0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0xFC, 0x7F,
  0x80, 0xFC, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xE0, 0x3F, 0xE1, 0xF8, 0x7F, 0xFB, 0xFE, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xC7, 0xF1, 0xFB, 0xE1,
  0xF8, 0x7F, 0xF0, 0xFC, 0x3F, 0xF8, 0x3E, 0x1F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F,
  0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xF1, 0xFE,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x81,
  0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0xDF, 0xC0, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xF7,
  0xFE, 0x07, 0xE0, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0xDF, 0xE0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x01, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x00, 0x5F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFE, 0x01, 0xC7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x40, 0x00, 0xFD, 0xE0, 0x07, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x18, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF,
  0x07, 0xC1, 0xF7, 0xE0, 0xF8, 0x3E, 0x7C, 0x3F, 0x07, 0xCF, 0x87, 0xF0,
  0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0xF8, 0xF8,
  0xFF, 0x9F, 0x1F, 0x1F, 0xF3, 0xE1, 0xE7, 0xDE, 0x7C, 0x3E, 0xF3, 0xEF,
  0x87, 0xDE, 0x7D, 0xF0, 0xFF, 0xC7, 0xBC, 0x1F, 0xF8, 0xF7, 0x83, 0xFE,
  0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC,
  0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xCF,
  0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0x80,
  0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x04, 0x0F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x02, 0x03, 0xFE, 0x01, 0xF1, 0xFF,
  0xE0, 0x7C, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7,
  0xE1, 0xFF, 0xF9, 0xF0, 0x3F, 0xFC, 0xF8, 0x03, 0xFE, 0x02, 0x00, 0x3E,
  0x00,
};

const GFXglyph UbuntuSansMono_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 36, 29, 10, -35 },
  { 42, 17, 16, 29, 6, -39 },
  { 76, 26, 35, 29, 1, -35 },
  { 190, 24, 46, 29, 2, -40 },
  { 328, 27, 37, 29, 1, -36 },
  { 453, 26, 36, 29, 1, -36 },
  { 570, 7, 17, 29, 11, -39 },
  { 585, 17, 50, 29, 6, -40 },
  { 692, 18, 50, 29, 5, -40 },
  { 805, 23, 22, 29, 3, -35 },
  { 869, 24, 26, 29, 2, -28 },
  { 947, 12, 18, 29, 8, -9 },
  { 974, 15, 6, 29, 7, -18 },
  { 986, 10, 10, 29, 9, -9 },
  { 999, 23, 49, 29, 3, -40 },
  { 1140, 24, 37, 29, 2, -36 },
  { 1251, 23, 35, 29, 3, -35 },
  { 1352, 23, 36, 29, 3, -36 },
  { 1456, 23, 37, 29, 3, -36 },
  { 1563, 25, 35, 29, 2, -35 },
  { 1673, 23, 36, 29, 2, -35 },
  { 1777, 23, 37, 29, 3, -36 },
  { 1884, 23, 35, 29, 3, -35 },
  { 1985, 24, 37, 29, 2, -36 },
  { 2096, 23, 36, 29, 3, -36 },
  { 2200, 10, 28, 29, 9, -27 },
  { 2235, 12, 36, 29, 7, -27 },
  { 2289, 23, 24, 29, 3, -27 },
  { 2358, 24, 16, 29, 2, -23 },
  { 2406, 24, 25, 29, 2, -27 },
  { 2481, 20, 37, 29, 4, -36 },
  { 2574, 26, 44, 29, 1, -36 },
  { 2717, 27, 35, 29, 1, -35 },
  { 2836, 23, 36, 29, 3, -36 },
  { 2940, 25, 37, 29, 2, -36 },
  { 3056, 24, 36, 29, 3, -36 },
  { 3164, 22, 35, 29, 4, -35 },
  { 3261, 21, 35, 29, 4, -35 },
  { 3353, 24, 37, 29, 2, -36 },
  { 3464, 23, 35, 29, 3, -35 },
  { 3565, 21, 35, 29, 4, -35 },
  { 3657, 22, 36, 29, 3, -35 },
  { 3756, 25, 35, 29, 3, -35 },
  { 3866, 22, 35, 29, 4, -35 },
  { 3963, 26, 35, 29, 1, -35 },
  { 4077, 23, 35, 29, 3, -35 },
  { 4178, 25, 37, 29, 2, -36 },
  { 4294, 24, 36, 29, 3, -36 },
  { 4402, 25, 46, 29, 2, -36 },
  { 4546, 24, 36, 29, 3, -36 },
  { 4654, 23, 37, 29, 3, -36 },
  { 4761, 25, 35, 29, 2, -35 },
  { 4871, 24, 36, 29, 2, -35 },
  { 4979, 27, 35, 29, 1, -35 },
  { 5098, 26, 35, 29, 1, -35 },
  { 5212, 27, 35, 29, 1, -35 },
  { 5331, 27, 35, 29, 1, -35 },
  { 5450, 23, 35, 29, 3, -35 },
  { 5551, 15, 49, 29, 7, -40 },
  { 5643, 23, 49, 29, 3, -40 },
  { 5784, 16, 49, 29, 6, -40 },
  { 5882, 27, 20, 29, 1, -35 },
  { 5950, 28, 5, 29, 0, 4 },
  { 5968, 12, 11, 29, 9, -40 },
  { 5985, 22, 28, 29, 3, -27 },
  { 6062, 23, 41, 29, 4, -40 },
  { 6180, 23, 28, 29, 3, -27 },
  { 6261, 23, 41, 29, 2, -40 },
  { 6379, 24, 28, 29, 2, -27 },
  { 6463, 26, 40, 29, 2, -40 },
  { 6593, 23, 37, 29, 2, -27 },
  { 6700, 21, 40, 29, 4, -40 },
  { 6805, 24, 40, 29, 2, -39 },
  { 6925, 20, 49, 29, 3, -39 },
  { 7048, 24, 40, 29, 4, -40 },
  { 7168, 24, 40, 29, 2, -39 },
  { 7288, 25, 27, 29, 2, -27 },
  { 7373, 21, 27, 29, 4, -27 },
  { 7444, 25, 28, 29, 2, -27 },
  { 7532, 23, 36, 29, 4, -27 },
  { 7636, 23, 36, 29, 2, -27 },
  { 7740, 21, 27, 29, 5, -27 },
  { 7811, 22, 28, 29, 3, -27 },
  { 7888, 25, 36, 29, 2, -35 },
  { 8001, 21, 28, 29, 4, -27 },
  { 8075, 26, 27, 29, 1, -27 },
  { 8163, 27, 27, 29, 1, -27 },
  { 8255, 26, 27, 29, 1, -27 },
  { 8343, 26, 37, 29, 1, -27 },
  { 8464, 21, 27, 29, 4, -27 },
  { 8535, 21, 49, 29, 4, -40 },
  { 8664, 7, 49, 29, 11, -40 },
  { 8707, 21, 49, 29, 4, -40 },
  { 8836, 26, 10, 29, 1, -20 },
};

const GFXfont UbuntuSansMono_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold51pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UBUNTUSANSMONO_SEMIBOLD51PT7B_H_
