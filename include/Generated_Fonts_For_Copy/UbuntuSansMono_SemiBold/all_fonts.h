#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/UbuntuSansMono_SemiBold
// Headers: 67

#include "UbuntuSansMono_SemiBold6pt7b.h"
#include "UbuntuSansMono_SemiBold7pt7b.h"
#include "UbuntuSansMono_SemiBold8pt7b.h"
#include "UbuntuSansMono_SemiBold9pt7b.h"
#include "UbuntuSansMono_SemiBold10pt7b.h"
#include "UbuntuSansMono_SemiBold11pt7b.h"
#include "UbuntuSansMono_SemiBold12pt7b.h"
#include "UbuntuSansMono_SemiBold13pt7b.h"
#include "UbuntuSansMono_SemiBold14pt7b.h"
#include "UbuntuSansMono_SemiBold15pt7b.h"
#include "UbuntuSansMono_SemiBold16pt7b.h"
#include "UbuntuSansMono_SemiBold17pt7b.h"
#include "UbuntuSansMono_SemiBold18pt7b.h"
#include "UbuntuSansMono_SemiBold19pt7b.h"
#include "UbuntuSansMono_SemiBold20pt7b.h"
#include "UbuntuSansMono_SemiBold21pt7b.h"
#include "UbuntuSansMono_SemiBold22pt7b.h"
#include "UbuntuSansMono_SemiBold23pt7b.h"
#include "UbuntuSansMono_SemiBold24pt7b.h"
#include "UbuntuSansMono_SemiBold25pt7b.h"
#include "UbuntuSansMono_SemiBold26pt7b.h"
#include "UbuntuSansMono_SemiBold27pt7b.h"
#include "UbuntuSansMono_SemiBold28pt7b.h"
#include "UbuntuSansMono_SemiBold29pt7b.h"
#include "UbuntuSansMono_SemiBold30pt7b.h"
#include "UbuntuSansMono_SemiBold31pt7b.h"
#include "UbuntuSansMono_SemiBold32pt7b.h"
#include "UbuntuSansMono_SemiBold33pt7b.h"
#include "UbuntuSansMono_SemiBold34pt7b.h"
#include "UbuntuSansMono_SemiBold35pt7b.h"
#include "UbuntuSansMono_SemiBold36pt7b.h"
#include "UbuntuSansMono_SemiBold37pt7b.h"
#include "UbuntuSansMono_SemiBold38pt7b.h"
#include "UbuntuSansMono_SemiBold39pt7b.h"
#include "UbuntuSansMono_SemiBold40pt7b.h"
#include "UbuntuSansMono_SemiBold41pt7b.h"
#include "UbuntuSansMono_SemiBold42pt7b.h"
#include "UbuntuSansMono_SemiBold43pt7b.h"
#include "UbuntuSansMono_SemiBold44pt7b.h"
#include "UbuntuSansMono_SemiBold45pt7b.h"
#include "UbuntuSansMono_SemiBold46pt7b.h"
#include "UbuntuSansMono_SemiBold47pt7b.h"
#include "UbuntuSansMono_SemiBold48pt7b.h"
#include "UbuntuSansMono_SemiBold49pt7b.h"
#include "UbuntuSansMono_SemiBold50pt7b.h"
#include "UbuntuSansMono_SemiBold51pt7b.h"
#include "UbuntuSansMono_SemiBold52pt7b.h"
#include "UbuntuSansMono_SemiBold53pt7b.h"
#include "UbuntuSansMono_SemiBold54pt7b.h"
#include "UbuntuSansMono_SemiBold55pt7b.h"
#include "UbuntuSansMono_SemiBold56pt7b.h"
#include "UbuntuSansMono_SemiBold57pt7b.h"
#include "UbuntuSansMono_SemiBold58pt7b.h"
#include "UbuntuSansMono_SemiBold59pt7b.h"
#include "UbuntuSansMono_SemiBold60pt7b.h"
#include "UbuntuSansMono_SemiBold61pt7b.h"
#include "UbuntuSansMono_SemiBold62pt7b.h"
#include "UbuntuSansMono_SemiBold63pt7b.h"
#include "UbuntuSansMono_SemiBold64pt7b.h"
#include "UbuntuSansMono_SemiBold65pt7b.h"
#include "UbuntuSansMono_SemiBold66pt7b.h"
#include "UbuntuSansMono_SemiBold67pt7b.h"
#include "UbuntuSansMono_SemiBold68pt7b.h"
#include "UbuntuSansMono_SemiBold69pt7b.h"
#include "UbuntuSansMono_SemiBold70pt7b.h"
#include "UbuntuSansMono_SemiBold71pt7b.h"
#include "UbuntuSansMono_SemiBold72pt7b.h"
