#ifndef _UBUNTUSANSMONO_SEMIBOLD30PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0x9C, 0xE7, 0x38, 0x00, 0x77,
  0xFF, 0xFF, 0x00, 0xF1, 0xFE, 0x3F, 0xC7, 0x78, 0xEF, 0x1C, 0xE3, 0x9C,
  0x73, 0x8E, 0x61, 0xC0, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xC0,
  0xE3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0xC7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xE0,
  0xF1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x03, 0xFE, 0x1F, 0xFC, 0xFF, 0xE7, 0xC1, 0x9E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x74, 0x03, 0xDF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0xBF, 0x03, 0x99, 0xC3,
  0x9C, 0xE1, 0x8E, 0x71, 0xC7, 0x39, 0xC1, 0x9C, 0xC0, 0xEE, 0xE0, 0x7E,
  0xE0, 0x1E, 0x70, 0x00, 0x70, 0x00, 0x73, 0x80, 0x3B, 0xE0, 0x3B, 0xB8,
  0x39, 0xCC, 0x1C, 0xC6, 0x1C, 0x63, 0x0C, 0x31, 0x8E, 0x1D, 0xCE, 0x07,
  0xEE, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0xF7, 0x83, 0xC7, 0x07, 0x8E,
  0x0F, 0x1C, 0x1E, 0x38, 0x1C, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0xFC, 0x73,
  0xFC, 0xE7, 0x79, 0xDE, 0x7B, 0xB8, 0x7E, 0x70, 0x7C, 0xE0, 0x79, 0xE1,
  0xF1, 0xFF, 0xF3, 0xFE, 0xF3, 0xF9, 0xE0, 0xFF, 0xFF, 0x77, 0x77, 0x77,
  0x00, 0x80, 0x38, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1C, 0x01, 0x00, 0x20, 0x0E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x07, 0x00, 0x40, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x2F, 0x77, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0x1D, 0xC1, 0xEF, 0x1F, 0x7C, 0x71, 0xC1, 0x8C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x1E, 0x3E, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E, 0xFC, 0x78, 0x60, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xE3, 0xC7, 0x83, 0xCE, 0x07, 0x9C, 0x07, 0x78, 0x0E, 0xF3, 0x9D,
  0xE7, 0x3B, 0xCE, 0x7F, 0x9C, 0xFF, 0x01, 0xDE, 0x03, 0x9C, 0x07, 0x38,
  0x1E, 0x78, 0x3C, 0xF8, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x03,
  0x80, 0x3C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F, 0xC1, 0xDE, 0x08, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xC3,
  0xFF, 0x3F, 0xFD, 0xE3, 0xE4, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x87, 0xFF,
  0x3F, 0xFC, 0xC3, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x07, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1C,
  0x78, 0x70, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0x01, 0xE7, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE0, 0x00, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xE0, 0x3E, 0x01, 0xE0,
  0x1E, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0x78, 0x3D, 0xC0, 0xF7, 0x83, 0xDE,
  0x0E, 0x3E, 0x78, 0xFF, 0xC1, 0xFE, 0x0F, 0xFE, 0x78, 0xFD, 0xC0, 0xF7,
  0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xE0, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0,
  0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x81, 0xDF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x3C, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x1F, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xF3, 0xE7, 0xCF, 0x87, 0x1D,
  0xFB, 0xE7, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x1F, 0x81, 0xFF, 0x3F, 0xE3,
  0xFE, 0x0F, 0xC0, 0x3C, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x40, 0x01, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xC0, 0x0F, 0x01, 0xFC, 0x1F, 0xE3, 0xFE, 0x3F, 0xE0, 0x7C, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0x7F, 0x9F, 0xFB, 0xFF, 0xE0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xDC, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0xBF, 0x9E, 0x7F, 0x38, 0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7,
  0xF3, 0xCF, 0xE7, 0xDF, 0xC7, 0xFD, 0xC7, 0xFB, 0x83, 0xC7, 0x80, 0x07,
  0x80, 0x07, 0xC1, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x40, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D, 0xE0,
  0x1C, 0xF0, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC1,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x78, 0x0E, 0x3C, 0x07, 0x9E,
  0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C,
  0x7C, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF3, 0xF3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xFC, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B,
  0xC3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF1, 0xF0, 0x67, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x08, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFF, 0x0F, 0xFE, 0x3C, 0x7C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF8,
  0x3F, 0xF1, 0xFF, 0xCF, 0x83, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xDE, 0x07, 0x78, 0x1C, 0xF0, 0x73, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF2, 0x0F, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0xE0, 0x7F,
  0x81, 0xEE, 0x0F, 0x38, 0x3C, 0xE1, 0xE3, 0x8F, 0x0E, 0x7C, 0x39, 0xE0,
  0xEF, 0x03, 0xF8, 0x0F, 0xF0, 0x3B, 0xE0, 0xE7, 0x83, 0x8F, 0x0E, 0x3E,
  0x38, 0x7C, 0xE0, 0xF3, 0x83, 0xEE, 0x07, 0xB8, 0x0F, 0xE0, 0x3C, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xE7, 0xC7, 0xCD, 0x8F, 0x9B, 0x3F, 0x77, 0x7E, 0xEE, 0xDD,
  0xCF, 0xBB, 0x9F, 0x77, 0x3C, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xE0, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFD, 0xC7,
  0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0x80, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0E, 0x78, 0x3C, 0xF0, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x3F, 0xBF, 0xFC, 0xFF,
  0xE3, 0xFC, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83,
  0xCE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x78, 0x3C, 0xF0,
  0xF8, 0xFF, 0xE1, 0xFF, 0x80, 0xFE, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF9,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x10, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C,
  0x7C, 0xF0, 0xFB, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xCF, 0x0F, 0x1E, 0x3C, 0x38, 0xF0, 0xF3,
  0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x9F, 0x06, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x3D, 0x80, 0xF7, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xDC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF0, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x38,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0F, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE3, 0x9F,
  0xCF, 0x3F, 0x9F, 0x77, 0x3E, 0xEE, 0x6D, 0xDD, 0xDF, 0x9B, 0x3F, 0x36,
  0x3E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0xF0,
  0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xE3, 0xC3, 0xC7, 0x83, 0xDE, 0x07, 0xB8,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03,
  0xDE, 0x07, 0xBC, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x79, 0xE0, 0xF7, 0x80,
  0xFF, 0x01, 0xE0, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x1C, 0x1C, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x07, 0x70, 0x07,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xDE, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x3D, 0xF0, 0x7F, 0xC0, 0x79, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0xE3,
  0xF1, 0xF0, 0xC0, 0x80, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0x81, 0xE0, 0x07,
  0x80, 0x3C, 0x1D, 0xE7, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0xFF,
  0x07, 0xFF, 0xFD, 0xFF, 0xE7, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF,
  0x8F, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xEF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0xE7, 0xFF, 0x9F, 0x02, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x09, 0xFF, 0xE3,
  0xFF, 0x83, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE1, 0xF7, 0x3F, 0xFB, 0xFF, 0xDF, 0x1E, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDE, 0x0E, 0xF8, 0x77,
  0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x01,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7C, 0x10, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF,
  0xDF, 0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x83, 0xDE, 0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0x00,
  0x39, 0x01, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x18, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF8, 0xFF,
  0xE7, 0xFF, 0xBC, 0x7D, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x20, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x41, 0xEF, 0xFF, 0xFF, 0x7F, 0xC0, 0xE0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x1F, 0xF0, 0xFB, 0xC3, 0xCF, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0,
  0xFB, 0xC1, 0xEF, 0x03, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x20, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7E, 0x79, 0xFF, 0xFB, 0xFF, 0xF7, 0x3C, 0xFE, 0x38, 0xFC, 0x71,
  0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x7F, 0xC7, 0xFF, 0x3F, 0xFD,
  0xE3, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x0F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xE7, 0x87, 0xC7, 0xFF, 0x0F,
  0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B,
  0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E,
  0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xDF,
  0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xDE, 0x0F, 0x78, 0x3D, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0xE1, 0xFF,
  0x9F, 0xFD, 0xF0, 0x6F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xFF, 0xFB, 0xFF, 0xCF, 0xF8, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x04, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xBF, 0xFC,
  0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xE7, 0x83,
  0xCF, 0x07, 0x0E, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x3D, 0xE0, 0x7B, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x71, 0xC7, 0x71, 0xC7, 0x73, 0xE7, 0x73,
  0xE7, 0x73, 0xE6, 0x37, 0x6E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0xF0, 0x1E, 0xF0, 0x78, 0xE1, 0xE1, 0xE3,
  0xC1, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x7B, 0xC0, 0xE7, 0x83, 0xC7, 0x8F, 0x07, 0x9C, 0x0F, 0x78, 0x0F, 0xF0,
  0x1E, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x1E,
  0x0E, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x0E, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xE0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x3F, 0xC1, 0xFC, 0x0F, 0x80, 0x00, 0x1C, 0x08, 0x7E, 0x1D, 0xFF, 0x7F,
  0xFF, 0xEE, 0x1F, 0xCC, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 11, 9, 17, 3, -23 },
  { 28, 15, 21, 17, 1, -21 },
  { 68, 14, 26, 17, 1, -23 },
  { 114, 17, 21, 17, 0, -21 },
  { 159, 15, 21, 17, 1, -21 },
  { 199, 4, 10, 17, 6, -23 },
  { 204, 11, 30, 17, 3, -24 },
  { 246, 11, 30, 17, 3, -24 },
  { 288, 13, 13, 17, 2, -21 },
  { 310, 14, 15, 17, 1, -16 },
  { 337, 8, 10, 17, 4, -5 },
  { 347, 9, 3, 17, 4, -10 },
  { 351, 5, 5, 17, 6, -5 },
  { 355, 13, 29, 17, 2, -23 },
  { 403, 15, 21, 17, 1, -21 },
  { 443, 13, 21, 17, 2, -21 },
  { 478, 13, 21, 17, 2, -21 },
  { 513, 13, 21, 17, 2, -21 },
  { 548, 15, 21, 17, 1, -21 },
  { 588, 14, 21, 17, 1, -21 },
  { 625, 13, 21, 17, 2, -21 },
  { 660, 13, 21, 17, 2, -21 },
  { 695, 14, 21, 17, 1, -21 },
  { 732, 13, 21, 17, 2, -21 },
  { 767, 5, 15, 17, 6, -15 },
  { 777, 7, 20, 17, 4, -15 },
  { 795, 14, 15, 17, 2, -16 },
  { 822, 14, 10, 17, 1, -14 },
  { 840, 14, 15, 17, 1, -16 },
  { 867, 11, 21, 17, 3, -21 },
  { 896, 15, 26, 17, 1, -21 },
  { 945, 17, 21, 17, 0, -21 },
  { 990, 14, 21, 17, 2, -21 },
  { 1027, 15, 21, 17, 1, -21 },
  { 1067, 14, 21, 17, 2, -21 },
  { 1104, 13, 21, 17, 2, -21 },
  { 1139, 13, 21, 17, 2, -21 },
  { 1174, 14, 21, 17, 1, -21 },
  { 1211, 14, 21, 17, 1, -21 },
  { 1248, 13, 21, 17, 2, -21 },
  { 1283, 13, 21, 17, 2, -21 },
  { 1318, 14, 21, 17, 2, -21 },
  { 1355, 12, 21, 17, 3, -21 },
  { 1387, 15, 21, 17, 1, -21 },
  { 1427, 13, 21, 17, 2, -21 },
  { 1462, 15, 21, 17, 1, -21 },
  { 1502, 14, 21, 17, 2, -21 },
  { 1539, 15, 27, 17, 1, -21 },
  { 1590, 14, 21, 17, 2, -21 },
  { 1627, 14, 21, 17, 1, -21 },
  { 1664, 15, 21, 17, 1, -21 },
  { 1704, 14, 21, 17, 1, -21 },
  { 1741, 16, 21, 17, 0, -21 },
  { 1783, 15, 21, 17, 1, -21 },
  { 1823, 15, 21, 17, 1, -21 },
  { 1863, 16, 21, 17, 0, -21 },
  { 1905, 13, 21, 17, 2, -21 },
  { 1940, 9, 29, 17, 4, -23 },
  { 1973, 13, 29, 17, 2, -23 },
  { 2021, 9, 29, 17, 4, -23 },
  { 2054, 15, 12, 17, 1, -21 },
  { 2077, 17, 4, 17, 0, 2 },
  { 2086, 7, 6, 17, 5, -23 },
  { 2092, 13, 16, 17, 2, -16 },
  { 2118, 14, 23, 17, 2, -23 },
  { 2159, 14, 16, 17, 2, -16 },
  { 2187, 13, 23, 17, 1, -23 },
  { 2225, 15, 16, 17, 1, -16 },
  { 2255, 15, 23, 17, 1, -23 },
  { 2299, 14, 22, 17, 1, -16 },
  { 2338, 13, 23, 17, 2, -23 },
  { 2376, 15, 23, 17, 1, -23 },
  { 2420, 11, 29, 17, 2, -23 },
  { 2460, 14, 23, 17, 2, -23 },
  { 2501, 15, 23, 17, 1, -23 },
  { 2545, 15, 16, 17, 1, -16 },
  { 2575, 13, 16, 17, 2, -16 },
  { 2601, 15, 16, 17, 1, -16 },
  { 2631, 14, 22, 17, 2, -16 },
  { 2670, 14, 22, 17, 1, -16 },
  { 2709, 12, 16, 17, 3, -16 },
  { 2733, 13, 16, 17, 2, -16 },
  { 2759, 15, 20, 17, 1, -20 },
  { 2797, 13, 16, 17, 2, -16 },
  { 2823, 15, 16, 17, 1, -16 },
  { 2853, 16, 16, 17, 0, -16 },
  { 2885, 15, 16, 17, 1, -16 },
  { 2915, 15, 22, 17, 1, -16 },
  { 2957, 13, 16, 17, 2, -16 },
  { 2983, 13, 29, 17, 2, -23 },
  { 3031, 3, 29, 17, 7, -23 },
  { 3042, 13, 29, 17, 2, -23 },
  { 3090, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_SEMIBOLD30PT7B_H_
