#ifndef _UBUNTUSANSMONO_SEMIBOLD13PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x83, 0xE0, 0xDE, 0xD6, 0xB0, 0x36, 0x6B, 0xFF, 0xF2,
  0xDF, 0xFF, 0xA4, 0x58, 0x21, 0xEF, 0xB0, 0xC1, 0xE1, 0xC3, 0xFB, 0xC2,
  0x00, 0x63, 0x4A, 0xB7, 0x41, 0x07, 0xCA, 0xA5, 0xCE, 0x38, 0x91, 0x23,
  0xC7, 0x6B, 0xB3, 0x66, 0x7E, 0xEA, 0x19, 0x98, 0xC4, 0x63, 0x08, 0x43,
  0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x8C, 0x63, 0x11, 0x89, 0xC0, 0x22, 0xAF,
  0xDC, 0xD9, 0x40, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0x6D, 0xE0, 0xFF, 0xEC,
  0x0C, 0x61, 0x84, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x30, 0x7B, 0x68, 0xEB,
  0xAE, 0x38, 0xF6, 0x78, 0x31, 0xCF, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0xFA,
  0x60, 0x86, 0x31, 0x8C, 0x30, 0xFC, 0xF2, 0x60, 0x86, 0x78, 0x20, 0xE6,
  0xF8, 0x0C, 0x38, 0xF1, 0x66, 0xCF, 0xFF, 0x86, 0x0C, 0x7A, 0x11, 0xCF,
  0x84, 0x33, 0xF0, 0x39, 0xCC, 0x3C, 0xFA, 0x38, 0xF2, 0x78, 0xFC, 0x21,
  0x84, 0x30, 0x86, 0x18, 0x60, 0x7B, 0x28, 0xB6, 0x73, 0x68, 0xF3, 0xF8,
  0x7B, 0x68, 0xE3, 0xFD, 0xA1, 0x9C, 0xE0, 0xEC, 0x01, 0xD8, 0xEC, 0x01,
  0xDB, 0xC0, 0x08, 0xFE, 0x30, 0x78, 0x70, 0xFC, 0x00, 0x3F, 0x83, 0x83,
  0xC7, 0x73, 0x00, 0xFC, 0xC6, 0x33, 0x30, 0x0C, 0x60, 0x3C, 0xCD, 0x1E,
  0xFD, 0x7E, 0xF5, 0xAF, 0x40, 0xC0, 0x70, 0x18, 0x70, 0xA1, 0x66, 0xCF,
  0x9F, 0xA3, 0xC6, 0xFA, 0x68, 0xA6, 0xFA, 0x38, 0xE7, 0xF8, 0x3E, 0xC5,
  0x02, 0x0C, 0x08, 0x10, 0x31, 0x3E, 0xF2, 0x68, 0xE3, 0x8E, 0x38, 0xE6,
  0xF0, 0xFB, 0x0C, 0x30, 0xFB, 0x0C, 0x30, 0xFC, 0xFE, 0x31, 0x8F, 0xE3,
  0x18, 0xC0, 0x3E, 0xC5, 0x02, 0x0C, 0x68, 0xD1, 0xB3, 0x3E, 0x8E, 0x38,
  0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xF9, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x78,
  0x42, 0x10, 0x84, 0x33, 0xF0, 0x8E, 0x6B, 0x28, 0xE2, 0xC9, 0xA2, 0x8C,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x44, 0xD9, 0xBB, 0x75, 0xEA,
  0xF1, 0xE3, 0xC6, 0x8F, 0x3C, 0xEB, 0xAE, 0x79, 0xE3, 0x8C, 0x3C, 0xC9,
  0x1E, 0x3C, 0x78, 0xD1, 0xB6, 0x3C, 0xFA, 0x78, 0xE3, 0xFB, 0xC8, 0x20,
  0x80, 0x3C, 0xD9, 0x1E, 0x3C, 0x78, 0xD1, 0xB2, 0x3C, 0x30, 0x38, 0xF2,
  0x68, 0xA2, 0xFB, 0xC9, 0xA2, 0x8C, 0x7B, 0x28, 0x38, 0x78, 0x60, 0xE2,
  0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xF2, 0xF8, 0xC6, 0x8D, 0x1B, 0x26, 0xC5, 0x8A, 0x1C, 0x18,
  0xC7, 0x8F, 0x1A, 0xB5, 0xED, 0xDB, 0xB6, 0x44, 0xC6, 0xD8, 0xB1, 0xC1,
  0x87, 0x1B, 0x32, 0xC6, 0xC6, 0x8D, 0xB1, 0x63, 0x83, 0x04, 0x08, 0x10,
  0xF8, 0x61, 0x8C, 0x21, 0x84, 0x30, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x83, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0x18, 0x70, 0xB3, 0x2C, 0x60, 0xFE, 0x5C, 0x80,
  0xF4, 0xC3, 0xF8, 0xE7, 0xE0, 0xC3, 0x0C, 0x3E, 0xDB, 0x3C, 0xF3, 0xDB,
  0xE0, 0x7F, 0xAC, 0x20, 0x83, 0x17, 0xC0, 0x04, 0x10, 0x4F, 0x6D, 0x1C,
  0x51, 0x64, 0xF0, 0x3C, 0xD9, 0x1F, 0xF4, 0x0C, 0x8F, 0x00, 0x3D, 0x96,
  0x3F, 0xFD, 0x86, 0x18, 0x61, 0x80, 0x3D, 0x94, 0x71, 0x45, 0xF3, 0x43,
  0x7C, 0xC6, 0x31, 0xED, 0xE7, 0x39, 0xCE, 0x40, 0x61, 0x80, 0x38, 0xE0,
  0x82, 0x08, 0x24, 0xF0, 0x11, 0xC1, 0xFF, 0x8C, 0x63, 0x18, 0xC7, 0xE0,
  0xC3, 0x0C, 0x33, 0xDB, 0xCE, 0x3C, 0xDB, 0x30, 0xE0, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x24, 0xF0, 0xFD, 0xAF, 0x5E, 0xBC, 0x78, 0xF1, 0x80, 0xF6,
  0xF3, 0x9C, 0xE7, 0x20, 0x38, 0xD9, 0x1E, 0x34, 0x6D, 0x8F, 0x00, 0xF3,
  0x6C, 0xF3, 0xCF, 0x2F, 0xB0, 0xC0, 0x3D, 0x94, 0x71, 0x45, 0x97, 0xC1,
  0x04, 0x7F, 0xEC, 0x30, 0xC3, 0x0C, 0x00, 0x7E, 0x70, 0xE1, 0xC7, 0xE0,
  0x61, 0x8F, 0xFF, 0x61, 0x86, 0x19, 0x3C, 0xCE, 0x73, 0x9C, 0xE5, 0xE0,
  0xC6, 0x8D, 0x93, 0x62, 0x87, 0x06, 0x00, 0xC3, 0x87, 0x4A, 0xF6, 0xED,
  0x99, 0x00, 0xC6, 0xD8, 0xE0, 0xC3, 0x8D, 0xB1, 0x80, 0x46, 0xC9, 0x91,
  0x63, 0xC7, 0x06, 0x08, 0xF0, 0xFF, 0xCC, 0x46, 0x63, 0xE0, 0x39, 0x08,
  0x42, 0x73, 0x84, 0x21, 0x08, 0x70, 0xFF, 0xF0, 0xE1, 0x8C, 0x63, 0x0C,
  0x66, 0x31, 0x8D, 0xC0, 0x73, 0xBC,
};

const GFXglyph UbuntuSansMono_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 5, 4, 7, 1, -10 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 7, 1, -10 },
  { 25, 7, 9, 7, 0, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 2, 4, 7, 3, -10 },
  { 42, 5, 12, 7, 1, -10 },
  { 50, 5, 12, 7, 1, -10 },
  { 58, 6, 6, 7, 1, -9 },
  { 63, 6, 6, 7, 1, -7 },
  { 68, 3, 4, 7, 2, -2 },
  { 70, 4, 2, 7, 2, -5 },
  { 71, 3, 2, 7, 2, -2 },
  { 72, 6, 12, 7, 1, -10 },
  { 81, 6, 9, 7, 1, -9 },
  { 88, 6, 9, 7, 1, -9 },
  { 95, 6, 9, 7, 1, -9 },
  { 102, 6, 9, 7, 1, -9 },
  { 109, 7, 9, 7, 0, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 6, 9, 7, 1, -9 },
  { 130, 6, 9, 7, 1, -9 },
  { 137, 6, 9, 7, 1, -9 },
  { 144, 6, 9, 7, 1, -9 },
  { 151, 3, 7, 7, 2, -7 },
  { 154, 3, 9, 7, 2, -7 },
  { 158, 6, 6, 7, 1, -7 },
  { 163, 6, 4, 7, 1, -6 },
  { 166, 6, 6, 7, 1, -7 },
  { 171, 5, 9, 7, 1, -9 },
  { 177, 7, 11, 7, 0, -9 },
  { 187, 7, 9, 7, 0, -9 },
  { 195, 6, 9, 7, 1, -9 },
  { 202, 7, 9, 7, 0, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 6, 9, 7, 1, -9 },
  { 224, 5, 9, 7, 1, -9 },
  { 230, 7, 9, 7, 0, -9 },
  { 238, 6, 9, 7, 1, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 6, 9, 7, 1, -9 },
  { 264, 6, 9, 7, 1, -9 },
  { 271, 7, 9, 7, 0, -9 },
  { 279, 6, 9, 7, 1, -9 },
  { 286, 7, 9, 7, 0, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 7, 11, 7, 0, -9 },
  { 311, 6, 9, 7, 1, -9 },
  { 318, 6, 9, 7, 1, -9 },
  { 325, 7, 9, 7, 0, -9 },
  { 333, 6, 9, 7, 1, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 7, 9, 7, 0, -9 },
  { 356, 7, 9, 7, 0, -9 },
  { 364, 7, 9, 7, 0, -9 },
  { 372, 6, 9, 7, 1, -9 },
  { 379, 4, 12, 7, 2, -10 },
  { 385, 6, 12, 7, 1, -10 },
  { 394, 4, 12, 7, 2, -10 },
  { 400, 7, 5, 7, 0, -9 },
  { 405, 7, 1, 7, 0, 1 },
  { 406, 3, 3, 7, 2, -10 },
  { 408, 5, 7, 7, 1, -7 },
  { 413, 6, 10, 7, 1, -10 },
  { 421, 6, 7, 7, 1, -7 },
  { 427, 6, 10, 7, 0, -10 },
  { 435, 7, 7, 7, 0, -7 },
  { 442, 6, 10, 7, 1, -10 },
  { 450, 6, 9, 7, 0, -7 },
  { 457, 5, 10, 7, 1, -10 },
  { 464, 6, 10, 7, 1, -10 },
  { 472, 5, 12, 7, 1, -10 },
  { 480, 6, 10, 7, 1, -10 },
  { 488, 6, 10, 7, 1, -10 },
  { 496, 7, 7, 7, 0, -7 },
  { 503, 5, 7, 7, 1, -7 },
  { 508, 7, 7, 7, 0, -7 },
  { 515, 6, 9, 7, 1, -7 },
  { 522, 6, 9, 7, 0, -7 },
  { 529, 6, 7, 7, 1, -7 },
  { 535, 5, 7, 7, 1, -7 },
  { 540, 6, 9, 7, 1, -9 },
  { 547, 5, 7, 7, 1, -7 },
  { 552, 7, 7, 7, 0, -7 },
  { 559, 7, 7, 7, 0, -7 },
  { 566, 7, 7, 7, 0, -7 },
  { 573, 7, 9, 7, 0, -7 },
  { 581, 5, 7, 7, 1, -7 },
  { 586, 5, 12, 7, 1, -10 },
  { 594, 1, 12, 7, 3, -10 },
  { 596, 5, 12, 7, 1, -10 },
  { 604, 7, 2, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_SEMIBOLD13PT7B_H_
