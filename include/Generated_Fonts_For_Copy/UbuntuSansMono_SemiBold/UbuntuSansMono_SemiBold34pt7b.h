#ifndef _UBUNTUSANSMONO_SEMIBOLD34PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB9, 0xCE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF0, 0xEC, 0x1C, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x70, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x1E, 0x07, 0x0E,
  0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFC, 0xF8,
  0x04, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1E, 0xE0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x01, 0xE7,
  0xE0, 0x39, 0xFC, 0x0E, 0x39, 0xC1, 0xC6, 0x38, 0x71, 0xC7, 0x1C, 0x38,
  0xE3, 0x83, 0x1C, 0xE0, 0x77, 0xBC, 0x0F, 0xE7, 0x00, 0xFD, 0xC0, 0x06,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x9F, 0x00, 0xF7, 0xF0, 0x1C, 0xEE, 0x07,
  0x39, 0xC0, 0xE7, 0x18, 0x38, 0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x9C, 0x70,
  0x7B, 0x9C, 0x07, 0xF7, 0x80, 0x7C, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFE, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xE0,
  0x78, 0xF0, 0x3C, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0xE3, 0xF8,
  0x73, 0xFE, 0x39, 0xEF, 0xBD, 0xE3, 0xFE, 0xF0, 0xFE, 0x78, 0x3F, 0x3C,
  0x0F, 0x9E, 0x07, 0xCF, 0x87, 0xF3, 0xFF, 0xF8, 0xFF, 0xBE, 0x3F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFD, 0xEE, 0x73, 0x9C, 0x00, 0x40, 0x1E, 0x03, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1E, 0x00, 0xC0, 0x40, 0x0E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x07, 0x80, 0x60, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x07, 0x38, 0xDF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x0F, 0xC0, 0x7B, 0xC1, 0xF7, 0xC3, 0xC7, 0xC3, 0x8E, 0x02, 0x08, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x3F, 0x3F, 0x3F,
  0x3F, 0x1F, 0x07, 0x0E, 0x3E, 0xFC, 0xF0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x63, 0xBC, 0x71, 0xFE, 0x7C, 0xFF, 0x3E,
  0x7F, 0x8E, 0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x03, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3D, 0xF0, 0x43, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE7, 0xFF, 0xE7, 0x07, 0xC8, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE6, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFE, 0x0F,
  0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1E, 0xF0, 0x0F,
  0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0x83, 0xC3,
  0xC1, 0xE3, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x3F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xFE, 0x0F, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x04, 0x00, 0x00, 0x0C,
  0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF7, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDE, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7,
  0xC7, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3,
  0xF7, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3C, 0xF8,
  0x79, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xBF, 0x9E, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF, 0xFF, 0x9F,
  0xFF, 0x0F, 0xF8, 0x03, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xF7,
  0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7B, 0xF1, 0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x87, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3E, 0x00, 0x38, 0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0xBF, 0xFF, 0x7E, 0xF8, 0x1C, 0x3E, 0x7F, 0x7F, 0x3F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x3E, 0x7F, 0x7F, 0x3F, 0x3F,
  0x0E, 0x1E, 0x7C, 0xF8, 0xF0, 0x80, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x7E,
  0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0x00, 0x3E, 0x01, 0xFC, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x3E,
  0x00, 0x30, 0x00, 0x3F, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF4, 0x0F, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x7C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0x83, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1E, 0xE0, 0x7F, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x78, 0xFE, 0x3C, 0x7F, 0x1C, 0x3F,
  0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xE3, 0xFC, 0xF1, 0xFE, 0x7F,
  0xF7, 0x1F, 0xFB, 0x87, 0xFD, 0xE0, 0x70, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07,
  0x9E, 0x00, 0xF7, 0xC0, 0x1F, 0x3F, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF1, 0xFE, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xE3, 0xF0, 0x11, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x70, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x3F,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3E, 0xF0, 0x7C, 0xF3, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0,
  0x31, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x03, 0xC7, 0xC1, 0xE3, 0xF0, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x40, 0x00, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xD0,
  0x1F, 0x70, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x06, 0x00, 0xF0, 0x1F,
  0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC7,
  0xC1, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x81, 0xE3, 0xE0, 0xF1, 0xF8, 0x78, 0x7C,
  0x3C, 0x1F, 0x1E, 0x07, 0xCF, 0x03, 0xE7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x0F,
  0x3C, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xF1, 0xF9, 0xF8,
  0xFC, 0xEC, 0x7E, 0x77, 0x77, 0x3B, 0xBB, 0x9D, 0xDD, 0xCE, 0x7C, 0xEF,
  0x3E, 0x7F, 0x9F, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF,
  0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x07, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0,
  0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07,
  0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xE3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xE3,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x3F, 0x80, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF3, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0x0F, 0xF0, 0x7F, 0xF9,
  0xFF, 0xF3, 0xFF, 0xEF, 0x80, 0x9E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7A, 0x00, 0xFF, 0x07, 0xFF,
  0xFF, 0xBF, 0xFF, 0x3F, 0xF8, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF,
  0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x03, 0x00, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF8, 0x0F, 0x9E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x0F, 0x38, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0xE3,
  0xFC, 0xF9, 0xFE, 0x7C, 0xFF, 0x3E, 0x7B, 0x9B, 0x39, 0xDD, 0xDC, 0xEE,
  0xEE, 0x76, 0x37, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x07, 0xBC, 0x07, 0xDF, 0x03,
  0xC7, 0x83, 0xC3, 0xE1, 0xE0, 0xF1, 0xE0, 0x7C, 0xF0, 0x1E, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x3C, 0x0F, 0x1E, 0x0F, 0x87, 0x87, 0x83,
  0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x80, 0xF9, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F, 0x07, 0xC3, 0xC1,
  0xE0, 0xF8, 0xF8, 0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF7, 0x80, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7D, 0xF0, 0x3C, 0x7C, 0x3E, 0x3E, 0x3E, 0x0F, 0x9F,
  0x03, 0xDF, 0x01, 0xF7, 0x00, 0x78, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x70, 0xFC, 0x7E, 0x1F, 0x0E, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF1, 0x87, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x87,
  0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFE, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x9E, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC1,
  0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xF7, 0x81, 0xEF, 0x83, 0xDF, 0xC7, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xE7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x38, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xF8,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F,
  0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xDF, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x70, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7B, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xF0, 0x0F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xE6, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x81, 0xF7,
  0x9F, 0xBF, 0xFB, 0xFF, 0x8F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xE0,
  0xFB, 0xC3, 0xE7, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8, 0x3D, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x03, 0xDF, 0x07, 0x9F, 0x0F, 0x1F, 0x1E, 0x3E, 0x3C,
  0x3E, 0x78, 0x3E, 0xF0, 0x3F, 0xE0, 0x7C, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC6, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x7F,
  0x3E, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE, 0xFD, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F,
  0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF0, 0x7B, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xF0, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xF7,
  0x80, 0xF3, 0xE0, 0xF8, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xCF, 0xCF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xDE, 0x0F, 0xBE, 0x3F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F,
  0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xF1, 0xC7,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xDC, 0x0F, 0xFF, 0xFE, 0xFF, 0xF8,
  0xFF, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xC6, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xEF, 0x07, 0xDF, 0x8F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x3E, 0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE1, 0xC3,
  0xBC, 0x78, 0xEF, 0x3E, 0x7B, 0xCF, 0x9E, 0xF3, 0xE7, 0x9C, 0xDD, 0xC7,
  0x77, 0x71, 0xDD, 0xDC, 0x76, 0x77, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0xF8, 0x0F, 0xBC, 0x07, 0x8F, 0x07,
  0x87, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC0, 0xF1, 0xF0,
  0xF0, 0x78, 0xF8, 0x3E, 0x78, 0x0F, 0x78, 0x07, 0xC0, 0x78, 0x0F, 0xBC,
  0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8, 0x78,
  0x3C, 0x3C, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x04, 0x7C, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x80, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xC1, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC3, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0x03, 0x9F, 0xE3, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0x0F, 0xF3, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 24, 19, 7, -24 },
  { 16, 11, 10, 19, 4, -26 },
  { 30, 17, 24, 19, 1, -24 },
  { 81, 16, 30, 19, 2, -26 },
  { 141, 19, 25, 19, 0, -24 },
  { 201, 17, 24, 19, 1, -24 },
  { 252, 5, 11, 19, 7, -26 },
  { 259, 12, 33, 19, 4, -27 },
  { 309, 11, 33, 19, 4, -27 },
  { 355, 15, 15, 19, 2, -24 },
  { 384, 15, 17, 19, 2, -19 },
  { 416, 8, 12, 19, 5, -6 },
  { 428, 9, 4, 19, 5, -12 },
  { 433, 7, 6, 19, 6, -6 },
  { 439, 15, 33, 19, 2, -27 },
  { 501, 17, 25, 19, 1, -24 },
  { 555, 15, 24, 19, 2, -24 },
  { 600, 15, 24, 19, 2, -24 },
  { 645, 15, 25, 19, 2, -24 },
  { 692, 17, 24, 19, 1, -24 },
  { 743, 15, 25, 19, 2, -24 },
  { 790, 15, 25, 19, 2, -24 },
  { 837, 15, 24, 19, 2, -24 },
  { 882, 15, 25, 19, 2, -24 },
  { 929, 15, 24, 19, 2, -24 },
  { 974, 7, 18, 19, 6, -18 },
  { 990, 8, 24, 19, 5, -18 },
  { 1014, 16, 16, 19, 2, -18 },
  { 1046, 15, 10, 19, 2, -15 },
  { 1065, 15, 16, 19, 2, -18 },
  { 1095, 13, 24, 19, 3, -24 },
  { 1134, 17, 29, 19, 1, -24 },
  { 1196, 19, 24, 19, 0, -24 },
  { 1253, 16, 24, 19, 2, -24 },
  { 1301, 17, 25, 19, 1, -24 },
  { 1355, 16, 24, 19, 2, -24 },
  { 1403, 15, 24, 19, 3, -24 },
  { 1448, 14, 24, 19, 3, -24 },
  { 1490, 17, 25, 19, 1, -24 },
  { 1544, 15, 24, 19, 2, -24 },
  { 1589, 15, 24, 19, 2, -24 },
  { 1634, 14, 25, 19, 2, -24 },
  { 1678, 17, 24, 19, 2, -24 },
  { 1729, 15, 24, 19, 3, -24 },
  { 1774, 17, 24, 19, 1, -24 },
  { 1825, 15, 24, 19, 2, -24 },
  { 1870, 17, 25, 19, 1, -24 },
  { 1924, 16, 24, 19, 2, -24 },
  { 1972, 17, 30, 19, 1, -24 },
  { 2036, 16, 24, 19, 2, -24 },
  { 2084, 15, 25, 19, 2, -24 },
  { 2131, 17, 24, 19, 1, -24 },
  { 2182, 15, 25, 19, 2, -24 },
  { 2229, 18, 24, 19, 1, -24 },
  { 2283, 17, 24, 19, 1, -24 },
  { 2334, 17, 24, 19, 1, -24 },
  { 2385, 18, 24, 19, 1, -24 },
  { 2439, 15, 24, 19, 2, -24 },
  { 2484, 10, 33, 19, 5, -27 },
  { 2526, 15, 33, 19, 2, -27 },
  { 2588, 10, 33, 19, 4, -27 },
  { 2630, 17, 14, 19, 1, -24 },
  { 2660, 19, 3, 19, 0, 3 },
  { 2668, 8, 6, 19, 6, -26 },
  { 2674, 15, 18, 19, 2, -18 },
  { 2708, 16, 26, 19, 2, -26 },
  { 2760, 16, 18, 19, 2, -18 },
  { 2796, 15, 26, 19, 1, -26 },
  { 2845, 17, 18, 19, 1, -18 },
  { 2884, 17, 26, 19, 2, -26 },
  { 2940, 16, 24, 19, 1, -18 },
  { 2988, 14, 26, 19, 3, -26 },
  { 3034, 16, 26, 19, 2, -26 },
  { 3086, 13, 32, 19, 2, -26 },
  { 3138, 15, 26, 19, 3, -26 },
  { 3187, 16, 26, 19, 2, -26 },
  { 3239, 17, 18, 19, 1, -18 },
  { 3278, 14, 18, 19, 3, -18 },
  { 3310, 17, 18, 19, 1, -18 },
  { 3349, 15, 24, 19, 3, -18 },
  { 3394, 16, 24, 19, 1, -18 },
  { 3442, 13, 18, 19, 4, -18 },
  { 3472, 15, 18, 19, 2, -18 },
  { 3506, 16, 23, 19, 2, -23 },
  { 3552, 15, 18, 19, 2, -18 },
  { 3586, 17, 18, 19, 1, -18 },
  { 3625, 18, 18, 19, 1, -18 },
  { 3666, 17, 18, 19, 1, -18 },
  { 3705, 17, 24, 19, 1, -18 },
  { 3756, 13, 18, 19, 3, -18 },
  { 3786, 14, 33, 19, 3, -27 },
  { 3844, 5, 33, 19, 7, -27 },
  { 3865, 13, 33, 19, 3, -27 },
  { 3919, 17, 6, 19, 1, -13 },
};

const GFXfont UbuntuSansMono_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_SEMIBOLD34PT7B_H_
