#ifndef _UBUNTUSANSMONO_SEMIBOLD15PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0x80, 0xF8, 0xDE, 0xE7, 0x20, 0x13, 0x12, 0xFF, 0xFF,
  0x26, 0x24, 0xFF, 0x6C, 0x6C, 0x6C, 0x30, 0x61, 0xF7, 0xEC, 0x1C, 0x1E,
  0x0E, 0x06, 0x0F, 0xF3, 0xC3, 0x06, 0x00, 0x60, 0xF3, 0x92, 0x94, 0xFC,
  0x28, 0x17, 0x35, 0x2D, 0x65, 0xC7, 0x18, 0x3C, 0x64, 0x6C, 0x6C, 0x33,
  0x7B, 0x4E, 0xC6, 0x6E, 0x7B, 0xFD, 0x11, 0xD8, 0xCC, 0x62, 0x10, 0x86,
  0x30, 0xC6, 0x1C, 0x40, 0x86, 0x18, 0x63, 0x0C, 0x63, 0x18, 0xCC, 0x66,
  0x62, 0x00, 0x31, 0xAB, 0xF9, 0x86, 0xC9, 0x00, 0x30, 0x60, 0xC7, 0xF3,
  0x06, 0x0C, 0x00, 0x27, 0x73, 0xE8, 0xFF, 0x5F, 0x00, 0x06, 0x18, 0x30,
  0x41, 0x83, 0x04, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0x00, 0x30,
  0xFB, 0x36, 0x39, 0x76, 0xE5, 0xE3, 0xC5, 0xD9, 0xE0, 0x38, 0xF3, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0xFF, 0xFC, 0x31, 0xFA, 0x30, 0x60, 0xC3, 0x0C,
  0x30, 0xE1, 0xFF, 0xF8, 0x31, 0xFA, 0x30, 0x60, 0xC7, 0x03, 0x03, 0x05,
  0x1B, 0xE0, 0x0E, 0x1E, 0x16, 0x36, 0x66, 0x66, 0xFF, 0x06, 0x06, 0x06,
  0x7D, 0x04, 0x18, 0xFC, 0x30, 0x41, 0x9F, 0xE0, 0x3C, 0xE1, 0x86, 0x8F,
  0xD9, 0xB1, 0xE3, 0xEC, 0xF0, 0xFE, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x18,
  0x20, 0xC0, 0x30, 0xFB, 0x36, 0x2C, 0xCF, 0x37, 0x63, 0x87, 0x99, 0xF0,
  0x30, 0xFB, 0x36, 0x3C, 0x7D, 0xDF, 0x06, 0x1D, 0xF3, 0x80, 0x5F, 0x00,
  0xBE, 0x27, 0x60, 0x02, 0x77, 0x2E, 0x80, 0x04, 0x3D, 0xE6, 0x0F, 0x07,
  0xC3, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC0, 0xF0, 0x71, 0xFE,
  0x30, 0x00, 0x33, 0xF8, 0xC3, 0x1C, 0xE3, 0x00, 0x00, 0xC3, 0x00, 0x0C,
  0x3E, 0x63, 0x43, 0x4F, 0xDB, 0xDB, 0xDB, 0x5B, 0x4F, 0x60, 0x30, 0x1E,
  0x1C, 0x1C, 0x34, 0x36, 0x26, 0x66, 0x7E, 0x7F, 0x43, 0xC3, 0x21, 0xFB,
  0x36, 0x6C, 0xDF, 0x33, 0x63, 0xC7, 0xFB, 0xE0, 0x18, 0xFF, 0x8E, 0x0C,
  0x10, 0x20, 0x60, 0xC1, 0xCD, 0xF8, 0x21, 0xF3, 0x36, 0x3C, 0x78, 0xF1,
  0xE3, 0xCD, 0xFB, 0xE0, 0xFD, 0x83, 0x06, 0x0F, 0xD8, 0x30, 0x60, 0xFF,
  0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0x00, 0x18, 0xFF, 0x8E,
  0x0C, 0x10, 0x21, 0xE3, 0xC7, 0xCD, 0xF8, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8C, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFF, 0xF0,
  0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xDF, 0xE0, 0xCF, 0x9B, 0x67, 0x8F,
  0x1F, 0x36, 0x66, 0xCF, 0x8C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xFC, 0x66, 0x66, 0x77, 0x5F, 0x5B, 0x5B, 0x43, 0x43, 0xC3, 0xC3,
  0xC7, 0x8F, 0x9F, 0xBF, 0x7A, 0xF7, 0xE7, 0xCF, 0x8C, 0x18, 0x3E, 0x66,
  0x63, 0x43, 0xC3, 0xC3, 0x43, 0x63, 0x76, 0x3C, 0x21, 0xFB, 0x3E, 0x3C,
  0x79, 0xFF, 0x60, 0xC1, 0x83, 0x00, 0x18, 0x3E, 0x66, 0x63, 0x43, 0xC3,
  0xC3, 0x43, 0x63, 0x76, 0x3C, 0x18, 0x0F, 0x02, 0x21, 0xFB, 0x36, 0x2C,
  0xDB, 0xBE, 0x6C, 0xCD, 0x9B, 0x18, 0x38, 0xFB, 0x16, 0x0E, 0x0F, 0x07,
  0x03, 0x07, 0x9B, 0xF0, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xEC, 0xF8, 0xC3,
  0x63, 0x63, 0x66, 0x66, 0x26, 0x34, 0x3C, 0x1C, 0x18, 0xC3, 0x43, 0x43,
  0x5B, 0x5B, 0x5F, 0x57, 0x67, 0x66, 0x62, 0xE3, 0x66, 0x34, 0x1C, 0x18,
  0x1C, 0x34, 0x66, 0x63, 0xC3, 0xE3, 0x62, 0x66, 0x36, 0x3C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFC, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x20, 0xFF, 0xFC,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xE0, 0xC1, 0x81,
  0x83, 0x06, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x80,
  0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0, 0x1C, 0x3C, 0x36, 0x66,
  0xE3, 0x42, 0xFF, 0xFF, 0x99, 0x80, 0x79, 0xF0, 0xDF, 0xFF, 0x1C, 0x5F,
  0x41, 0x83, 0x06, 0x0F, 0x9F, 0xB1, 0xE3, 0xC7, 0x8F, 0x37, 0xC0, 0x3E,
  0xFB, 0x06, 0x0C, 0x18, 0x3D, 0xBF, 0x04, 0x30, 0xC3, 0x7F, 0xFC, 0xE3,
  0x8F, 0x3E, 0xDF, 0x79, 0xFB, 0x1F, 0xFF, 0xF8, 0x39, 0x3E, 0x0C, 0x7C,
  0xC3, 0x0F, 0xFF, 0xD8, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x7F, 0xFC, 0xE3,
  0xCF, 0x3F, 0xCB, 0x0F, 0xFF, 0x00, 0x43, 0x0C, 0x30, 0xFB, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0x20, 0xE0, 0xC0, 0x0F, 0x1E, 0x0C, 0x18, 0x30, 0x60,
  0xF8, 0xF0, 0x08, 0x61, 0x80, 0x7D, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0F,
  0xE7, 0x00, 0x41, 0x83, 0x06, 0x0C, 0xF9, 0xB6, 0x78, 0xF1, 0xB3, 0x36,
  0x30, 0xF1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE8, 0xF0,
  0xFD, 0xFE, 0xDD, 0xBB, 0x70, 0xE1, 0xC3, 0xFB, 0xFC, 0xF3, 0xCF, 0x3C,
  0xF3, 0x79, 0xFB, 0x1C, 0x38, 0x78, 0xFB, 0x3C, 0xF9, 0xFB, 0x1E, 0x3C,
  0x78, 0xFB, 0x7E, 0xC1, 0x83, 0x00, 0x7F, 0xFC, 0xF3, 0x8F, 0x3E, 0xDF,
  0x0C, 0x30, 0xC0, 0xFF, 0xE8, 0x20, 0x82, 0x08, 0x20, 0x7F, 0xFC, 0x1C,
  0x3C, 0x3C, 0xFF, 0x60, 0xC3, 0xFF, 0xF6, 0x0C, 0x18, 0x30, 0x36, 0x7C,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3E, 0xDF, 0xC3, 0x63, 0x66, 0x66, 0x36, 0x3C,
  0x1C, 0x18, 0xC1, 0xC1, 0xDB, 0x5B, 0x5F, 0x56, 0x66, 0x66, 0xE3, 0x66,
  0x3C, 0x1C, 0x1C, 0x3E, 0x66, 0xE3, 0x63, 0x63, 0x66, 0x36, 0x36, 0x14,
  0x1C, 0x1C, 0x18, 0x78, 0xE0, 0xFF, 0xF1, 0x8C, 0x31, 0x8F, 0xFF, 0x1C,
  0xF3, 0x0C, 0x30, 0xC2, 0x30, 0x20, 0xC3, 0x0C, 0x30, 0xF1, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE3, 0xC1, 0x04, 0x10, 0x41, 0x83, 0x18, 0x41, 0x04,
  0x13, 0xCE, 0x00, 0x31, 0x7F, 0xCE,
};

const GFXglyph UbuntuSansMono_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 5, 4, 8, 2, -11 },
  { 8, 8, 10, 8, 0, -10 },
  { 18, 7, 14, 8, 1, -12 },
  { 31, 8, 11, 8, 0, -11 },
  { 42, 8, 11, 8, 0, -11 },
  { 53, 2, 4, 8, 3, -11 },
  { 54, 5, 15, 8, 2, -12 },
  { 64, 5, 15, 8, 2, -12 },
  { 74, 7, 6, 8, 1, -10 },
  { 80, 7, 7, 8, 1, -8 },
  { 87, 4, 6, 8, 2, -3 },
  { 90, 4, 2, 8, 2, -5 },
  { 91, 3, 3, 8, 3, -3 },
  { 93, 7, 15, 8, 1, -12 },
  { 107, 7, 11, 8, 1, -11 },
  { 117, 7, 10, 8, 1, -10 },
  { 126, 7, 11, 8, 1, -11 },
  { 136, 7, 11, 8, 1, -11 },
  { 146, 8, 10, 8, 0, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 7, 10, 8, 1, -10 },
  { 173, 7, 10, 8, 1, -10 },
  { 182, 7, 11, 8, 1, -11 },
  { 192, 7, 11, 8, 1, -11 },
  { 202, 3, 8, 8, 3, -8 },
  { 205, 4, 11, 8, 2, -8 },
  { 211, 7, 7, 8, 1, -8 },
  { 218, 7, 5, 8, 1, -7 },
  { 223, 7, 7, 8, 1, -8 },
  { 230, 6, 11, 8, 1, -11 },
  { 239, 8, 13, 8, 0, -11 },
  { 252, 8, 10, 8, 0, -10 },
  { 262, 7, 11, 8, 1, -11 },
  { 272, 7, 11, 8, 1, -11 },
  { 282, 7, 11, 8, 1, -11 },
  { 292, 7, 10, 8, 1, -10 },
  { 301, 6, 10, 8, 1, -10 },
  { 309, 7, 11, 8, 1, -11 },
  { 319, 7, 10, 8, 1, -10 },
  { 328, 6, 10, 8, 1, -10 },
  { 336, 6, 10, 8, 1, -10 },
  { 344, 7, 10, 8, 1, -10 },
  { 353, 7, 10, 8, 1, -10 },
  { 362, 8, 10, 8, 0, -10 },
  { 372, 7, 10, 8, 1, -10 },
  { 381, 8, 11, 8, 0, -11 },
  { 392, 7, 11, 8, 1, -11 },
  { 402, 8, 14, 8, 0, -11 },
  { 416, 7, 11, 8, 1, -11 },
  { 426, 7, 11, 8, 1, -11 },
  { 436, 8, 10, 8, 0, -10 },
  { 446, 7, 10, 8, 1, -10 },
  { 455, 8, 10, 8, 0, -10 },
  { 465, 8, 10, 8, 0, -10 },
  { 475, 8, 10, 8, 0, -10 },
  { 485, 8, 10, 8, 0, -10 },
  { 495, 7, 10, 8, 1, -10 },
  { 504, 5, 15, 8, 2, -12 },
  { 514, 7, 15, 8, 1, -12 },
  { 528, 4, 15, 8, 2, -12 },
  { 536, 8, 6, 8, 0, -10 },
  { 542, 8, 2, 8, 0, 1 },
  { 544, 3, 3, 8, 3, -12 },
  { 546, 6, 8, 8, 1, -8 },
  { 552, 7, 12, 8, 1, -12 },
  { 563, 7, 8, 8, 1, -8 },
  { 570, 6, 12, 8, 1, -12 },
  { 579, 7, 8, 8, 1, -8 },
  { 586, 7, 12, 8, 1, -12 },
  { 597, 6, 11, 8, 1, -8 },
  { 606, 6, 12, 8, 1, -12 },
  { 615, 7, 12, 8, 1, -12 },
  { 626, 6, 15, 8, 1, -12 },
  { 638, 7, 12, 8, 1, -12 },
  { 649, 7, 12, 8, 1, -12 },
  { 660, 7, 8, 8, 1, -8 },
  { 667, 6, 8, 8, 1, -8 },
  { 673, 7, 8, 8, 1, -8 },
  { 680, 7, 11, 8, 1, -8 },
  { 690, 6, 11, 8, 1, -8 },
  { 699, 6, 8, 8, 2, -8 },
  { 705, 6, 8, 8, 1, -8 },
  { 711, 7, 10, 8, 1, -10 },
  { 720, 6, 8, 8, 1, -8 },
  { 726, 8, 8, 8, 0, -8 },
  { 734, 8, 8, 8, 0, -8 },
  { 742, 8, 8, 8, 0, -8 },
  { 750, 8, 11, 8, 0, -8 },
  { 761, 6, 8, 8, 1, -8 },
  { 767, 6, 15, 8, 1, -12 },
  { 779, 2, 15, 8, 3, -12 },
  { 783, 6, 15, 8, 1, -12 },
  { 795, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_SEMIBOLD15PT7B_H_
