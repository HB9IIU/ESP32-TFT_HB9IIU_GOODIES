#ifndef _UBUNTUSANSMONO_SEMIBOLD41PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x02, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xE1, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xE0, 0x01,
  0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x0F, 0x00, 0xF8, 0x78, 0x07,
  0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xC0,
  0x31, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE8, 0x00, 0x7D, 0xC0, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x02, 0x7F, 0x00, 0x79, 0xFF, 0x01, 0xE3,
  0xDE, 0x03, 0xC7, 0x1E, 0x0F, 0x0E, 0x3C, 0x1C, 0x1C, 0x78, 0x78, 0x38,
  0xF1, 0xE0, 0x71, 0xE3, 0x80, 0xE3, 0xCF, 0x01, 0xEF, 0x3C, 0x03, 0xFE,
  0x78, 0x03, 0xF9, 0xE0, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x30, 0x00, 0xF3, 0xF0, 0x01, 0xEF, 0xF0, 0x07, 0x9F, 0xF0, 0x0E, 0x79,
  0xE0, 0x3C, 0xF1, 0xC0, 0xF1, 0xE3, 0x81, 0xC3, 0xC7, 0x07, 0x87, 0x8E,
  0x1E, 0x0F, 0x1C, 0x38, 0x1E, 0x78, 0xF0, 0x1F, 0xF3, 0xC0, 0x3F, 0xCF,
  0x80, 0x3F, 0x00, 0x00, 0x08, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x80, 0x3F, 0x87, 0xC3, 0xFE, 0x3E,
  0x3F, 0xF1, 0xF3, 0xE7, 0xCF, 0x1E, 0x3F, 0x79, 0xF0, 0xFF, 0xCF, 0x83,
  0xFE, 0x7C, 0x0F, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0x7C, 0x1F, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFB, 0xE0, 0xFF, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDC, 0xE7, 0x00, 0x00, 0x30, 0x03, 0xE0,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xE0, 0x07, 0x00, 0x04, 0x30, 0x01, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xF0,
  0x03, 0x80, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x20,
  0xF8, 0x27, 0x8E, 0x1C, 0xF9, 0xCF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E,
  0x3E, 0x0F, 0xC7, 0xE0, 0x70, 0x70, 0x06, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x07, 0xE3,
  0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x0E, 0x07, 0x83, 0xCF, 0xF3, 0xF8,
  0x78, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x71, 0xFF, 0x9F, 0x3F, 0xF3,
  0xE7, 0xFE, 0x7C, 0xFF, 0xCF, 0x9F, 0xF8, 0xE3, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x01, 0xF3, 0xE0,
  0x3E, 0x7E, 0x0F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0x71, 0xF0,
  0x10, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF7, 0xF8, 0x70, 0x3F, 0x08, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xC7, 0xF8, 0x60, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x60, 0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7D,
  0xF8, 0x03, 0xCF, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0x1E, 0x1F, 0x81,
  0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x78, 0x0F,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFD, 0x80, 0x7F,
  0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7,
  0xF0, 0xFE, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7E, 0x0F, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x1F, 0x3F, 0x87, 0xC3,
  0xFD, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x3E, 0x7F, 0x8F,
  0x83, 0xF9, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F,
  0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7,
  0xC0, 0x3E, 0xFC, 0x0F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x03, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x1F,
  0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF1, 0xF8, 0x3C,
  0x3C, 0x3E, 0xFE, 0x7E, 0x3E, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x78, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC7, 0xF1,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1F, 0x3C, 0x00, 0xF3, 0xC0,
  0x0F, 0x78, 0x00, 0xF7, 0x81, 0xFF, 0x78, 0x7F, 0xF7, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0x8F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF1, 0xE0, 0xFF,
  0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F,
  0xF8, 0xF8, 0xF7, 0x8F, 0xFF, 0x78, 0x7F, 0xF7, 0x87, 0xFF, 0x7C, 0x1F,
  0xF3, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0,
  0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x3F, 0xDF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFE, 0x7C, 0x7E, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC,
  0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFE, 0x3C, 0x7E, 0x00, 0x9F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xF0, 0x1F, 0x3F, 0x83, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF2, 0x00, 0xF9, 0xE0, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0xF8, 0x07, 0xF7, 0xC0,
  0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83,
  0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0xFC,
  0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0x7F, 0x00, 0xF9, 0xFC, 0x07, 0xC7, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E,
  0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8,
  0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFD, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0x71, 0xDE, 0x7B, 0x8E, 0xF3, 0xDC, 0xF7,
  0x9E, 0xF7, 0xBC, 0xF3, 0xB9, 0xE7, 0x9F, 0xCF, 0x3C, 0xFE, 0x79, 0xE3,
  0xE3, 0xCF, 0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xC7, 0x87, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x78, 0x7F,
  0xEF, 0x0F, 0xFC, 0xF1, 0xFF, 0x9E, 0x3F, 0xF1, 0xE7, 0xFE, 0x3C, 0xFF,
  0xC3, 0xDF, 0xF8, 0x7B, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0x83, 0xF1, 0xF8,
  0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x10, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF0,
  0xF8, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F,
  0x07, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC1,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC,
  0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07,
  0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x01, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF8, 0xF8, 0xF8,
  0x02, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFA, 0x00, 0x3F, 0x70, 0x0F, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xF3, 0xF0, 0x7E, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x7D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C, 0xFC,
  0x79, 0xE7, 0xF3, 0xCF, 0x3B, 0x9E, 0x79, 0xDC, 0xF3, 0xDE, 0xF7, 0x9E,
  0xE3, 0xBC, 0xF7, 0x1D, 0xE7, 0xF8, 0xFF, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78,
  0x03, 0xC0, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3E,
  0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0x83, 0xE0,
  0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0xBF, 0x00,
  0x7F, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C,
  0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8,
  0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFC, 0xE0, 0x03, 0xC1, 0x00,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x18, 0x1F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3E,
  0x06, 0x0F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x18, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xFF, 0xF1,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x18, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x9F, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xF7,
  0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0x3C, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0C, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xCF, 0x87, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xF0, 0x1F, 0x7E, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F,
  0x9F, 0x81, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC,
  0xFC, 0x0F, 0xBF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x30, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x01, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x0F,
  0xDF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0x7F, 0xBF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0xE7,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x40, 0x1F, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x30,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x10, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7D, 0x81, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x07, 0xE0,
  0x18, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0x7E, 0x3E, 0x1F, 0x87,
  0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x8F, 0x81, 0xF9, 0xF0, 0x1F, 0xBE,
  0x03, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x30, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x0F, 0x87, 0x87, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0x9F, 0x9F, 0x7C, 0x78, 0x7B,
  0xE3, 0xE3, 0xDF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E,
  0x3F, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7C, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E,
  0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFE, 0x7F, 0xBE, 0x07, 0xEF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xDF, 0xDF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xC0, 0x0B, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x0F,
  0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xE0, 0xF7, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x03, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0x7E, 0x0F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xE0,
  0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0x87, 0xF8, 0x7C, 0x3F,
  0xC3, 0xE1, 0xFF, 0x1F, 0x1F, 0x78, 0xFC, 0xF3, 0xCF, 0xE7, 0x9E, 0x7F,
  0x3C, 0xF3, 0xB9, 0xE7, 0xBD, 0xEF, 0x3D, 0xEF, 0x78, 0xEE, 0x3B, 0x87,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x00, 0xFC, 0x01, 0xF9, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x80,
  0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xF7,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x60, 0xFF, 0x03, 0xCF, 0xFE,
  0x3E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7C, 0x3F, 0xF3, 0xC0, 0x7F, 0x02,
  0x00, 0xF0,
};

const GFXglyph UbuntuSansMono_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 29, 23, 8, -28 },
  { 27, 13, 12, 23, 5, -31 },
  { 47, 21, 28, 23, 1, -28 },
  { 121, 19, 36, 23, 2, -32 },
  { 207, 23, 30, 23, 0, -29 },
  { 294, 21, 29, 23, 1, -29 },
  { 371, 5, 13, 23, 9, -31 },
  { 380, 14, 40, 23, 5, -32 },
  { 450, 14, 40, 23, 4, -32 },
  { 520, 19, 17, 23, 2, -28 },
  { 561, 19, 20, 23, 2, -22 },
  { 609, 10, 14, 23, 6, -7 },
  { 627, 11, 5, 23, 6, -14 },
  { 634, 7, 7, 23, 8, -7 },
  { 641, 19, 40, 23, 2, -32 },
  { 736, 19, 30, 23, 2, -29 },
  { 808, 18, 28, 23, 3, -28 },
  { 871, 19, 29, 23, 2, -29 },
  { 940, 19, 30, 23, 2, -29 },
  { 1012, 21, 28, 23, 1, -28 },
  { 1086, 18, 29, 23, 2, -28 },
  { 1152, 19, 30, 23, 2, -29 },
  { 1224, 19, 28, 23, 2, -28 },
  { 1291, 19, 30, 23, 2, -29 },
  { 1363, 19, 29, 23, 2, -29 },
  { 1432, 7, 21, 23, 8, -21 },
  { 1451, 9, 28, 23, 6, -21 },
  { 1483, 19, 19, 23, 2, -21 },
  { 1529, 19, 14, 23, 2, -19 },
  { 1563, 19, 19, 23, 2, -21 },
  { 1609, 17, 30, 23, 3, -29 },
  { 1673, 20, 35, 23, 1, -29 },
  { 1761, 23, 28, 23, 0, -28 },
  { 1842, 19, 29, 23, 2, -29 },
  { 1911, 19, 30, 23, 2, -29 },
  { 1983, 20, 29, 23, 2, -29 },
  { 2056, 18, 28, 23, 3, -28 },
  { 2119, 17, 28, 23, 3, -28 },
  { 2179, 19, 30, 23, 2, -29 },
  { 2251, 19, 28, 23, 2, -28 },
  { 2318, 17, 28, 23, 3, -28 },
  { 2378, 18, 29, 23, 2, -28 },
  { 2444, 21, 28, 23, 2, -28 },
  { 2518, 17, 28, 23, 4, -28 },
  { 2578, 21, 28, 23, 1, -28 },
  { 2652, 19, 28, 23, 2, -28 },
  { 2719, 21, 30, 23, 1, -29 },
  { 2798, 18, 29, 23, 3, -29 },
  { 2864, 21, 37, 23, 1, -29 },
  { 2962, 20, 29, 23, 2, -29 },
  { 3035, 19, 30, 23, 2, -29 },
  { 3107, 21, 28, 23, 1, -28 },
  { 3181, 19, 29, 23, 2, -28 },
  { 3250, 21, 28, 23, 1, -28 },
  { 3324, 21, 28, 23, 1, -28 },
  { 3398, 21, 28, 23, 1, -28 },
  { 3472, 21, 28, 23, 1, -28 },
  { 3546, 19, 28, 23, 2, -28 },
  { 3613, 12, 40, 23, 6, -32 },
  { 3673, 18, 40, 23, 3, -32 },
  { 3763, 12, 40, 23, 5, -32 },
  { 3823, 21, 16, 23, 1, -28 },
  { 3865, 23, 5, 23, 0, 3 },
  { 3880, 9, 8, 23, 7, -32 },
  { 3889, 18, 22, 23, 2, -22 },
  { 3939, 18, 32, 23, 3, -32 },
  { 4011, 19, 22, 23, 2, -22 },
  { 4064, 19, 32, 23, 1, -32 },
  { 4140, 19, 22, 23, 2, -22 },
  { 4193, 20, 32, 23, 2, -32 },
  { 4273, 18, 30, 23, 2, -22 },
  { 4341, 17, 32, 23, 3, -32 },
  { 4409, 19, 32, 23, 2, -32 },
  { 4485, 15, 40, 23, 3, -32 },
  { 4560, 19, 32, 23, 3, -32 },
  { 4636, 19, 32, 23, 2, -32 },
  { 4712, 21, 22, 23, 1, -22 },
  { 4770, 17, 22, 23, 3, -22 },
  { 4817, 21, 23, 23, 1, -22 },
  { 4878, 18, 30, 23, 3, -22 },
  { 4946, 18, 30, 23, 2, -22 },
  { 5014, 17, 22, 23, 4, -22 },
  { 5061, 17, 22, 23, 3, -22 },
  { 5108, 19, 28, 23, 2, -28 },
  { 5175, 17, 21, 23, 3, -21 },
  { 5220, 21, 21, 23, 1, -21 },
  { 5276, 21, 21, 23, 1, -21 },
  { 5332, 21, 21, 23, 1, -21 },
  { 5388, 21, 29, 23, 1, -21 },
  { 5465, 17, 21, 23, 3, -21 },
  { 5510, 17, 40, 23, 3, -32 },
  { 5595, 5, 40, 23, 9, -32 },
  { 5620, 17, 40, 23, 3, -32 },
  { 5705, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuSansMono_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_SEMIBOLD41PT7B_H_
