#ifndef _UBUNTUSANSMONO_SEMIBOLD26PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xDE, 0xFF,
  0x80, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1B, 0x8C, 0xC6, 0x0E, 0x70,
  0x63, 0x87, 0x1C, 0x38, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x1C, 0x38,
  0xC1, 0xCE, 0x0E, 0x71, 0xFF, 0xFF, 0xFF, 0xB8, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x07, 0x01, 0xFF, 0x3F, 0xE7,
  0x86, 0x70, 0x07, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x60, 0xF7, 0xFF, 0xFF, 0xE1, 0xF8, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7C, 0x0D, 0xF0, 0x6E, 0xE3, 0xB9, 0x8C, 0xE6, 0x63,
  0xBB, 0x87, 0xCC, 0x1F, 0x60, 0x13, 0x80, 0x0C, 0xC0, 0x77, 0x83, 0xBF,
  0x0C, 0xCC, 0x73, 0x31, 0x8C, 0xCC, 0x33, 0x70, 0xFF, 0x81, 0xE0, 0x1F,
  0x01, 0xFC, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0xFE, 0x07, 0xE0,
  0x3E, 0x73, 0xF3, 0xBF, 0xDD, 0xCF, 0xEE, 0x3E, 0x70, 0xF3, 0x87, 0x9E,
  0x7E, 0x7F, 0xF1, 0xF1, 0xC0, 0xFF, 0xFF, 0xFE, 0xC0, 0x01, 0x01, 0x81,
  0xE1, 0xC1, 0xC1, 0xE1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1F,
  0x07, 0x00, 0x80, 0x40, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81,
  0xC1, 0xC1, 0xE0, 0xE0, 0xE1, 0xF0, 0xE0, 0x20, 0x00, 0x07, 0x00, 0x70,
  0x47, 0x17, 0x67, 0x7B, 0xFF, 0xFF, 0x0F, 0x01, 0xD8, 0x3D, 0xC3, 0x9E,
  0x18, 0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x10, 0xF7,
  0xDF, 0x3C, 0x73, 0xBC, 0xE0, 0xFF, 0xFF, 0xF8, 0x27, 0xBF, 0xFF, 0x00,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x1F,
  0x83, 0xFE, 0x7D, 0xE7, 0x0F, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x77, 0xE7,
  0x7E, 0x77, 0xE2, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x70, 0xF7, 0xDE, 0x3F,
  0xC1, 0xF8, 0x07, 0x01, 0xE0, 0xFC, 0x7F, 0x8F, 0xF1, 0xDE, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC3, 0xFF,
  0x7F, 0xEF, 0xFC, 0x3F, 0x8F, 0xFE, 0x7B, 0xE2, 0x0E, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0x87, 0xFC, 0x7B, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF7, 0x3E, 0x7F, 0xEF, 0xF8, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x70, 0xE3,
  0x87, 0x38, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0xF7, 0x3E, 0xFF, 0xEF, 0xF8, 0x01, 0xE0, 0x7E, 0x1F, 0xE1, 0xE0,
  0x3C, 0x07, 0x80, 0x70, 0x07, 0xFC, 0x7F, 0xEF, 0x9F, 0xF0, 0x7F, 0x07,
  0x70, 0x77, 0x07, 0x70, 0xF7, 0xDE, 0x3F, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x1F, 0xC3,
  0xFE, 0x78, 0xF7, 0x07, 0x70, 0x77, 0x07, 0x78, 0xE3, 0xDE, 0x1F, 0xC3,
  0xFC, 0x71, 0xE7, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x9F, 0x7F, 0xE3,
  0xFC, 0x1F, 0x83, 0xFE, 0x79, 0xE7, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x77,
  0x07, 0x7D, 0xF3, 0xFF, 0x1F, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0xC7,
  0xF8, 0x7F, 0x07, 0x80, 0x27, 0xBF, 0xFF, 0x00, 0x00, 0x01, 0x3D, 0xFF,
  0xF8, 0x11, 0xE7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x47, 0x9F, 0x7D, 0xF1,
  0x8E, 0xF3, 0x80, 0x00, 0x10, 0x07, 0x03, 0xF0, 0xFF, 0x3F, 0x8F, 0xE0,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xF0, 0x07, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x40, 0x07, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x70,
  0x3F, 0x0F, 0xE7, 0xF8, 0xFC, 0x07, 0x00, 0x40, 0x00, 0x7F, 0xBF, 0xF6,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x07, 0x00, 0x0F, 0xC1, 0xFF, 0x0E,
  0x1C, 0xE0, 0x66, 0x03, 0x70, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0x3E, 0x71,
  0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7, 0x1F, 0x9F, 0xFC, 0xFF, 0x61, 0xF3,
  0x80, 0x0E, 0x00, 0x7E, 0x61, 0xFF, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x1C, 0x1C, 0x70,
  0x61, 0xC3, 0x87, 0x0F, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0x03, 0x9C, 0x0F,
  0x70, 0x1F, 0xC0, 0x70, 0xFF, 0x0F, 0xFC, 0xFF, 0xCE, 0x1E, 0xE1, 0xEE,
  0x1E, 0xE1, 0xCF, 0xF8, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0xFE,
  0x0E, 0xE0, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x8F, 0x9C,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xEF,
  0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xF1, 0xFF, 0x3E, 0x77, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x77, 0x07, 0x78, 0x73, 0xEF, 0x3F, 0xF0, 0xFF, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x40, 0xE7,
  0xBE, 0xFF, 0xC7, 0xF8, 0xF0, 0x7F, 0x87, 0xBC, 0x79, 0xE3, 0x8F, 0x3C,
  0x7B, 0xC3, 0xDC, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xE1, 0xE7, 0x8F,
  0x3C, 0x78, 0xF3, 0xC3, 0xDE, 0x1E, 0xF0, 0x7F, 0x83, 0xC0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x70,
  0x73, 0x87, 0x9C, 0x3D, 0xF1, 0xEF, 0x9F, 0x7C, 0xDB, 0xB6, 0xDD, 0xF6,
  0xEF, 0x37, 0x79, 0xB9, 0xCD, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xC0, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC,
  0x7F, 0xC7, 0xEE, 0x7E, 0xE7, 0xE7, 0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0x1F, 0xC1, 0xFF, 0x1F,
  0x78, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x78, 0x39, 0xC3, 0xCF, 0xBC, 0x3F, 0xE0,
  0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xF8, 0xE1, 0xEF,
  0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0x78, 0x39, 0xC3, 0xCF, 0xBC, 0x3F, 0xE0, 0xFE, 0x01, 0xC0,
  0x0F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE,
  0x1E, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xEF, 0xCF, 0xF8, 0xFF, 0x0E,
  0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0x1F, 0xF3,
  0xFE, 0x7C, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0xC0,
  0xFE, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x40, 0x77, 0x9F, 0xFF, 0xE7,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0xDF, 0x7F, 0xE1, 0xFC, 0xF0, 0x1D,
  0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x78, 0x38, 0xE0, 0xE3, 0x87, 0x8E, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x9C, 0xFC, 0xE6, 0xEF, 0x37, 0x79, 0xBB, 0x6D,
  0xDB, 0x6F, 0x9B, 0x7C, 0xF9, 0xE3, 0xCE, 0x1E, 0x70, 0xF3, 0x83, 0x80,
  0x78, 0x3C, 0xE0, 0xE3, 0xC7, 0x07, 0x1C, 0x1E, 0xE0, 0x3B, 0x80, 0xFC,
  0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xB8, 0x1C, 0xF0, 0x71,
  0xC3, 0xC7, 0x8E, 0x0E, 0x78, 0x3F, 0xC0, 0xF0, 0xF0, 0x1D, 0xC0, 0xF7,
  0x83, 0x8E, 0x0E, 0x3C, 0x70, 0x71, 0xC1, 0xCE, 0x03, 0xB8, 0x0F, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x83,
  0xDC, 0x1C, 0xF1, 0xE3, 0xCE, 0x0E, 0xF0, 0x7B, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x47, 0x3C, 0x71, 0x80, 0x3F, 0x83, 0xFE, 0x3F,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x3F, 0xF7, 0xFF, 0x70, 0x7F, 0x07, 0xF0,
  0x77, 0xC7, 0x7F, 0xF3, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xEF, 0x0F, 0xFC, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0x7E, 0xFF, 0xCF, 0xF0, 0x07,
  0xF1, 0xFF, 0x3F, 0xF7, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xFF, 0x3F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1F, 0xF3, 0xFF, 0x7F, 0xF7, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFF, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x0F, 0xF0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x03,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3C, 0x01, 0xE0, 0x0E, 0x03, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xE3, 0xFF, 0x7F,
  0xF7, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F,
  0xF7, 0xFF, 0x1F, 0xF0, 0x0F, 0x00, 0xF4, 0x1E, 0x7F, 0xEF, 0xFC, 0x3F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xC7, 0xFC,
  0xFF, 0xDC, 0x3B, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0x03,
  0x01, 0xE0, 0x78, 0x1E, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x7F, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xB0, 0xEF, 0xFB, 0xFC, 0x3E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x78, 0xEF, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE0, 0xEF, 0x0E, 0x78, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE,
  0x0F, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0x7D, 0xE7, 0xFF, 0xBF, 0xFD,
  0xCC, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C, 0x7F, 0x1F, 0xF3, 0xFF, 0x70, 0xEE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0x9C, 0x3C, 0xFF, 0xE3, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x8F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFF,
  0x7F, 0xF1, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x8F, 0xFB, 0xFF, 0x70, 0x2E, 0x01,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xFB, 0xFF, 0xFD, 0xFF,
  0x00, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF,
  0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xFF, 0xF7,
  0xFE, 0x7F, 0xC0, 0xE0, 0x3F, 0x03, 0xFC, 0x1C, 0xE0, 0xE7, 0x0F, 0x38,
  0x70, 0xE3, 0x87, 0x3C, 0x3D, 0xC0, 0xEE, 0x07, 0xE0, 0x1F, 0x00, 0xF0,
  0x03, 0x80, 0xE0, 0x1F, 0x80, 0x76, 0x01, 0xD8, 0xE7, 0x63, 0x9D, 0xCE,
  0x77, 0x79, 0x9D, 0xF6, 0x76, 0xD8, 0xFB, 0x63, 0xCF, 0x8F, 0x1E, 0x3C,
  0x70, 0xE1, 0xC0, 0xE0, 0x7B, 0x83, 0x9E, 0x38, 0x73, 0xC1, 0xDC, 0x07,
  0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x80, 0xEE, 0x0E, 0x78, 0xE1, 0xEF, 0x07,
  0x70, 0x3C, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x8F, 0x1C, 0x70,
  0xE3, 0x87, 0x9C, 0x1D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFC, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7C, 0x0F, 0x01, 0xF0,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xF8, 0x7F, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xF0, 0x3E, 0x0F, 0xC1, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0x87, 0xF0, 0xF8,
  0x00, 0x3C, 0x3B, 0xF9, 0xFF, 0xFD, 0xC7, 0xE4, 0x1C, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 9, 8, 15, 3, -20 },
  { 22, 13, 18, 15, 1, -18 },
  { 52, 12, 23, 15, 1, -20 },
  { 87, 14, 18, 15, 0, -18 },
  { 119, 13, 18, 15, 1, -18 },
  { 149, 3, 9, 15, 6, -20 },
  { 153, 9, 26, 15, 3, -21 },
  { 183, 9, 26, 15, 3, -21 },
  { 213, 12, 11, 15, 1, -18 },
  { 230, 12, 13, 15, 1, -14 },
  { 250, 6, 9, 15, 4, -5 },
  { 257, 7, 3, 15, 4, -9 },
  { 260, 5, 5, 15, 5, -5 },
  { 264, 11, 25, 15, 2, -20 },
  { 299, 12, 18, 15, 1, -18 },
  { 326, 11, 18, 15, 2, -18 },
  { 351, 12, 18, 15, 1, -18 },
  { 378, 12, 18, 15, 1, -18 },
  { 405, 13, 18, 15, 1, -18 },
  { 435, 12, 18, 15, 1, -18 },
  { 462, 12, 18, 15, 1, -18 },
  { 489, 11, 18, 15, 2, -18 },
  { 514, 12, 18, 15, 1, -18 },
  { 541, 12, 18, 15, 1, -18 },
  { 568, 5, 14, 15, 5, -14 },
  { 577, 6, 18, 15, 4, -14 },
  { 591, 12, 13, 15, 1, -14 },
  { 611, 12, 9, 15, 1, -12 },
  { 625, 12, 13, 15, 1, -14 },
  { 645, 10, 18, 15, 2, -18 },
  { 668, 13, 22, 15, 1, -18 },
  { 704, 14, 18, 15, 0, -18 },
  { 736, 12, 18, 15, 2, -18 },
  { 763, 13, 18, 15, 1, -18 },
  { 793, 12, 18, 15, 2, -18 },
  { 820, 11, 18, 15, 2, -18 },
  { 845, 11, 18, 15, 2, -18 },
  { 870, 12, 18, 15, 1, -18 },
  { 897, 12, 18, 15, 1, -18 },
  { 924, 11, 18, 15, 2, -18 },
  { 949, 12, 18, 15, 1, -18 },
  { 976, 13, 18, 15, 1, -18 },
  { 1006, 11, 18, 15, 2, -18 },
  { 1031, 13, 18, 15, 1, -18 },
  { 1061, 12, 18, 15, 1, -18 },
  { 1088, 13, 18, 15, 1, -18 },
  { 1118, 12, 18, 15, 2, -18 },
  { 1145, 13, 23, 15, 1, -18 },
  { 1183, 12, 18, 15, 2, -18 },
  { 1210, 12, 18, 15, 1, -18 },
  { 1237, 13, 18, 15, 1, -18 },
  { 1267, 12, 18, 15, 1, -18 },
  { 1294, 14, 18, 15, 0, -18 },
  { 1326, 13, 18, 15, 1, -18 },
  { 1356, 14, 18, 15, 0, -18 },
  { 1388, 14, 18, 15, 0, -18 },
  { 1420, 12, 18, 15, 1, -18 },
  { 1447, 7, 25, 15, 4, -20 },
  { 1469, 11, 25, 15, 2, -20 },
  { 1504, 8, 25, 15, 3, -20 },
  { 1529, 13, 10, 15, 1, -18 },
  { 1546, 14, 3, 15, 0, 2 },
  { 1552, 5, 5, 15, 5, -20 },
  { 1556, 12, 14, 15, 1, -14 },
  { 1577, 12, 20, 15, 2, -20 },
  { 1607, 12, 14, 15, 1, -14 },
  { 1628, 12, 20, 15, 1, -20 },
  { 1658, 12, 14, 15, 1, -14 },
  { 1679, 13, 20, 15, 1, -20 },
  { 1712, 12, 19, 15, 1, -14 },
  { 1741, 11, 20, 15, 2, -20 },
  { 1769, 12, 20, 15, 1, -20 },
  { 1799, 10, 25, 15, 2, -20 },
  { 1831, 12, 20, 15, 2, -20 },
  { 1861, 12, 20, 15, 1, -20 },
  { 1891, 13, 14, 15, 1, -14 },
  { 1914, 11, 14, 15, 2, -14 },
  { 1934, 13, 14, 15, 1, -14 },
  { 1957, 12, 19, 15, 2, -14 },
  { 1986, 12, 19, 15, 1, -14 },
  { 2015, 10, 14, 15, 3, -14 },
  { 2033, 11, 14, 15, 2, -14 },
  { 2053, 13, 18, 15, 1, -18 },
  { 2083, 11, 14, 15, 2, -14 },
  { 2103, 13, 14, 15, 1, -14 },
  { 2126, 14, 14, 15, 0, -14 },
  { 2151, 13, 14, 15, 1, -14 },
  { 2174, 13, 19, 15, 1, -14 },
  { 2205, 11, 14, 15, 2, -14 },
  { 2225, 11, 25, 15, 2, -20 },
  { 2260, 3, 25, 15, 6, -20 },
  { 2270, 11, 25, 15, 2, -20 },
  { 2305, 13, 5, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_SEMIBOLD26PT7B_H_
