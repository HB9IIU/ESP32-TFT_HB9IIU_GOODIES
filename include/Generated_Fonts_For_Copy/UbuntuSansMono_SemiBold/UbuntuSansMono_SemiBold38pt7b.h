#ifndef _UBUNTUSANSMONO_SEMIBOLD38PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0xFF, 0xFF, 0x7E, 0xF8,
  0x40, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7D, 0xE1,
  0xEF, 0x0F, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE0, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x01, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7D, 0x80, 0x3E, 0x7E, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x09, 0xFC, 0x03, 0x9F, 0xE0, 0x3C, 0xE7, 0x83,
  0xC7, 0x1C, 0x1C, 0x38, 0xE1, 0xE1, 0xC7, 0x0E, 0x0E, 0x38, 0xF0, 0x71,
  0xCF, 0x03, 0x9E, 0x70, 0x1F, 0xE7, 0x80, 0x7F, 0x78, 0x01, 0xF3, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC6, 0x00, 0x1C, 0xFC, 0x01, 0xEF, 0xF0, 0x1E,
  0x7F, 0x80, 0xE7, 0x9E, 0x0F, 0x3C, 0xF0, 0x71, 0xC3, 0x87, 0x0E, 0x1C,
  0x78, 0x79, 0xE3, 0x81, 0xCE, 0x3C, 0x0F, 0xF3, 0xC0, 0x7F, 0xBC, 0x01,
  0xF8, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C,
  0x3C, 0x07, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x87, 0x8F, 0xF8, 0xF1, 0xFF, 0x9E, 0x7D, 0xF3, 0xDF, 0x1F, 0x7B, 0xC1,
  0xFE, 0x78, 0x1F, 0xCF, 0x01, 0xF9, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF7,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0x7C, 0x3F, 0x87, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0x7B, 0xDC, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xE0, 0x03, 0x00, 0x20, 0x03, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x0C, 0x3C, 0x27, 0x9C, 0x73, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x01, 0xF8, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xF3, 0xE1, 0xF1,
  0xF0, 0x38, 0x70, 0x08, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF9, 0xFC, 0x7E, 0x0E, 0x0F, 0x0F, 0x3F,
  0x1F, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0x07,
  0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B,
  0xC7, 0x9F, 0xF3, 0xE7, 0xFC, 0xF9, 0xFF, 0x3E, 0x7F, 0xC7, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0x9E, 0x03,
  0xE7, 0xC1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xF3, 0xE0, 0x21, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x07, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xC7, 0xC7, 0xF3, 0x80, 0xF8, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x87, 0xF1, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0x00, 0x7E, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F,
  0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFA, 0x00, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0x9F, 0x03, 0xC7, 0xE1, 0xF0, 0xFC, 0xF8, 0x3F, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0xE0, 0xF3, 0xFC, 0x7C, 0x3F, 0xBE, 0x03, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xFD, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0x7B, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE0, 0x0E,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x7C, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3, 0xF0, 0x78, 0x38,
  0x7D, 0xFC, 0xFC, 0x38, 0x00, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x40, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3,
  0xFF, 0xE7, 0x07, 0xE8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xE0, 0x7C, 0x78,
  0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x1F, 0xEE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x1F, 0xE3, 0xC3, 0xFC, 0xF8, 0x7F, 0x9F,
  0x0F, 0xF3, 0xC1, 0xFE, 0x78, 0x3F, 0xCF, 0x87, 0xF8, 0xF0, 0xFF, 0x1E,
  0x1F, 0xE3, 0xF7, 0xDC, 0x3F, 0xFB, 0xC7, 0xFF, 0x78, 0x3F, 0xE7, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x7C,
  0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xE0, 0x1F,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xFF,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFE, 0xFF, 0x3E, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E,
  0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF3, 0xE0, 0xFE, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFC, 0x3C, 0x7E, 0x00, 0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x10, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x1F,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFD, 0xFF, 0x3E, 0x0F,
  0xCF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07,
  0xEF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x3C,
  0x7E, 0x00, 0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC0, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x40,
  0x1F, 0x60, 0x3F, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x01,
  0x00, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7C,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFC,
  0x07, 0xCF, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7E, 0xF8, 0x07,
  0xDF, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xEE,
  0x1F, 0x9D, 0xC7, 0x73, 0xB8, 0xEE, 0x77, 0x9D, 0xCE, 0x77, 0xB9, 0xCE,
  0xE7, 0x39, 0xFC, 0xF7, 0x1F, 0x9E, 0xE3, 0xE3, 0xDC, 0x7C, 0x7B, 0x87,
  0x8F, 0xF0, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3C, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xF7, 0x87, 0xFB, 0xC3, 0xFC, 0xF1,
  0xFE, 0x78, 0xFF, 0x1E, 0x7F, 0x87, 0x3F, 0xC3, 0xDF, 0xE1, 0xEF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7C, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x8F, 0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x9F, 0xF7, 0x80, 0xFB, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0x87, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xF1, 0xF8, 0x7C, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBC,
  0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0x83, 0xF1, 0xFD, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x0F,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFD, 0xFF, 0x3E, 0x07,
  0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x7C, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7C,
  0x03, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE0, 0xE3, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7D, 0x80,
  0x3E, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBF, 0x03, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF,
  0x00, 0x08, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3C,
  0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF9, 0xE0,
  0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x1E, 0x3D, 0xC7, 0xC7, 0xB8, 0xF8,
  0xF7, 0x1F, 0x1E, 0xE3, 0xF3, 0xDC, 0xEE, 0x73, 0x9D, 0xCE, 0x73, 0x9D,
  0xCE, 0xF3, 0xB9, 0xDC, 0x77, 0x3B, 0x8E, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xFC, 0x03,
  0xE7, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1,
  0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7E, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x01, 0xF1,
  0xF0, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x7E, 0xFC,
  0x03, 0xF7, 0x80, 0x1C, 0x10, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x78, 0xFC, 0xFE, 0x3F, 0x0F,
  0x06, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF,
  0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x08, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF3, 0xE0, 0xFD, 0xE0, 0x3E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0xF0,
  0x1F, 0x78, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x80,
  0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFD, 0xE3, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFD, 0xF8, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF8, 0x0F,
  0x7C, 0x07, 0xBF, 0x03, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x04, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C,
  0x04, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7E, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xF0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3E, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE3,
  0x01, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x08,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xB8, 0x3E, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF,
  0x00, 0x08, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE7,
  0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3E, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F,
  0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x9F, 0x9F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x1E, 0x1F, 0xE1, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1,
  0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x78, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFB,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7,
  0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF1, 0xF0, 0x7E, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x7D,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x7D, 0xF0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1E, 0xFF, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC0, 0x23, 0xE0, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xC0, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF,
  0xBF, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x20, 0x7F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0x81,
  0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x07, 0x8F,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0xF1, 0xEF, 0x0F, 0x1E, 0xF1,
  0xF1, 0xEF, 0x1F, 0x1E, 0xF1, 0xF9, 0xE7, 0x1F, 0x9E, 0x73, 0xF9, 0xC7,
  0xBB, 0x9C, 0x7B, 0xBD, 0xC7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xC0, 0x78, 0xF8, 0x03,
  0xEF, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1F, 0x7C,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x7C, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x07, 0x81, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xE0, 0x3E, 0x3C,
  0x07, 0xCF, 0x80, 0x7D, 0xE0, 0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x87, 0xF8, 0x1C, 0xFF, 0xC7, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xE0, 0xFF, 0xBC, 0x0F, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 27, 21, 7, -26 },
  { 25, 13, 12, 21, 4, -29 },
  { 45, 19, 26, 21, 1, -26 },
  { 107, 18, 33, 21, 2, -29 },
  { 182, 21, 28, 21, 0, -27 },
  { 256, 19, 27, 21, 1, -27 },
  { 321, 5, 12, 21, 8, -29 },
  { 329, 13, 37, 21, 4, -30 },
  { 390, 13, 37, 21, 4, -30 },
  { 451, 17, 16, 21, 2, -26 },
  { 485, 18, 19, 21, 2, -21 },
  { 528, 9, 13, 21, 6, -7 },
  { 543, 11, 4, 21, 5, -13 },
  { 549, 7, 7, 21, 7, -7 },
  { 556, 17, 37, 21, 2, -30 },
  { 635, 18, 28, 21, 2, -27 },
  { 698, 17, 26, 21, 2, -26 },
  { 754, 17, 27, 21, 2, -27 },
  { 812, 17, 28, 21, 2, -27 },
  { 872, 19, 26, 21, 1, -26 },
  { 934, 17, 27, 21, 2, -26 },
  { 992, 17, 28, 21, 2, -27 },
  { 1052, 17, 26, 21, 2, -26 },
  { 1108, 18, 28, 21, 2, -27 },
  { 1171, 17, 27, 21, 2, -27 },
  { 1229, 7, 20, 21, 7, -20 },
  { 1247, 9, 26, 21, 5, -20 },
  { 1277, 18, 18, 21, 2, -20 },
  { 1318, 18, 12, 21, 2, -17 },
  { 1345, 18, 18, 21, 2, -20 },
  { 1386, 15, 28, 21, 3, -27 },
  { 1439, 19, 33, 21, 1, -27 },
  { 1518, 21, 26, 21, 0, -26 },
  { 1587, 18, 27, 21, 2, -27 },
  { 1648, 19, 28, 21, 1, -27 },
  { 1715, 18, 27, 21, 2, -27 },
  { 1776, 17, 26, 21, 3, -26 },
  { 1832, 16, 26, 21, 3, -26 },
  { 1884, 19, 28, 21, 1, -27 },
  { 1951, 17, 26, 21, 2, -26 },
  { 2007, 16, 26, 21, 3, -26 },
  { 2059, 16, 27, 21, 2, -26 },
  { 2113, 19, 26, 21, 2, -26 },
  { 2175, 17, 26, 21, 3, -26 },
  { 2231, 19, 26, 21, 1, -26 },
  { 2293, 17, 26, 21, 2, -26 },
  { 2349, 19, 28, 21, 1, -27 },
  { 2416, 17, 27, 21, 3, -27 },
  { 2474, 19, 34, 21, 1, -27 },
  { 2555, 18, 27, 21, 2, -27 },
  { 2616, 17, 28, 21, 2, -27 },
  { 2676, 19, 26, 21, 1, -26 },
  { 2738, 18, 27, 21, 2, -26 },
  { 2799, 20, 26, 21, 1, -26 },
  { 2864, 19, 26, 21, 1, -26 },
  { 2926, 20, 26, 21, 1, -26 },
  { 2991, 20, 26, 21, 1, -26 },
  { 3056, 17, 26, 21, 2, -26 },
  { 3112, 11, 37, 21, 5, -30 },
  { 3163, 17, 37, 21, 2, -30 },
  { 3242, 11, 37, 21, 5, -30 },
  { 3293, 20, 15, 21, 1, -26 },
  { 3331, 21, 4, 21, 0, 3 },
  { 3342, 8, 7, 21, 7, -29 },
  { 3349, 17, 20, 21, 2, -20 },
  { 3392, 17, 30, 21, 3, -30 },
  { 3456, 18, 20, 21, 2, -20 },
  { 3501, 17, 30, 21, 1, -30 },
  { 3565, 19, 20, 21, 1, -20 },
  { 3613, 19, 29, 21, 2, -29 },
  { 3682, 18, 27, 21, 1, -20 },
  { 3743, 16, 30, 21, 3, -30 },
  { 3803, 18, 29, 21, 2, -29 },
  { 3869, 15, 36, 21, 2, -29 },
  { 3937, 18, 30, 21, 3, -30 },
  { 4005, 18, 29, 21, 2, -29 },
  { 4071, 19, 20, 21, 1, -20 },
  { 4119, 16, 20, 21, 3, -20 },
  { 4159, 19, 21, 21, 1, -20 },
  { 4209, 17, 27, 21, 3, -20 },
  { 4267, 18, 27, 21, 1, -20 },
  { 4328, 15, 20, 21, 4, -20 },
  { 4366, 17, 20, 21, 2, -20 },
  { 4409, 18, 26, 21, 2, -26 },
  { 4468, 16, 20, 21, 3, -20 },
  { 4508, 19, 20, 21, 1, -20 },
  { 4556, 20, 20, 21, 1, -20 },
  { 4606, 19, 20, 21, 1, -20 },
  { 4654, 19, 27, 21, 1, -20 },
  { 4719, 15, 20, 21, 3, -20 },
  { 4757, 15, 37, 21, 3, -30 },
  { 4827, 5, 37, 21, 8, -30 },
  { 4851, 15, 37, 21, 3, -30 },
  { 4921, 19, 7, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_SEMIBOLD38PT7B_H_
