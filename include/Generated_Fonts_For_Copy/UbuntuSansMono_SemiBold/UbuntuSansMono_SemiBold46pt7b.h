#ifndef _UBUNTUSANSMONO_SEMIBOLD46PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E,
  0xFC, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFD, 0xC0, 0x07,
  0xE7, 0xF1, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x81,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xCF, 0xF8, 0x03, 0xC7, 0xFC, 0x03, 0xE7, 0x9F, 0x01, 0xE3, 0xC7,
  0x81, 0xE1, 0xE3, 0xC1, 0xF0, 0xE1, 0xE0, 0xF0, 0x70, 0xF0, 0xF8, 0x38,
  0x78, 0x78, 0x1E, 0x3C, 0x78, 0x0F, 0x1E, 0x7C, 0x07, 0xDE, 0x3C, 0x01,
  0xFF, 0x3C, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x3F, 0xC0, 0x0F, 0x9F,
  0xF0, 0x07, 0x9F, 0x78, 0x07, 0xCF, 0x1E, 0x03, 0xC7, 0x8F, 0x03, 0xC3,
  0xC7, 0x83, 0xE1, 0xC3, 0xC1, 0xE0, 0xF1, 0xE1, 0xE0, 0x78, 0xF1, 0xF0,
  0x3C, 0x78, 0xF0, 0x1E, 0x7C, 0xF0, 0x0F, 0xFC, 0xF8, 0x03, 0xFE, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7C, 0x1F, 0xF8, 0x7C,
  0x1F, 0xFC, 0x7C, 0x3F, 0xFE, 0x7C, 0x7E, 0x7E, 0x7C, 0x7C, 0x3F, 0x7C,
  0xFC, 0x1F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xF8, 0x7E, 0x0F, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0x7E, 0x1F, 0xFE, 0x7E, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x0C, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x04, 0x30, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x40, 0xF0, 0x27, 0x0F, 0x0E,
  0x7C, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x01, 0xF9,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x0E, 0x07, 0x00, 0x20, 0x40, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7,
  0xF8, 0x7F, 0x03, 0xC0, 0xF8, 0x3E, 0x1F, 0xCF, 0xF1, 0xFC, 0x3E, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0x7C,
  0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC,
  0x00, 0xFF, 0xE1, 0xC3, 0xFF, 0x87, 0x8F, 0xFE, 0x3F, 0x3F, 0xF8, 0xFC,
  0xFF, 0xE3, 0xF3, 0xFF, 0x87, 0x8F, 0xFE, 0x0C, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xCF,
  0xC0, 0x70, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFE, 0xFF,
  0x83, 0xC0, 0x7F, 0x04, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x9F, 0xF0, 0x60, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x80, 0x07, 0xE7, 0xC1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3E, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xD0, 0x01, 0xFC,
  0xF8, 0x3F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xEF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xCF, 0xC0, 0xFC, 0x7F, 0x8F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80,
  0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C,
  0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0x81, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC7, 0xFC, 0x7E, 0x07,
  0xF9, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x80, 0x7E, 0x7F, 0x87, 0xF9, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xC7, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xDF, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x0F, 0x83, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0x7F, 0x03, 0xE0, 0x78, 0x1F, 0x1F, 0xCF, 0xF0, 0xFC, 0x1E, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x0F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x0F, 0xE6, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x07, 0xFB, 0xE0, 0x7F,
  0xF7, 0x83, 0xFF, 0xEF, 0x07, 0xFF, 0xDE, 0x1F, 0xFF, 0xFC, 0x3F, 0x1F,
  0xF8, 0xFC, 0x3F, 0xF1, 0xF0, 0x7F, 0xE3, 0xE0, 0xFF, 0xC7, 0xC1, 0xFF,
  0x8F, 0x83, 0xFF, 0x1F, 0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8,
  0xFC, 0x3E, 0xF1, 0xF8, 0x7D, 0xE1, 0xFF, 0xFB, 0xE3, 0xFF, 0xF7, 0xC3,
  0xFF, 0xEF, 0x83, 0xFF, 0xCF, 0x81, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7C, 0x07, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x81, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3E, 0x01, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xE7, 0xE3, 0xFC, 0x01, 0x8F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x02, 0x1F, 0xF8, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7C, 0x0F, 0xF3, 0xE0, 0x3F, 0x9F, 0x00, 0xFE, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF,
  0x00, 0x7E, 0xF8, 0x07, 0xF7, 0xC0, 0x7F, 0x3E, 0x07, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0D, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xE7, 0xE3, 0xFC, 0x01, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0,
  0x0F, 0xCF, 0xE0, 0x3F, 0x1F, 0xF1, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF2, 0x00, 0x3F, 0x38, 0x07,
  0xE7, 0xE3, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7F,
  0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3E,
  0x0F, 0xC0, 0xF8, 0x7F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E,
  0x00, 0xFB, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xEF, 0xE0, 0x0F, 0x9F, 0xC0, 0x3E, 0x3F, 0x80, 0xF8,
  0x7F, 0x03, 0xE1, 0xFC, 0x0F, 0x83, 0xF8, 0x3E, 0x07, 0xF0, 0xF8, 0x0F,
  0xE3, 0xE0, 0x3F, 0x8F, 0x80, 0x7F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x87, 0x79, 0xF7, 0x1E, 0xF3,
  0xEF, 0x3D, 0xE7, 0xDE, 0x73, 0xCF, 0x9D, 0xE7, 0xDF, 0x3F, 0xCF, 0xBE,
  0x7F, 0x9F, 0x7C, 0xFE, 0x3E, 0xF8, 0xFC, 0x7D, 0xF1, 0xF8, 0xFB, 0xE3,
  0xE1, 0xF7, 0xC3, 0xC3, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xBE, 0x1F, 0xFB, 0xE1, 0xFF, 0x9F, 0x1F, 0xF9,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F, 0xF8, 0x7D, 0xFF,
  0x83, 0xDF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC,
  0xFF, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xFE, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E,
  0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xDF, 0x81, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x18, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xE1, 0xF1, 0xFC, 0x01, 0x8F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x60, 0x03, 0xF7, 0xE0, 0x7F, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x3F, 0x9F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC7, 0xC3, 0xEF, 0x8F, 0xC7,
  0xDF, 0x1F, 0x8F, 0xBE, 0x3F, 0x1F, 0x7C, 0xFE, 0x3E, 0xF9, 0xFE, 0x7D,
  0xF3, 0xFC, 0xFB, 0xEF, 0x39, 0xE7, 0xDE, 0x7B, 0xCF, 0xBC, 0xF7, 0x9F,
  0xF0, 0xEF, 0x3F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01,
  0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC,
  0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7C, 0x00, 0x3E, 0x1C, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x0C, 0x07, 0xC1, 0xF8, 0xFF, 0x0F, 0xE1,
  0xFC, 0x1F, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x06, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x7E, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0x0F, 0xEF, 0xC0, 0x3F, 0x7C, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x60, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x9F, 0xF7, 0xE0, 0x3F,
  0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xC7,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xC1, 0xC3, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFD,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0E, 0x3F, 0x07, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x03, 0xF7, 0xFC, 0x7F, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x10, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0xFC, 0x00,
  0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x04, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x28, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x7F, 0x87, 0x80, 0xFC, 0x00, 0x81, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0x1F, 0x7F,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0x87, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0E, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF4, 0x00, 0x7F, 0x7C, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC7, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0x1F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x20, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xFB, 0x00, 0xFD, 0xF1, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F, 0x07, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x20, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0xFF, 0xCF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFF,
  0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1,
  0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xE1,
  0xFF, 0x07, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0x00, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0x9F,
  0xC0, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x0F, 0xF3, 0xF0,
  0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF,
  0xFD, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xE0, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFC, 0x3F, 0x7F, 0x01, 0xF7, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xF7, 0xF0, 0x1F, 0x7F, 0xDF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFD, 0xF0, 0x06, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xF0, 0x3C, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF6, 0x00,
  0x3F, 0x7C, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0x0A, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x20, 0x3F, 0xEF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x80, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0xEF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07,
  0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78,
  0x7E, 0x3E, 0x78, 0xFE, 0x3E, 0x78, 0xFF, 0x3E, 0x7C, 0xFF, 0x3E, 0x7C,
  0xEF, 0x3C, 0x7D, 0xEF, 0xBC, 0x3D, 0xE7, 0xBC, 0x3D, 0xE7, 0xBC, 0x3F,
  0xC7, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF0, 0xFE, 0x00, 0x7E, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x18,
  0x1F, 0xF0, 0x1F, 0x3F, 0xFC, 0x1E, 0x3F, 0xFF, 0x7E, 0x7F, 0xFF, 0xFE,
  0x7E, 0x7F, 0xFC, 0x78, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0x08, 0x01, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 33, 26, 9, -32 },
  { 34, 16, 14, 26, 5, -35 },
  { 62, 24, 32, 26, 1, -32 },
  { 158, 22, 41, 26, 2, -36 },
  { 271, 25, 34, 26, 0, -33 },
  { 378, 24, 33, 26, 1, -33 },
  { 477, 6, 15, 26, 10, -35 },
  { 489, 16, 45, 26, 5, -36 },
  { 579, 16, 45, 26, 5, -36 },
  { 669, 20, 20, 26, 3, -32 },
  { 719, 22, 23, 26, 2, -25 },
  { 783, 11, 16, 26, 7, -8 },
  { 805, 14, 6, 26, 6, -16 },
  { 816, 8, 9, 26, 9, -8 },
  { 825, 20, 45, 26, 3, -36 },
  { 938, 22, 34, 26, 2, -33 },
  { 1032, 20, 32, 26, 3, -32 },
  { 1112, 22, 33, 26, 2, -33 },
  { 1203, 21, 34, 26, 2, -33 },
  { 1293, 22, 32, 26, 2, -32 },
  { 1381, 21, 33, 26, 2, -32 },
  { 1468, 21, 33, 26, 2, -32 },
  { 1555, 20, 32, 26, 3, -32 },
  { 1635, 22, 34, 26, 2, -33 },
  { 1729, 21, 33, 26, 2, -33 },
  { 1816, 8, 25, 26, 9, -24 },
  { 1841, 11, 32, 26, 6, -24 },
  { 1885, 22, 22, 26, 2, -24 },
  { 1946, 22, 15, 26, 2, -21 },
  { 1988, 22, 22, 26, 2, -24 },
  { 2049, 18, 34, 26, 4, -33 },
  { 2126, 23, 40, 26, 1, -33 },
  { 2241, 25, 32, 26, 0, -32 },
  { 2341, 21, 32, 26, 3, -32 },
  { 2425, 22, 34, 26, 2, -33 },
  { 2519, 21, 32, 26, 3, -32 },
  { 2603, 20, 32, 26, 4, -32 },
  { 2683, 19, 32, 26, 4, -32 },
  { 2759, 22, 34, 26, 2, -33 },
  { 2853, 21, 32, 26, 2, -32 },
  { 2937, 20, 32, 26, 3, -32 },
  { 3017, 20, 33, 26, 2, -32 },
  { 3100, 22, 32, 26, 3, -32 },
  { 3188, 20, 32, 26, 4, -32 },
  { 3268, 23, 32, 26, 1, -32 },
  { 3360, 20, 32, 26, 3, -32 },
  { 3440, 23, 34, 26, 1, -33 },
  { 3538, 21, 32, 26, 3, -32 },
  { 3622, 23, 42, 26, 1, -33 },
  { 3743, 22, 32, 26, 3, -32 },
  { 3831, 21, 34, 26, 2, -33 },
  { 3921, 22, 32, 26, 2, -32 },
  { 4009, 22, 33, 26, 2, -32 },
  { 4100, 24, 32, 26, 1, -32 },
  { 4196, 23, 32, 26, 1, -32 },
  { 4288, 24, 32, 26, 1, -32 },
  { 4384, 24, 32, 26, 1, -32 },
  { 4480, 21, 32, 26, 2, -32 },
  { 4564, 14, 45, 26, 6, -36 },
  { 4643, 20, 45, 26, 3, -36 },
  { 4756, 13, 45, 26, 6, -36 },
  { 4830, 24, 18, 26, 1, -32 },
  { 4884, 25, 5, 26, 0, 4 },
  { 4900, 10, 9, 26, 8, -36 },
  { 4912, 21, 26, 26, 2, -25 },
  { 4981, 21, 37, 26, 3, -36 },
  { 5079, 22, 26, 26, 2, -25 },
  { 5151, 20, 37, 26, 2, -36 },
  { 5244, 22, 26, 26, 2, -25 },
  { 5316, 23, 36, 26, 2, -36 },
  { 5420, 20, 34, 26, 2, -25 },
  { 5505, 20, 36, 26, 3, -36 },
  { 5595, 22, 36, 26, 2, -35 },
  { 5694, 17, 44, 26, 3, -35 },
  { 5788, 22, 36, 26, 3, -36 },
  { 5887, 22, 36, 26, 2, -35 },
  { 5986, 22, 24, 26, 2, -24 },
  { 6052, 20, 25, 26, 3, -25 },
  { 6115, 22, 26, 26, 2, -25 },
  { 6187, 21, 34, 26, 3, -25 },
  { 6277, 20, 34, 26, 2, -25 },
  { 6362, 18, 25, 26, 5, -25 },
  { 6419, 20, 26, 26, 3, -25 },
  { 6484, 22, 32, 26, 2, -31 },
  { 6572, 19, 25, 26, 3, -24 },
  { 6632, 24, 24, 26, 1, -24 },
  { 6704, 24, 24, 26, 1, -24 },
  { 6776, 24, 24, 26, 1, -24 },
  { 6848, 23, 33, 26, 1, -24 },
  { 6943, 18, 24, 26, 4, -24 },
  { 6997, 19, 45, 26, 3, -36 },
  { 7104, 6, 45, 26, 10, -36 },
  { 7138, 19, 45, 26, 3, -36 },
  { 7245, 24, 9, 26, 1, -18 },
};

const GFXfont UbuntuSansMono_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_SEMIBOLD46PT7B_H_
