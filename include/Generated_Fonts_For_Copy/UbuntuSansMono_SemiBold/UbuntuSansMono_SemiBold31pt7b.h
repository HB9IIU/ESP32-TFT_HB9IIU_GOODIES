#ifndef _UBUNTUSANSMONO_SEMIBOLD31PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xE7, 0x00, 0x00, 0x77,
  0xFF, 0xF7, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0x1E, 0xE3, 0xDC,
  0x7B, 0x8E, 0x70, 0xCE, 0x18, 0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0E,
  0x3C, 0x0E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x38, 0x1C,
  0x78, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x71, 0xE0, 0x71, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0xC7, 0xFF, 0x9F, 0xDF,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7B, 0x01,
  0xF7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0xBF, 0x03, 0x9F, 0xC1, 0xCC, 0xE1, 0xCE, 0x70,
  0xC7, 0x18, 0xE3, 0x9C, 0xE0, 0xCE, 0x70, 0x7F, 0x70, 0x3F, 0x70, 0x07,
  0x38, 0x00, 0x38, 0x00, 0x39, 0xE0, 0x1D, 0xF8, 0x1C, 0xCE, 0x1C, 0xE7,
  0x0E, 0x73, 0x8E, 0x39, 0xC6, 0x1C, 0xE7, 0x0E, 0x77, 0x03, 0xF7, 0x80,
  0xF8, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x38, 0xF0, 0x78, 0x70, 0x78,
  0xF0, 0x78, 0xF0, 0x39, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x1C, 0x3F,
  0x1E, 0x7F, 0x9E, 0x73, 0xDC, 0xF1, 0xFC, 0xE1, 0xFC, 0xE0, 0xF8, 0xE0,
  0x78, 0xF0, 0xFC, 0x7F, 0xFE, 0x7F, 0xDE, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xEE, 0xEE, 0x00, 0x40, 0x18, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x80, 0x10, 0x20, 0x0E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x80, 0xE0, 0x08, 0x00, 0x07, 0x80, 0x1E, 0x04, 0x70, 0xBD, 0xCE, 0xFB,
  0xFB, 0xFF, 0xF3, 0xFF, 0x03, 0xE0, 0x1F, 0xC0, 0xF7, 0x87, 0xCF, 0x0E,
  0x38, 0x08, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x08, 0x79, 0xFB,
  0xF7, 0xE7, 0xC3, 0x8E, 0xF9, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x23, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE1, 0xF3, 0xE7, 0x83, 0xCF, 0x03, 0x9C, 0x07, 0xB8,
  0x0F, 0xF0, 0x1F, 0xE7, 0x3F, 0xCF, 0x7F, 0x9E, 0xFF, 0x39, 0xFE, 0x03,
  0xDC, 0x07, 0xB8, 0x0F, 0x78, 0x1C, 0xF0, 0x78, 0xF1, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x1F, 0x01, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC1, 0xEF, 0x06, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07,
  0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x1F, 0x81, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C,
  0x60, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x81, 0xFF, 0x8F,
  0xFF, 0x1E, 0x7C, 0x40, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x7F, 0x81, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x01, 0xEC, 0x0F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0x9E,
  0x0F, 0x3C, 0x1C, 0x78, 0x70, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xFF, 0xFD, 0xFF, 0xCF,
  0xFC, 0x00, 0x00, 0x10, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x3F, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF3, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0,
  0x7B, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xE7, 0x87, 0x9F,
  0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x7C, 0x3C, 0x7E,
  0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xDF, 0x8F, 0x0F, 0x9C, 0x07, 0xB8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0xF0, 0x7B, 0xC1, 0xEE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFF, 0x3F, 0xF8, 0x7F,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x01, 0xF0, 0x00, 0x23, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x08,
  0xFB, 0xFF, 0xFE, 0x78, 0x08, 0x3E, 0x3F, 0x3F, 0x3E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x3E, 0x3E, 0x3F, 0x3F, 0x1E, 0x0E, 0x1E, 0x7C,
  0xF8, 0x60, 0x00, 0x18, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFC,
  0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0xFC, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00,
  0xF8, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x80,
  0x1F, 0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x07, 0xC0, 0x0E, 0x00,
  0x00, 0x3F, 0x8F, 0xFC, 0xFF, 0xEE, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x9E, 0x3F, 0x3C, 0x7E, 0x78, 0xFC, 0xE1,
  0xF9, 0xC3, 0xF3, 0xC7, 0xE7, 0x8F, 0xC7, 0x9F, 0x8F, 0xFB, 0x8F, 0xF7,
  0x07, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x82, 0x0F, 0xFC, 0x0F, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x80,
  0x3B, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x87,
  0x03, 0x83, 0xC1, 0xC1, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0xFF, 0x00, 0x78, 0x3E, 0x03,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0xF3, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0xF1, 0xFB, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x7F, 0xF9, 0xFD, 0xE3, 0xC0, 0x2F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x10, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFC, 0xF0, 0xFB, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC1, 0xEF, 0x1F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF9, 0xFD, 0xE3, 0xC0, 0x4F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x3C, 0xF8, 0x79, 0xFF, 0xF1,
  0xFF, 0xE0, 0xFF, 0xC0, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x40, 0x7B, 0x07, 0xBF, 0xFD, 0xFF,
  0xC7, 0xFC, 0x00, 0xF0, 0x7D, 0xE0, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x1E,
  0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF9, 0xE0,
  0xF3, 0xC1, 0xF7, 0x81, 0xEF, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xE1, 0xE6, 0xC7, 0xED, 0x8D, 0xDB, 0x9B, 0xB3, 0x77, 0xE6, 0xEF, 0xCF,
  0x9F, 0x9F, 0x3F, 0x1E, 0x7E, 0x38, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0xF0, 0x3F,
  0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFB, 0x8F,
  0xE7, 0x3F, 0x9C, 0xFE, 0x3B, 0xF8, 0xEF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xF7, 0xE7, 0x83, 0xCF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x70, 0x1E, 0xF0, 0x7D, 0xF0, 0xF1, 0xFF,
  0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xFF, 0x8F, 0xFF, 0xBF, 0xFE,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x81,
  0xFC, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x60, 0x3E, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xCF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC1,
  0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xC0, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF,
  0xBF, 0x1C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFC, 0x07, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x79,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03,
  0xCF, 0x01, 0xE3, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x1C,
  0x1E, 0x0F, 0x0E, 0x07, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0,
  0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xC7, 0xE3, 0xCF, 0xC7, 0x9F, 0x9F, 0x3F,
  0x3E, 0x7E, 0x6E, 0xED, 0xDD, 0xDB, 0x9B, 0xB6, 0x3F, 0x7C, 0x7E, 0xF8,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xC0, 0xF8, 0x1E, 0x78, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E,
  0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF8, 0x07, 0xBC, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78,
  0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0x20, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0xE3, 0xF1,
  0xF1, 0xE0, 0x80, 0x0F, 0x83, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x40, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF0, 0x01, 0xE0, 0x3F, 0xF3, 0xFF, 0x9F, 0xFE, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x17, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xCF, 0x1F, 0xFC, 0xFF,
  0xF7, 0xFF, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x0F, 0x7C, 0x3C, 0xFF, 0xF3, 0xFF, 0xC3,
  0xFF, 0x03, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0x83, 0xCF, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF8, 0x7C, 0x61, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xC0, 0x3F, 0xF3, 0xFF, 0xDF,
  0xFF, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xDE, 0x0F, 0x7C, 0x7C, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xDF, 0x7E, 0x7F, 0xF9, 0xFF, 0xC1, 0xF8, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x60,
  0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x20, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF4, 0x1F, 0x7F, 0xEF, 0xFE, 0xFF, 0xC1, 0xF0, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x7D, 0xE1, 0xF3, 0xC7, 0xC7, 0x8F, 0x0F, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x81, 0xEF, 0x83, 0xCF, 0x87, 0x8F, 0x8F, 0x0F, 0x9E,
  0x0F, 0x3C, 0x1F, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x20, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x7E, 0x38, 0xFC,
  0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x0F, 0x07, 0xFF, 0x3F,
  0xFD, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x78,
  0x03, 0x80, 0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x83,
  0xEF, 0x8F, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x0E, 0x03, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xEF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x3D, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x3D,
  0xF0, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0x83, 0xFF, 0xFF, 0xFD, 0xFF,
  0xEF, 0x01, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x81,
  0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0x01, 0x78, 0x01, 0xE0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x10, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xF7, 0x87,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0xF0, 0x07, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x38, 0xF7, 0x1E, 0x73,
  0x8F, 0x39, 0xCF, 0x9C, 0xE7, 0xCE, 0x73, 0xF7, 0x1D, 0xBB, 0x8F, 0xDD,
  0xC7, 0xE6, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x70, 0x78, 0x38, 0x38, 0xF8,
  0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C,
  0x7C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x0F, 0x3C, 0x1E, 0x78,
  0x1C, 0xE0, 0x3D, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x03, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x7F, 0x03, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x03, 0xE1, 0xFF, 0x0F, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0x7F, 0x8E,
  0x7F, 0xFE, 0xF7, 0xFE, 0xE1, 0xFC, 0x20, 0x70,
};

const GFXglyph UbuntuSansMono_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 11, 10, 17, 3, -24 },
  { 29, 16, 21, 17, 1, -21 },
  { 71, 15, 27, 17, 1, -24 },
  { 122, 17, 22, 17, 0, -22 },
  { 169, 16, 22, 17, 1, -22 },
  { 213, 4, 10, 17, 7, -24 },
  { 218, 11, 31, 17, 3, -25 },
  { 261, 11, 31, 17, 3, -25 },
  { 304, 14, 13, 17, 2, -21 },
  { 327, 15, 16, 17, 1, -17 },
  { 357, 7, 11, 17, 5, -6 },
  { 367, 9, 4, 17, 4, -11 },
  { 372, 6, 6, 17, 6, -6 },
  { 377, 14, 30, 17, 2, -24 },
  { 430, 15, 22, 17, 1, -22 },
  { 472, 14, 21, 17, 2, -21 },
  { 509, 14, 22, 17, 2, -22 },
  { 548, 14, 22, 17, 2, -22 },
  { 587, 15, 21, 17, 1, -21 },
  { 627, 13, 21, 17, 2, -21 },
  { 662, 14, 22, 17, 2, -22 },
  { 701, 14, 21, 17, 2, -21 },
  { 738, 15, 22, 17, 1, -22 },
  { 780, 14, 22, 17, 2, -22 },
  { 819, 6, 17, 17, 6, -17 },
  { 832, 8, 22, 17, 4, -17 },
  { 854, 14, 14, 17, 2, -16 },
  { 879, 15, 10, 17, 1, -14 },
  { 898, 15, 14, 17, 1, -16 },
  { 925, 12, 22, 17, 3, -22 },
  { 958, 15, 27, 17, 1, -22 },
  { 1009, 17, 21, 17, 0, -21 },
  { 1054, 14, 22, 17, 2, -22 },
  { 1093, 15, 22, 17, 1, -22 },
  { 1135, 14, 22, 17, 2, -22 },
  { 1174, 14, 21, 17, 2, -21 },
  { 1211, 13, 21, 17, 2, -21 },
  { 1246, 15, 22, 17, 1, -22 },
  { 1288, 14, 21, 17, 2, -21 },
  { 1325, 13, 21, 17, 2, -21 },
  { 1360, 13, 21, 17, 2, -21 },
  { 1395, 15, 21, 17, 2, -21 },
  { 1435, 13, 21, 17, 3, -21 },
  { 1470, 15, 21, 17, 1, -21 },
  { 1510, 14, 21, 17, 2, -21 },
  { 1547, 15, 22, 17, 1, -22 },
  { 1589, 14, 22, 17, 2, -22 },
  { 1628, 15, 28, 17, 1, -22 },
  { 1681, 15, 22, 17, 2, -22 },
  { 1723, 14, 22, 17, 2, -22 },
  { 1762, 15, 21, 17, 1, -21 },
  { 1802, 15, 21, 17, 1, -21 },
  { 1842, 17, 21, 17, 0, -21 },
  { 1887, 15, 21, 17, 1, -21 },
  { 1927, 16, 21, 17, 1, -21 },
  { 1969, 17, 21, 17, 0, -21 },
  { 2014, 14, 21, 17, 2, -21 },
  { 2051, 9, 30, 17, 4, -24 },
  { 2085, 14, 30, 17, 2, -24 },
  { 2138, 9, 30, 17, 4, -24 },
  { 2172, 16, 12, 17, 1, -21 },
  { 2196, 17, 4, 17, 0, 2 },
  { 2205, 7, 6, 17, 5, -24 },
  { 2211, 13, 17, 17, 2, -17 },
  { 2239, 14, 24, 17, 2, -24 },
  { 2281, 14, 17, 17, 2, -17 },
  { 2311, 14, 24, 17, 1, -24 },
  { 2353, 15, 17, 17, 1, -17 },
  { 2385, 15, 24, 17, 2, -24 },
  { 2430, 14, 23, 17, 1, -17 },
  { 2471, 13, 24, 17, 2, -24 },
  { 2510, 15, 24, 17, 1, -24 },
  { 2555, 12, 30, 17, 2, -24 },
  { 2600, 15, 24, 17, 2, -24 },
  { 2645, 15, 24, 17, 1, -24 },
  { 2690, 15, 16, 17, 1, -16 },
  { 2720, 13, 17, 17, 2, -17 },
  { 2748, 15, 17, 17, 1, -17 },
  { 2780, 14, 23, 17, 2, -17 },
  { 2821, 14, 23, 17, 1, -17 },
  { 2862, 13, 17, 17, 3, -17 },
  { 2890, 13, 17, 17, 2, -17 },
  { 2918, 14, 21, 17, 2, -21 },
  { 2955, 13, 16, 17, 2, -16 },
  { 2981, 16, 16, 17, 1, -16 },
  { 3013, 17, 16, 17, 0, -16 },
  { 3047, 16, 16, 17, 1, -16 },
  { 3079, 15, 22, 17, 1, -16 },
  { 3121, 13, 16, 17, 2, -16 },
  { 3147, 13, 30, 17, 2, -24 },
  { 3196, 4, 30, 17, 7, -24 },
  { 3211, 13, 30, 17, 2, -24 },
  { 3260, 16, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_SEMIBOLD31PT7B_H_
