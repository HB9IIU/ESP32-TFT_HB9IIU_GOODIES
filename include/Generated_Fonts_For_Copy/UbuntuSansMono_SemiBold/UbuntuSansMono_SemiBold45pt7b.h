#ifndef _UBUNTUSANSMONO_SEMIBOLD45PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F,
  0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xC0, 0x01, 0xF0,
  0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F,
  0x80, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F,
  0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC0, 0x18, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF6, 0x00, 0x1F, 0xBF, 0x07, 0xFD, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xCF, 0xF8, 0x07, 0xCF, 0xFC,
  0x03, 0xC7, 0x9E, 0x03, 0xC3, 0xC7, 0x83, 0xE1, 0xC3, 0xC1, 0xE0, 0xE1,
  0xE1, 0xE0, 0x70, 0xF0, 0xF0, 0x38, 0x78, 0xF0, 0x1E, 0x3C, 0xF8, 0x0F,
  0x3C, 0x78, 0x07, 0xFE, 0x78, 0x01, 0xFE, 0x7C, 0x00, 0x7F, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7F,
  0x80, 0x1F, 0x7F, 0xC0, 0x0F, 0x3F, 0xF0, 0x0F, 0x1E, 0x78, 0x07, 0x9E,
  0x1C, 0x07, 0x8F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC3, 0xC1,
  0xE1, 0xC3, 0xE0, 0x71, 0xE1, 0xE0, 0x3C, 0xF1, 0xE0, 0x1F, 0xF9, 0xF0,
  0x07, 0xF9, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xE1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x3F, 0xF0,
  0xF8, 0xFF, 0xF1, 0xE3, 0xF3, 0xF3, 0xC7, 0xC7, 0xFF, 0x8F, 0x87, 0xFF,
  0x3E, 0x07, 0xFC, 0x7C, 0x07, 0xF8, 0xF8, 0x07, 0xF1, 0xF0, 0x07, 0xE1,
  0xF0, 0x1F, 0xC3, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87,
  0xFF, 0x9F, 0x83, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFB,
  0xEF, 0x9E, 0x79, 0xC0, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x08, 0x20, 0x00,
  0x60, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0x0F, 0x82,
  0x1E, 0x3C, 0x79, 0xF9, 0xCF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0xC0,
  0x3F, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0x87, 0xC0, 0x38, 0x3C, 0x00, 0xC0,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0x03, 0xF8, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xC7, 0xF0, 0xFE, 0x03, 0xC0,
  0xF8, 0x3E, 0x3F, 0x8F, 0xE1, 0xF8, 0x3E, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xC3, 0xF1, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x82, 0x0F, 0xFC, 0x3C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x1C, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0x8F, 0xC0, 0x60, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x07, 0xF0, 0xE0, 0x1F, 0x82, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x07, 0xF0, 0x40, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x90,
  0x01, 0xFC, 0xF0, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF4, 0x00, 0x7F, 0x78, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x3E,
  0x1F, 0xE3, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xCF, 0xF8, 0xFC, 0x0F, 0xE7, 0xC0, 0x3F, 0x7E, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7E, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF,
  0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xF8, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x07, 0x83,
  0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7E, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x7F,
  0x1F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F, 0x03, 0xC0, 0x78, 0x3E, 0x3F,
  0xCF, 0xF1, 0xFC, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9C, 0x0F, 0xE4, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x1F, 0x83, 0xF0, 0x1F, 0x07,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0,
  0x3F, 0xFB, 0xC0, 0xFF, 0xF7, 0x83, 0xFF, 0xEF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xDF, 0xFC, 0x7E, 0x1F, 0xF8, 0xF8, 0x3F, 0xF1, 0xF0, 0x7F, 0xE3, 0xE0,
  0xFF, 0xC7, 0xC1, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0x07, 0xFE, 0x3E, 0x0F,
  0xFC, 0x7C, 0x1F, 0x78, 0xFC, 0x3E, 0xF0, 0xFC, 0xFD, 0xE1, 0xFF, 0xFB,
  0xE1, 0xFF, 0xF7, 0xC1, 0xFF, 0xE7, 0x80, 0xFF, 0x8F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x60, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x01, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0x83, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x38,
  0xFE, 0x00, 0x4F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x04, 0x7F, 0xE1, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7C, 0x3F, 0xE3, 0xE0, 0x7F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0,
  0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF,
  0x00, 0x7E, 0xF8, 0x07, 0xE7, 0xC0, 0x7F, 0x3E, 0x07, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xF0, 0x38, 0xFE, 0x00, 0x4F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF,
  0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF8, 0x07, 0xCF, 0xE0, 0x3E, 0x7F, 0xC3,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x1F, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x20, 0x07, 0xE3, 0x00, 0x7E, 0x7C, 0x1F, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0xF8, 0x03,
  0xFB, 0xE0, 0x1F, 0xCF, 0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0xC3,
  0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0xC0, 0xF8, 0x7E, 0x03, 0xE3,
  0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFE, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xEF, 0xF0, 0x0F,
  0x9F, 0xC0, 0x3E, 0x3F, 0x80, 0xF8, 0x7F, 0x03, 0xE0, 0xFE, 0x0F, 0x81,
  0xF8, 0x3E, 0x07, 0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7F,
  0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x7F, 0x0E, 0xE0, 0xFF, 0x3D, 0xC1,
  0xDE, 0x7B, 0xC7, 0xBC, 0xF7, 0x8F, 0x79, 0xF7, 0x1C, 0xF3, 0xEF, 0x79,
  0xE7, 0xDE, 0xF3, 0xCF, 0x9D, 0xE7, 0x9F, 0x3F, 0x8F, 0x3C, 0x7F, 0x1E,
  0x78, 0xFE, 0x3C, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7,
  0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFB, 0xE1, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x7F, 0xF3, 0xE3, 0xFF,
  0x8F, 0x1F, 0xFC, 0x7C, 0xFF, 0xE1, 0xE7, 0xFF, 0x0F, 0xBF, 0xF8, 0x3D,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x01, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x80, 0x1F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE0,
  0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x1F, 0xF3, 0xF0, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x81, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x03, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7C, 0x1F, 0xE3, 0xE0, 0x3F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xF3, 0xE0, 0x3F, 0x9F, 0x0F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x01, 0xF9, 0xF0,
  0x0F, 0xCF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0x80, 0x61, 0xF8, 0x01, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC8, 0x00, 0xFE, 0xF8,
  0x0F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0xE1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF, 0x0F, 0x87, 0x9E, 0x3F,
  0x8F, 0x3C, 0x7F, 0x1E, 0x78, 0xFE, 0x3C, 0xF1, 0xDE, 0x79, 0xE7, 0xBC,
  0xF3, 0xCF, 0x39, 0xE7, 0x9C, 0x7B, 0xCF, 0x78, 0xF7, 0x9E, 0xF1, 0xEF,
  0x1D, 0xC1, 0xDE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x00,
  0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07,
  0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0x7C,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xF7, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0xBE, 0x00,
  0x3F, 0x1C, 0x00, 0x38, 0x10, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20,
  0x0C, 0x07, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x1E, 0x01, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7E, 0x01,
  0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xF0,
  0x1F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0,
  0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF8, 0xFF, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xE0, 0x09, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF1, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0xBF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x87,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x03,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xE7, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0xE3, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x40, 0x07, 0xE7, 0xE1, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x1C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x0F,
  0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF9, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFB, 0x01, 0xFD, 0xF1, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE,
  0x0F, 0xFE, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xEF, 0xC0, 0x7F, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC,
  0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE3,
  0xF0, 0x3F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x00,
  0x7E, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF9, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0C, 0x00,
  0x1F, 0x87, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xC3, 0xE3, 0xEF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8,
  0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F,
  0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x1F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0xE3, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF,
  0xF9, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFC, 0x20, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0x7E,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF8, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x43, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x80, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFC, 0x01,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7D, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x40, 0xFF, 0x1E, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0xC7, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x50, 0x00, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x3C,
  0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7E, 0x3E, 0x78, 0x7E,
  0x3E, 0x78, 0xFE, 0x3C, 0x78, 0xFE, 0x3C, 0x78, 0xFF, 0x3C, 0x7D, 0xEF,
  0x3C, 0x7D, 0xEF, 0x3C, 0x3D, 0xEF, 0x7C, 0x3D, 0xC7, 0xF8, 0x3F, 0xC7,
  0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0xFC, 0x01,
  0xF8, 0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xF8, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0xF9, 0xF8, 0x01,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0x1F, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x3C, 0x7F, 0xE0, 0xF9, 0xFF,
  0xF3, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9E, 0x0F, 0xFE, 0x7C, 0x07,
  0xF8, 0x10, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 32, 25, 9, -31 },
  { 33, 15, 13, 25, 5, -34 },
  { 58, 23, 31, 25, 1, -31 },
  { 148, 21, 40, 25, 2, -35 },
  { 253, 25, 33, 25, 0, -32 },
  { 357, 23, 32, 25, 1, -32 },
  { 449, 6, 14, 25, 10, -34 },
  { 460, 16, 45, 25, 5, -36 },
  { 550, 15, 45, 25, 5, -36 },
  { 635, 21, 19, 25, 2, -31 },
  { 685, 21, 22, 25, 2, -24 },
  { 743, 11, 16, 25, 7, -8 },
  { 765, 13, 6, 25, 6, -16 },
  { 775, 9, 9, 25, 8, -8 },
  { 786, 20, 43, 25, 3, -35 },
  { 894, 21, 33, 25, 2, -32 },
  { 981, 20, 31, 25, 3, -31 },
  { 1059, 21, 32, 25, 2, -32 },
  { 1143, 21, 33, 25, 2, -32 },
  { 1230, 23, 31, 25, 1, -31 },
  { 1320, 20, 32, 25, 2, -31 },
  { 1400, 21, 32, 25, 2, -31 },
  { 1484, 20, 31, 25, 3, -31 },
  { 1562, 21, 33, 25, 2, -32 },
  { 1649, 21, 32, 25, 2, -32 },
  { 1733, 9, 25, 25, 8, -24 },
  { 1762, 11, 32, 25, 6, -24 },
  { 1806, 21, 22, 25, 2, -24 },
  { 1864, 21, 14, 25, 2, -20 },
  { 1901, 21, 22, 25, 2, -24 },
  { 1959, 18, 33, 25, 4, -32 },
  { 2034, 23, 39, 25, 1, -32 },
  { 2147, 25, 31, 25, 0, -31 },
  { 2244, 20, 32, 25, 3, -32 },
  { 2324, 21, 33, 25, 2, -32 },
  { 2411, 21, 32, 25, 3, -32 },
  { 2495, 19, 31, 25, 4, -31 },
  { 2569, 18, 31, 25, 4, -31 },
  { 2639, 21, 33, 25, 2, -32 },
  { 2726, 21, 31, 25, 2, -31 },
  { 2808, 19, 31, 25, 3, -31 },
  { 2882, 20, 32, 25, 2, -31 },
  { 2962, 22, 31, 25, 3, -31 },
  { 3048, 19, 31, 25, 4, -31 },
  { 3122, 23, 31, 25, 1, -31 },
  { 3212, 21, 31, 25, 2, -31 },
  { 3294, 23, 33, 25, 1, -32 },
  { 3389, 21, 32, 25, 3, -32 },
  { 3473, 23, 40, 25, 1, -32 },
  { 3588, 21, 32, 25, 3, -32 },
  { 3672, 21, 33, 25, 2, -32 },
  { 3759, 23, 31, 25, 1, -31 },
  { 3849, 21, 32, 25, 2, -31 },
  { 3933, 24, 31, 25, 1, -31 },
  { 4026, 23, 31, 25, 1, -31 },
  { 4116, 23, 31, 25, 1, -31 },
  { 4206, 24, 31, 25, 1, -31 },
  { 4299, 21, 31, 25, 2, -31 },
  { 4381, 14, 43, 25, 6, -35 },
  { 4457, 20, 43, 25, 3, -35 },
  { 4565, 13, 43, 25, 6, -35 },
  { 4635, 23, 18, 25, 1, -31 },
  { 4687, 25, 5, 25, 0, 3 },
  { 4703, 10, 9, 25, 8, -35 },
  { 4715, 20, 25, 25, 2, -24 },
  { 4778, 21, 36, 25, 3, -35 },
  { 4873, 21, 25, 25, 2, -24 },
  { 4939, 20, 36, 25, 2, -35 },
  { 5029, 21, 25, 25, 2, -24 },
  { 5095, 23, 35, 25, 2, -35 },
  { 5196, 20, 32, 25, 2, -24 },
  { 5276, 19, 35, 25, 3, -35 },
  { 5360, 21, 36, 25, 2, -35 },
  { 5455, 17, 44, 25, 3, -35 },
  { 5549, 21, 35, 25, 3, -35 },
  { 5641, 21, 36, 25, 2, -35 },
  { 5736, 22, 24, 25, 2, -24 },
  { 5802, 19, 24, 25, 3, -24 },
  { 5859, 22, 25, 25, 2, -24 },
  { 5928, 20, 32, 25, 3, -24 },
  { 6008, 20, 32, 25, 2, -24 },
  { 6088, 18, 24, 25, 5, -24 },
  { 6142, 19, 25, 25, 3, -24 },
  { 6202, 21, 32, 25, 2, -31 },
  { 6286, 19, 25, 25, 3, -24 },
  { 6346, 23, 24, 25, 1, -24 },
  { 6415, 24, 24, 25, 1, -24 },
  { 6487, 23, 24, 25, 1, -24 },
  { 6556, 23, 32, 25, 1, -24 },
  { 6648, 19, 24, 25, 3, -24 },
  { 6705, 19, 43, 25, 3, -35 },
  { 6808, 5, 43, 25, 10, -35 },
  { 6835, 19, 43, 25, 3, -35 },
  { 6938, 23, 9, 25, 1, -18 },
};

const GFXfont UbuntuSansMono_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_SEMIBOLD45PT7B_H_
