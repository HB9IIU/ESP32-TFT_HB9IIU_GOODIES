#ifndef _UBUNTUSANSMONO_SEMIBOLD9PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x3F, 0xD5, 0xF5, 0x30, 0x23, 0x90, 0xC1, 0x0F,
  0xC4, 0xCE, 0x98, 0x75, 0xCC, 0x72, 0x9B, 0xE9, 0x3C, 0xE0, 0x2A, 0x49,
  0x32, 0x20, 0x88, 0x92, 0x5A, 0x80, 0x27, 0xD4, 0xA0, 0x21, 0x3E, 0x42,
  0x00, 0x4D, 0x40, 0xE0, 0xC0, 0x32, 0x24, 0x44, 0x88, 0x80, 0x72, 0xEB,
  0x15, 0x38, 0x4C, 0x44, 0x4F, 0xF0, 0x84, 0x44, 0x3C, 0x70, 0x8C, 0x21,
  0xF8, 0x31, 0x95, 0x27, 0x88, 0x74, 0x71, 0x1F, 0x32, 0x1D, 0xB5, 0xB8,
  0xF2, 0x44, 0x4C, 0x72, 0x9C, 0xA8, 0xB8, 0x76, 0xD6, 0xE1, 0x30, 0xD8,
  0x51, 0x58, 0x0B, 0xB0, 0x60, 0x80, 0xF8, 0x3E, 0x83, 0x86, 0xC8, 0x00,
  0xE5, 0xA0, 0x80, 0x74, 0x6F, 0x5A, 0xAD, 0xE0, 0x22, 0x94, 0xAF, 0xC4,
  0xEA, 0xEB, 0x9E, 0x7A, 0x21, 0x84, 0x3C, 0xEB, 0x99, 0xAE, 0xE8, 0xE8,
  0x8F, 0xF3, 0xC9, 0x00, 0x7A, 0x21, 0x94, 0xBC, 0xDE, 0xFF, 0xBD, 0xEC,
  0xE9, 0x25, 0xC0, 0x71, 0x11, 0x1F, 0xBE, 0xCC, 0xAB, 0x88, 0x88, 0x8F,
  0x56, 0xEB, 0x58, 0xC4, 0xCE, 0x7B, 0xDD, 0xEC, 0x76, 0xE3, 0x1D, 0xB8,
  0xE9, 0xBE, 0x88, 0x76, 0xE3, 0x1D, 0xB8, 0x83, 0xEA, 0xAE, 0xAB, 0x72,
  0x18, 0x21, 0xF8, 0xF9, 0x08, 0x42, 0x10, 0xDE, 0xF7, 0xBD, 0xB8, 0x8A,
  0xD4, 0xA5, 0x10, 0x8C, 0x6B, 0x55, 0xA8, 0xDA, 0x88, 0xE5, 0x6C, 0xDA,
  0x94, 0x42, 0x10, 0x70, 0x88, 0xC4, 0x7C, 0xF2, 0x49, 0x24, 0xE0, 0x88,
  0xC4, 0x44, 0x22, 0x30, 0xE4, 0x92, 0x49, 0xE0, 0x22, 0xB6, 0xF8, 0x90,
  0x71, 0x7D, 0x70, 0x88, 0xEB, 0x9B, 0xE0, 0x3A, 0x30, 0x87, 0x80, 0x11,
  0x7D, 0x9D, 0x70, 0x72, 0xFF, 0x87, 0x00, 0x3B, 0x3E, 0xC6, 0x31, 0x80,
  0x75, 0xDD, 0x79, 0x60, 0x93, 0xDB, 0x68, 0x61, 0x38, 0x42, 0x10, 0xE0,
  0x67, 0x92, 0x4D, 0xC0, 0x88, 0xBE, 0xCA, 0xB0, 0xE1, 0x08, 0x42, 0x10,
  0xE0, 0xF5, 0x6B, 0x18, 0x80, 0xF6, 0xDA, 0x72, 0xE3, 0xB7, 0x00, 0xEB,
  0x9B, 0xE8, 0x80, 0x75, 0x9D, 0x71, 0x10, 0xF8, 0x88, 0x80, 0xF3, 0x9E,
  0x67, 0xD8, 0xC2, 0x1C, 0xB6, 0xDE, 0x8A, 0x94, 0xA2, 0x00, 0x8D, 0x6B,
  0xA5, 0x00, 0xDA, 0x88, 0xAD, 0x80, 0xCA, 0x94, 0x62, 0x13, 0x00, 0xE5,
  0x4E, 0x69, 0x28, 0x92, 0x60, 0xFF, 0x80, 0xC9, 0x22, 0x92, 0xC0, 0x47,
  0xC0,
};

const GFXglyph UbuntuSansMono_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 3, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 3, 9, 5, 1, -7 },
  { 30, 5, 4, 5, 0, -6 },
  { 33, 5, 5, 5, 0, -5 },
  { 37, 3, 4, 5, 1, -2 },
  { 39, 3, 1, 5, 1, -3 },
  { 40, 1, 2, 5, 2, -2 },
  { 41, 4, 9, 5, 1, -7 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 4, 6, 5, 1, -6 },
  { 53, 5, 6, 5, 0, -6 },
  { 57, 5, 6, 5, 0, -6 },
  { 61, 5, 6, 5, 0, -6 },
  { 65, 4, 6, 5, 0, -6 },
  { 68, 5, 6, 5, 0, -6 },
  { 72, 4, 6, 5, 1, -6 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 1, 5, 5, 2, -5 },
  { 84, 2, 7, 5, 1, -5 },
  { 86, 5, 5, 5, 0, -5 },
  { 90, 5, 3, 5, 0, -4 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 5, 7, 5, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 4, 6, 5, 1, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 3, 6, 5, 1, -6 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 3, 6, 5, 1, -6 },
  { 135, 4, 6, 5, 0, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 4, 6, 5, 1, -6 },
  { 159, 5, 8, 5, 0, -6 },
  { 164, 4, 6, 5, 1, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 5, 6, 5, 0, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 5, 6, 5, 0, -6 },
  { 195, 5, 6, 5, 0, -6 },
  { 199, 3, 9, 5, 1, -7 },
  { 203, 4, 9, 5, 1, -7 },
  { 208, 3, 9, 5, 1, -7 },
  { 212, 5, 3, 5, 0, -6 },
  { 214, 5, 1, 5, 0, 1 },
  { 215, 2, 2, 5, 2, -7 },
  { 216, 4, 5, 5, 0, -5 },
  { 219, 4, 7, 5, 1, -7 },
  { 223, 5, 5, 5, 0, -5 },
  { 227, 4, 7, 5, 0, -7 },
  { 231, 5, 5, 5, 0, -5 },
  { 235, 5, 7, 5, 0, -7 },
  { 240, 4, 7, 5, 0, -5 },
  { 244, 3, 7, 5, 1, -7 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 3, 9, 5, 1, -7 },
  { 256, 4, 7, 5, 1, -7 },
  { 260, 5, 7, 5, 0, -7 },
  { 265, 5, 5, 5, 0, -5 },
  { 269, 3, 5, 5, 1, -5 },
  { 271, 5, 5, 5, 0, -5 },
  { 275, 4, 7, 5, 1, -5 },
  { 279, 4, 7, 5, 0, -5 },
  { 283, 4, 5, 5, 1, -5 },
  { 286, 3, 5, 5, 1, -5 },
  { 288, 5, 6, 5, 0, -6 },
  { 292, 3, 5, 5, 1, -5 },
  { 294, 5, 5, 5, 0, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 5, 5, 5, 0, -5 },
  { 306, 5, 7, 5, 0, -5 },
  { 311, 3, 5, 5, 1, -5 },
  { 313, 3, 9, 5, 1, -7 },
  { 317, 1, 9, 5, 2, -7 },
  { 319, 3, 9, 5, 1, -7 },
  { 323, 5, 2, 5, 0, -4 },
};

const GFXfont UbuntuSansMono_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_SEMIBOLD9PT7B_H_
