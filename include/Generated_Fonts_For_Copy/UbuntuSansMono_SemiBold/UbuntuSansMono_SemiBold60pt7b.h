#ifndef _UBUNTUSANSMONO_SEMIBOLD60PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xE0, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7E, 0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0x01, 0xF8, 0x7F, 0xC0, 0x01, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF2,
  0x00, 0x00, 0xFF, 0x78, 0x00, 0x1F, 0xF7, 0xF0, 0x07, 0xFE, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x3F, 0xF0, 0x00, 0x3E, 0x3F,
  0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0xFC, 0x7C, 0xFC, 0x00, 0xF8, 0xFC,
  0x7C, 0x01, 0xF8, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x3E, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x3F, 0x00, 0xFC,
  0x7C, 0x7E, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0x3F,
  0xF9, 0xF8, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x1F, 0x8F, 0xF8, 0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0x00,
  0x3E, 0x3F, 0xFE, 0x00, 0x7E, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x0F,
  0x80, 0x7C, 0x3F, 0x1F, 0x80, 0x7C, 0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x3E,
  0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x3F, 0xFC, 0x7C, 0x00, 0x1F, 0xFC, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x03, 0x80, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xE0,
  0xFC, 0x3F, 0xFF, 0x83, 0xF0, 0xFE, 0xFF, 0x0F, 0xC7, 0xF1, 0xFE, 0x3F,
  0x1F, 0x83, 0xFD, 0xF8, 0xFE, 0x07, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0x8F,
  0xC0, 0x1F, 0xFE, 0x3F, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0xC3, 0xF0,
  0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xC0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C,
  0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0C,
  0x07, 0xE0, 0x21, 0xF0, 0xFC, 0x1E, 0x3F, 0x1F, 0x0F, 0xCF, 0xF9, 0xE7,
  0xF9, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x03, 0xE0,
  0x01, 0xC0, 0x78, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x0F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF0, 0x1F, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x03, 0xF8, 0x7F,
  0xC7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F,
  0x80, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0xF0, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0xC7,
  0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x3F, 0xC7, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE,
  0x1F, 0x87, 0xFF, 0xE0, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0x07, 0xF0, 0x03, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0x7F, 0x81, 0xC0, 0x07,
  0xFC, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC,
  0x18, 0x00, 0xFF, 0x82, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xA0, 0x00, 0x1F, 0xE7, 0x80,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0x00,
  0x01, 0xFF, 0x38, 0x00, 0x7F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xEF, 0xFF, 0x83, 0xFC, 0x1F, 0xFC, 0x7F, 0x80, 0x7F, 0xC7,
  0xF0, 0x03, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xFF,
  0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x1F,
  0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x06, 0x03, 0xF8, 0x7F, 0xC7, 0xFE,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC, 0x3F, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x3F, 0x87, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFE, 0x7F, 0xC3, 0xF8, 0x06, 0x00, 0x00, 0xC0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x81, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x7E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3C,
  0x03, 0xFE, 0x20, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x0C, 0xFD, 0xF8, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0xFE,
  0x07, 0xFF, 0x87, 0xE0, 0x3F, 0xFC, 0x3F, 0x01, 0xFF, 0xE1, 0xF8, 0x0F,
  0xFF, 0x0F, 0xC0, 0x7F, 0xF8, 0x7E, 0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0xFE,
  0x1F, 0x80, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xFC, 0x3F,
  0x81, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF7, 0xE0, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xE7,
  0xE0, 0x1F, 0xFE, 0x3F, 0x00, 0x0C, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0xC7, 0xF0,
  0x07, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xE7, 0xF0, 0x07, 0xF8, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0xFE, 0x00, 0x7F, 0xDF,
  0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3E, 0x0F, 0xF8, 0x00, 0x30, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x20, 0xFF, 0xC0, 0x0F, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F,
  0xFF, 0x0F, 0xE0, 0x3F, 0xF0, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x0F, 0xF8,
  0xFE, 0x01, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3E, 0x0F, 0xF8, 0x00, 0x60, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xCF, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0xC0, 0x7F, 0x87,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC4, 0x00, 0x1F, 0xE3, 0x80, 0x07, 0xF8, 0xF8, 0x07,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x1F, 0x7C, 0x7E, 0xF0, 0x7D, 0xF1, 0xFB, 0xE1, 0xF7, 0xC7,
  0xEF, 0x8F, 0x9F, 0x9F, 0x9E, 0x3E, 0x7E, 0x7E, 0x7C, 0xF9, 0xF9, 0xF9,
  0xF7, 0xC7, 0xE7, 0xE7, 0xDF, 0x1F, 0x9F, 0x8F, 0xFC, 0x7E, 0x7E, 0x3F,
  0xF1, 0xF9, 0xF8, 0xFF, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F, 0x87, 0xF8,
  0x7E, 0xFE, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0x07, 0xEF, 0xE0, 0xFC, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0x01, 0xFF,
  0xF7, 0xF0, 0x3F, 0xFE, 0x7E, 0x07, 0xFF, 0xC7, 0xE0, 0xFF, 0xF8, 0xFC,
  0x1F, 0xFF, 0x0F, 0xC3, 0xFF, 0xE1, 0xF8, 0x7F, 0xFC, 0x1F, 0x8F, 0xFF,
  0x83, 0xF1, 0xFF, 0xF0, 0x3F, 0x3F, 0xFE, 0x07, 0xE7, 0xFF, 0xC0, 0x7E,
  0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0x00, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE1, 0xFF, 0xF7, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xEF,
  0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x0F, 0xE0, 0x1F,
  0xF8, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xFE, 0x00, 0xF0, 0x7F, 0x80, 0x01, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE3, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x3F, 0xE7, 0xFE, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F,
  0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x03,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x1F, 0xBF, 0x83, 0xF0, 0x7E, 0xFE, 0x0F, 0xC1, 0xFB, 0xF8,
  0x7F, 0x07, 0xEF, 0xE1, 0xFE, 0x1F, 0xBF, 0x87, 0xF8, 0x7E, 0x7E, 0x3F,
  0xE1, 0xF9, 0xF8, 0xFF, 0x87, 0xE7, 0xE3, 0xFF, 0x1F, 0x9F, 0x8F, 0xFC,
  0x7E, 0x7E, 0x7D, 0xF1, 0xF9, 0xF9, 0xF3, 0xE7, 0xE7, 0xE7, 0xCF, 0x9F,
  0x9F, 0xBE, 0x3E, 0x7E, 0x7E, 0xF8, 0x7D, 0xF1, 0xFB, 0xE1, 0xF7, 0xC7,
  0xFF, 0x07, 0xDF, 0x1F, 0xFC, 0x0F, 0x7C, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF,
  0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x08, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0x87,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x0C, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFE, 0x01, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xFF,
  0x03, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x07, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F,
  0xF3, 0xFF, 0xCF, 0xF8, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x0E, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1E,
  0x01, 0xFF, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFE, 0x03, 0xF9, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF8,
  0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xF0, 0x03, 0xF9, 0xFF, 0x81, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x88, 0x00, 0x1F, 0xE3, 0xE0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x3F, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x06, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x20,
  0x03, 0xFC, 0x60, 0x07, 0xF9, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x03,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x1F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFB,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x06,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x01, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF,
  0xE3, 0xFE, 0x7F, 0xBF, 0x07, 0xF0, 0xFE, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0,
  0x3F, 0x07, 0xEF, 0xC0, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x0F,
  0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0x03, 0xF0,
  0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xE7, 0xF8, 0x07, 0xFE,
  0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x1F,
  0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0x80, 0xFF, 0x07, 0x80,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F,
  0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7,
  0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0x00,
  0x1E, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80,
  0x06, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xE1,
  0xFE, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x60, 0x00, 0x3F, 0x9F, 0x00,
  0x1F, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x3F, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x07, 0xE0,
  0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0,
  0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0xFC, 0x7E, 0x0F, 0xF0,
  0xFC, 0x7E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8,
  0xFC, 0x3F, 0x3F, 0xF8, 0xFC, 0x3F, 0x3E, 0xFC, 0xFC, 0x3F, 0x3E, 0x7C,
  0xF8, 0x3F, 0x3E, 0x7C, 0xF8, 0x1F, 0x7C, 0x7E, 0xF8, 0x1F, 0x7C, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x7F, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x10, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xC0, 0xFF, 0xE0, 0x0F, 0xC7, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF,
  0xC1, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xFF,
  0xFC, 0xFE, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFC,
  0x02, 0x00, 0x0F, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 43, 34, 12, -42 },
  { 55, 20, 19, 34, 7, -46 },
  { 103, 31, 42, 34, 1, -42 },
  { 266, 28, 54, 34, 3, -47 },
  { 455, 32, 44, 34, 1, -43 },
  { 631, 30, 44, 34, 2, -43 },
  { 796, 8, 20, 34, 13, -46 },
  { 816, 20, 59, 34, 7, -48 },
  { 964, 21, 59, 34, 6, -48 },
  { 1119, 27, 26, 34, 3, -42 },
  { 1207, 28, 30, 34, 3, -33 },
  { 1312, 14, 21, 34, 9, -11 },
  { 1349, 17, 7, 34, 8, -21 },
  { 1364, 12, 12, 34, 11, -11 },
  { 1382, 26, 58, 34, 4, -47 },
  { 1571, 28, 44, 34, 3, -43 },
  { 1725, 26, 42, 34, 4, -42 },
  { 1862, 28, 43, 34, 3, -43 },
  { 2013, 27, 44, 34, 3, -43 },
  { 2162, 30, 42, 34, 2, -42 },
  { 2320, 27, 43, 34, 3, -42 },
  { 2466, 27, 43, 34, 3, -42 },
  { 2612, 26, 42, 34, 4, -42 },
  { 2749, 28, 44, 34, 3, -43 },
  { 2903, 28, 43, 34, 3, -43 },
  { 3054, 12, 33, 34, 11, -32 },
  { 3104, 15, 42, 34, 8, -32 },
  { 3183, 28, 28, 34, 3, -31 },
  { 3281, 28, 19, 34, 3, -27 },
  { 3348, 28, 28, 34, 3, -31 },
  { 3446, 24, 44, 34, 5, -43 },
  { 3578, 29, 52, 34, 2, -43 },
  { 3767, 32, 42, 34, 1, -42 },
  { 3935, 27, 42, 34, 4, -42 },
  { 4077, 29, 44, 34, 2, -43 },
  { 4237, 28, 42, 34, 4, -42 },
  { 4384, 26, 42, 34, 5, -42 },
  { 4521, 25, 42, 34, 5, -42 },
  { 4653, 29, 44, 34, 2, -43 },
  { 4813, 28, 42, 34, 3, -42 },
  { 4960, 25, 42, 34, 4, -42 },
  { 5092, 26, 43, 34, 3, -42 },
  { 5232, 30, 42, 34, 3, -42 },
  { 5390, 26, 42, 34, 5, -42 },
  { 5527, 30, 42, 34, 2, -42 },
  { 5685, 27, 42, 34, 3, -42 },
  { 5827, 30, 44, 34, 2, -43 },
  { 5992, 27, 42, 34, 4, -42 },
  { 6134, 30, 53, 34, 2, -42 },
  { 6333, 28, 42, 34, 4, -42 },
  { 6480, 28, 44, 34, 3, -43 },
  { 6634, 30, 42, 34, 2, -42 },
  { 6792, 28, 43, 34, 3, -42 },
  { 6943, 32, 42, 34, 1, -42 },
  { 7111, 30, 42, 34, 2, -42 },
  { 7269, 32, 42, 34, 1, -42 },
  { 7437, 32, 42, 34, 1, -42 },
  { 7605, 28, 42, 34, 3, -42 },
  { 7752, 18, 58, 34, 8, -47 },
  { 7883, 26, 58, 34, 4, -47 },
  { 8072, 18, 58, 34, 7, -47 },
  { 8203, 30, 24, 34, 2, -42 },
  { 8293, 32, 6, 34, 1, 5 },
  { 8317, 14, 12, 34, 10, -47 },
  { 8338, 26, 33, 34, 3, -32 },
  { 8446, 27, 48, 34, 4, -47 },
  { 8608, 28, 33, 34, 3, -32 },
  { 8724, 27, 48, 34, 2, -47 },
  { 8886, 29, 33, 34, 2, -32 },
  { 9006, 30, 47, 34, 3, -47 },
  { 9183, 27, 43, 34, 2, -32 },
  { 9329, 25, 47, 34, 4, -47 },
  { 9476, 28, 47, 34, 3, -46 },
  { 9641, 23, 57, 34, 4, -46 },
  { 9805, 29, 47, 34, 4, -47 },
  { 9976, 28, 47, 34, 3, -46 },
  { 10141, 30, 32, 34, 2, -32 },
  { 10261, 25, 32, 34, 4, -32 },
  { 10361, 30, 33, 34, 2, -32 },
  { 10485, 27, 43, 34, 4, -32 },
  { 10631, 27, 43, 34, 2, -32 },
  { 10777, 24, 32, 34, 6, -32 },
  { 10873, 26, 33, 34, 4, -32 },
  { 10981, 28, 42, 34, 3, -41 },
  { 11128, 25, 32, 34, 4, -31 },
  { 11228, 31, 31, 34, 1, -31 },
  { 11349, 32, 31, 34, 1, -31 },
  { 11473, 31, 31, 34, 1, -31 },
  { 11594, 30, 42, 34, 2, -31 },
  { 11752, 24, 31, 34, 5, -31 },
  { 11845, 24, 58, 34, 5, -47 },
  { 12019, 8, 58, 34, 13, -47 },
  { 12077, 25, 58, 34, 4, -47 },
  { 12259, 30, 12, 34, 2, -24 },
};

const GFXfont UbuntuSansMono_SemiBold60pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold60pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold60pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _UBUNTUSANSMONO_SEMIBOLD60PT7B_H_
