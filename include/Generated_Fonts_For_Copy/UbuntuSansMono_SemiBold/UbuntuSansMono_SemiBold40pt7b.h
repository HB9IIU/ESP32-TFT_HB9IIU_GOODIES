#ifndef _UBUNTUSANSMONO_SEMIBOLD40PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF,
  0xF3, 0xE1, 0x00, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0x78, 0x7D,
  0xE1, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x39, 0xE0, 0xE7, 0x83, 0x8C, 0x0E,
  0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87,
  0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x9F, 0x8F,
  0x80, 0x11, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xEE, 0x01, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x3C, 0xFE, 0x01, 0xE7, 0xFC, 0x07, 0x9C, 0x70,
  0x3C, 0x71, 0xC0, 0xE1, 0xC7, 0x07, 0x87, 0x1E, 0x3C, 0x1C, 0x70, 0xE0,
  0x71, 0xC7, 0x81, 0xC7, 0x3C, 0x07, 0xFC, 0xE0, 0x0F, 0xE7, 0x80, 0x1F,
  0xBC, 0x00, 0x10, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0xF7,
  0xF8, 0x07, 0x9F, 0xE0, 0x1C, 0xF3, 0x80, 0xF3, 0x8F, 0x07, 0x8E, 0x3C,
  0x1C, 0x38, 0x70, 0xF0, 0xE3, 0xC7, 0x83, 0x8F, 0x1C, 0x0F, 0x3C, 0xF0,
  0x3F, 0xE7, 0x80, 0x7F, 0xBC, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF3, 0xE0, 0x3E, 0x1F, 0x03, 0xC1,
  0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x1F,
  0x7C, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x1E, 0x1F, 0xE1, 0xE3,
  0xFF, 0x1E, 0x7D, 0xF9, 0xE7, 0x8F, 0xDE, 0xF8, 0x7F, 0xCF, 0x83, 0xFC,
  0xF8, 0x1F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0xC1, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xF9, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF7, 0xBC, 0xE7, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xE0,
  0x03, 0x80, 0x04, 0x20, 0x00, 0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0x00, 0x08,
  0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x21, 0xE0,
  0x9E, 0x39, 0xE7, 0xEE, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xBE, 0x07, 0xCF, 0xC3, 0xF1, 0xF0, 0x78,
  0x78, 0x06, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xF1,
  0xF8, 0x1E, 0x07, 0x87, 0xCF, 0xE3, 0xF0, 0xF8, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F,
  0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0xF1, 0xFF, 0x1F, 0x3F, 0xE3, 0xE7,
  0xFC, 0x7C, 0xFF, 0x8F, 0x1F, 0xF0, 0x43, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0x7C, 0x01, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xF0, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xF0, 0x30, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0x7C, 0x3F, 0x8C,
  0x03, 0xE2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x38, 0x3F, 0x88, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFD, 0x80, 0x7E, 0x7F, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0xF8, 0x78, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFD, 0x00,
  0x7E, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC4, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF8, 0x0F,
  0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x80, 0xF1, 0xF8, 0x3E,
  0x1F, 0xCF, 0x83, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xF7, 0xF8,
  0x7C, 0x3F, 0x8F, 0x81, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x7C, 0x07,
  0xDF, 0xEF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x33, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x7E,
  0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x0F, 0x07, 0xE1, 0xFC, 0xFF,
  0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x7E, 0x1F, 0xCF, 0xF3, 0xFC, 0x7F, 0x0F, 0xC0, 0xE0, 0x78,
  0x3E, 0xFF, 0x1F, 0x87, 0x81, 0x00, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x78, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x40,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFC, 0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01,
  0xF7, 0x80, 0x0F, 0x78, 0x0F, 0xF7, 0x83, 0xFF, 0x78, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFD, 0xFF, 0x1F, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1,
  0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xF0, 0xFF,
  0x1F, 0x0F, 0x78, 0xFF, 0xF7, 0x8F, 0xFF, 0x78, 0x7F, 0xF7, 0x81, 0xFF,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x0F, 0x00, 0xF8,
  0x3C, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x83,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x01,
  0xF3, 0xE0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xC0, 0xE3, 0xF8, 0x02, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x06, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x2C, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x87, 0xF9, 0xF0, 0x3F, 0x3E,
  0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x1F, 0xBE, 0x07, 0xE7, 0xC1, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC0, 0xE3, 0xF0, 0x02, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x80, 0x7E,
  0xE0, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8,
  0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8, 0x7E,
  0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80,
  0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x0E, 0xE7, 0xF0, 0xEE, 0x7B, 0x8E,
  0xE7, 0xB9, 0xEE, 0x7B, 0x9C, 0xE7, 0xBD, 0xCE, 0x79, 0xFC, 0xF7, 0x9F,
  0x8F, 0x79, 0xF8, 0xF7, 0x8F, 0x8F, 0x78, 0xF8, 0xF7, 0x8F, 0x0F, 0x78,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xBC,
  0x3F, 0xEF, 0x0F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x8F, 0x3F, 0xE3, 0xCF,
  0xF8, 0x7B, 0xFE, 0x1E, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x3E, 0x03,
  0xE3, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xF8, 0x7F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x0F, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E, 0x7E, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x02, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF8,
  0x7F, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x07,
  0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0x03, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF4, 0x00, 0x7D, 0xC0, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x01, 0xF3, 0xE0, 0x7E,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0C, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x3C, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x83,
  0xE0, 0x7C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x78, 0x03,
  0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0xF0, 0xF7, 0x8F, 0x0F, 0x78, 0xF8, 0xF7, 0x9F,
  0x8F, 0x79, 0xF8, 0xF7, 0x9F, 0xCF, 0x7B, 0xDC, 0xE7, 0xBD, 0xCE, 0x7B,
  0x9E, 0xE7, 0xB8, 0xEE, 0x7F, 0x8E, 0xE7, 0xF0, 0xEE, 0x7F, 0x07, 0xE7,
  0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E,
  0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0,
  0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x7D, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0,
  0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0xC7, 0xE0,
  0x3F, 0x7E, 0x00, 0xF9, 0xE0, 0x07, 0xE3, 0x00, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x18, 0x1F, 0x1F,
  0xC7, 0xF0, 0xFC, 0x1C, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x83, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x08,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xF0, 0xFD, 0xF8, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF3, 0xF0, 0x7C, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x40, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0xBF, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x31, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xF0, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xFC, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF9, 0x80,
  0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0x00,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x38, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x30, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0x3F,
  0xF0, 0x03, 0x80, 0x38, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF0, 0xFC,
  0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xC0,
  0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7C, 0x0F, 0x8F, 0x81, 0xF9,
  0xF0, 0x1F, 0xBE, 0x01, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xDF, 0x8F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xF1, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0,
  0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F,
  0x0F, 0xF8, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x20, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x07, 0xEF, 0x80, 0xFB, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC, 0x1F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x7E, 0x0F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xF7, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x13, 0xE0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x10, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xEF, 0x0F, 0x0F, 0x78, 0x78, 0x7B, 0xC3, 0xE3, 0xDE, 0x1F,
  0x1E, 0x71, 0xF8, 0xF3, 0xCF, 0xC7, 0x9E, 0x7F, 0x3C, 0xF3, 0xF9, 0xC7,
  0xBD, 0xCE, 0x3D, 0xCF, 0xF1, 0xEE, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F,
  0xE1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00,
  0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x8F,
  0x80, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0x9F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x03, 0xE7,
  0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x06, 0x00, 0x81, 0xFC,
  0x07, 0x3F, 0xF0, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x8F, 0xFE, 0xF0,
  0x3F, 0xC3, 0x00, 0xF8,
};

const GFXglyph UbuntuSansMono_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 29, 22, 8, -28 },
  { 27, 14, 12, 22, 4, -30 },
  { 48, 21, 28, 22, 1, -28 },
  { 122, 19, 35, 22, 2, -31 },
  { 206, 22, 29, 22, 0, -28 },
  { 286, 20, 28, 22, 1, -28 },
  { 356, 5, 13, 22, 9, -30 },
  { 365, 14, 40, 22, 4, -32 },
  { 435, 14, 40, 22, 4, -32 },
  { 505, 18, 17, 22, 2, -28 },
  { 544, 19, 20, 22, 2, -22 },
  { 592, 10, 14, 22, 6, -7 },
  { 610, 12, 5, 22, 5, -14 },
  { 618, 8, 7, 22, 7, -7 },
  { 625, 18, 38, 22, 2, -31 },
  { 711, 19, 29, 22, 2, -28 },
  { 780, 17, 28, 22, 3, -28 },
  { 840, 18, 28, 22, 2, -28 },
  { 903, 18, 29, 22, 2, -28 },
  { 969, 20, 28, 22, 1, -28 },
  { 1039, 18, 29, 22, 2, -28 },
  { 1105, 18, 29, 22, 2, -28 },
  { 1171, 18, 28, 22, 2, -28 },
  { 1234, 19, 29, 22, 2, -28 },
  { 1303, 18, 28, 22, 2, -28 },
  { 1366, 8, 21, 22, 7, -21 },
  { 1387, 10, 28, 22, 5, -21 },
  { 1422, 19, 19, 22, 2, -21 },
  { 1468, 19, 13, 22, 2, -18 },
  { 1499, 19, 19, 22, 2, -21 },
  { 1545, 16, 29, 22, 3, -28 },
  { 1603, 20, 34, 22, 1, -28 },
  { 1688, 22, 28, 22, 0, -28 },
  { 1765, 19, 28, 22, 2, -28 },
  { 1832, 20, 29, 22, 1, -28 },
  { 1905, 19, 28, 22, 2, -28 },
  { 1972, 18, 28, 22, 3, -28 },
  { 2035, 17, 28, 22, 3, -28 },
  { 2095, 20, 29, 22, 1, -28 },
  { 2168, 18, 28, 22, 2, -28 },
  { 2231, 17, 28, 22, 3, -28 },
  { 2291, 17, 29, 22, 2, -28 },
  { 2353, 20, 28, 22, 2, -28 },
  { 2423, 18, 28, 22, 3, -28 },
  { 2486, 20, 28, 22, 1, -28 },
  { 2556, 18, 28, 22, 2, -28 },
  { 2619, 20, 29, 22, 1, -28 },
  { 2692, 18, 28, 22, 3, -28 },
  { 2755, 20, 36, 22, 1, -28 },
  { 2845, 20, 28, 22, 2, -28 },
  { 2915, 18, 29, 22, 2, -28 },
  { 2981, 20, 28, 22, 1, -28 },
  { 3051, 19, 29, 22, 2, -28 },
  { 3120, 21, 28, 22, 1, -28 },
  { 3194, 20, 28, 22, 1, -28 },
  { 3264, 21, 28, 22, 1, -28 },
  { 3338, 21, 28, 22, 1, -28 },
  { 3412, 18, 28, 22, 2, -28 },
  { 3475, 12, 38, 22, 5, -31 },
  { 3532, 18, 38, 22, 2, -31 },
  { 3618, 12, 38, 22, 5, -31 },
  { 3675, 21, 16, 22, 1, -28 },
  { 3717, 22, 4, 22, 0, 3 },
  { 3728, 9, 8, 22, 7, -31 },
  { 3737, 18, 22, 22, 2, -22 },
  { 3787, 18, 31, 22, 3, -31 },
  { 3857, 19, 22, 22, 2, -22 },
  { 3910, 18, 31, 22, 1, -31 },
  { 3980, 19, 22, 22, 2, -22 },
  { 4033, 20, 31, 22, 2, -31 },
  { 4111, 18, 29, 22, 2, -21 },
  { 4177, 17, 31, 22, 3, -31 },
  { 4243, 19, 31, 22, 2, -31 },
  { 4317, 16, 39, 22, 2, -31 },
  { 4395, 19, 31, 22, 3, -31 },
  { 4469, 19, 31, 22, 2, -31 },
  { 4543, 20, 21, 22, 1, -21 },
  { 4596, 17, 21, 22, 3, -21 },
  { 4641, 20, 23, 22, 1, -22 },
  { 4699, 18, 28, 22, 3, -21 },
  { 4762, 18, 28, 22, 2, -21 },
  { 4825, 16, 21, 22, 4, -21 },
  { 4867, 17, 22, 22, 3, -22 },
  { 4914, 19, 27, 22, 2, -27 },
  { 4979, 17, 21, 22, 3, -21 },
  { 5024, 21, 21, 22, 1, -21 },
  { 5080, 21, 21, 22, 1, -21 },
  { 5136, 20, 21, 22, 1, -21 },
  { 5189, 20, 29, 22, 1, -21 },
  { 5262, 16, 21, 22, 3, -21 },
  { 5304, 16, 38, 22, 3, -31 },
  { 5380, 5, 38, 22, 9, -31 },
  { 5404, 16, 38, 22, 3, -31 },
  { 5480, 20, 8, 22, 1, -16 },
};

const GFXfont UbuntuSansMono_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_SEMIBOLD40PT7B_H_
