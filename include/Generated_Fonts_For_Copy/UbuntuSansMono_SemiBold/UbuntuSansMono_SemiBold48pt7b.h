#ifndef _UBUNTUSANSMONO_SEMIBOLD48PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x7E, 0x04, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x80, 0xF1, 0xC0, 0x70, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFE,
  0x01, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE4, 0x00, 0x1F, 0xDE, 0x00, 0x7F, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x01, 0xF3, 0xFE, 0x00, 0x79, 0xFF, 0xC0, 0x3E, 0x78, 0xF0, 0x1F, 0x1E,
  0x3C, 0x07, 0x87, 0x8F, 0x83, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x78,
  0x1E, 0x1E, 0x3E, 0x07, 0x8F, 0x0F, 0x01, 0xE3, 0xC7, 0x80, 0x7D, 0xF3,
  0xE0, 0x0F, 0xFC, 0xF0, 0x03, 0xFE, 0x7C, 0x00, 0x7F, 0x3E, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF3, 0xFC,
  0x00, 0x7C, 0xFF, 0x80, 0x1E, 0x7F, 0xE0, 0x0F, 0x1E, 0x7C, 0x07, 0xCF,
  0x8F, 0x01, 0xE3, 0xC3, 0xC0, 0xF0, 0xF0, 0xF0, 0x7C, 0x3C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC7, 0xC0, 0x78, 0xF1, 0xE0, 0x1E, 0x7C,
  0xF8, 0x07, 0xFE, 0x7C, 0x00, 0xFF, 0xBE, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFE, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x07, 0xFF, 0x0F,
  0x87, 0xFF, 0xC7, 0xC3, 0xF7, 0xF3, 0xE3, 0xF1, 0xFD, 0xF1, 0xF0, 0x7F,
  0xF1, 0xF8, 0x1F, 0xF8, 0xFC, 0x07, 0xFC, 0x7E, 0x03, 0xFC, 0x3F, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0xC3, 0xF8, 0x7F, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0x7E, 0x0F, 0xFF, 0x3F, 0x03, 0xFE, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x8E, 0x00, 0x00, 0x04, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x10, 0x30, 0x00, 0x1C, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x04, 0x0F, 0x81, 0x3C,
  0x7C, 0x39, 0xF9, 0xC7, 0xDF, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x3F,
  0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x7E, 0x03, 0xC1, 0xE0,
  0x0C, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0x00, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0xCF, 0xF8, 0xFF, 0x07, 0xC0,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x08, 0x3F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x04, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xC0, 0x7E,
  0x3F, 0x80, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x87, 0x0F, 0xFF, 0x1F, 0x1F, 0xFE,
  0x3E, 0x3F, 0xFC, 0xFE, 0x7F, 0xF8, 0xF8, 0xFF, 0xF1, 0xF1, 0xFF, 0xE1,
  0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x0F,
  0xC3, 0xF8, 0x3F, 0x87, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x0C,
  0x1F, 0x80, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFC, 0x7F, 0x87, 0x80, 0x7F, 0x08, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xF8, 0x3F, 0xC1, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x60, 0x03, 0xF9, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x98, 0x00, 0xFE, 0x7F, 0x3F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x7F, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0x01, 0xFD, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xF0, 0x3F,
  0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0x7E, 0x07,
  0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFC, 0xFF, 0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0x3F, 0x9F, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0xE7, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x47,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x08, 0x3F,
  0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3F, 0x02, 0x00, 0x01, 0x00, 0xFC, 0x0F, 0xE1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F, 0xC0, 0xFE, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0xE0, 0x3E, 0x07,
  0xC1, 0xFC, 0xFF, 0x87, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xF0, 0x3F, 0xC8, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3C, 0x01, 0xDF, 0x7C, 0x0F, 0xFF, 0x7C, 0x1F, 0xFF, 0x7C,
  0x3F, 0xFF, 0x78, 0x3F, 0xFF, 0x78, 0x7F, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0x78,
  0x7C, 0x1F, 0x78, 0x7E, 0x1F, 0x7C, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C,
  0x1F, 0xFF, 0x3E, 0x0F, 0xFF, 0x3E, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x04, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0x03, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFE, 0x0F, 0x8F, 0xF0, 0x03, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xC3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0x3F, 0x01, 0xFC,
  0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0,
  0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0x8F, 0xF0, 0x02, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xFC,
  0x07, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC8, 0x00, 0xFE,
  0x70, 0x0F, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x07,
  0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0xFE, 0x03,
  0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF7,
  0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x0F,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xDE,
  0x3D, 0xE3, 0xDE, 0x7D, 0xE3, 0xDE, 0x7D, 0xE3, 0xDE, 0x7C, 0xF7, 0x9F,
  0x7C, 0xF7, 0x9F, 0x7C, 0xF7, 0x9F, 0x7C, 0x7F, 0x1F, 0x7C, 0x7F, 0x1F,
  0x7C, 0x7F, 0x1F, 0x7C, 0x7E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF, 0x9F, 0x0F, 0xFC, 0xF8,
  0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0x7C, 0xFF, 0xC3, 0xE7, 0xFE,
  0x0F, 0x3F, 0xF0, 0x7D, 0xFF, 0x81, 0xEF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x1F, 0xE7, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80,
  0xFC, 0x1F, 0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0x03, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F,
  0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFE,
  0x03, 0xC7, 0xF0, 0x01, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC8,
  0x00, 0x3F, 0x38, 0x01, 0xFD, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E,
  0x1F, 0x7C, 0x7F, 0x1F, 0x7C, 0x7F, 0x1F, 0x7C, 0x7F, 0x1F, 0x7C, 0xFF,
  0x1F, 0x7C, 0xF7, 0x9F, 0x7C, 0xF7, 0x9F, 0x7C, 0xF7, 0x9E, 0x7D, 0xE3,
  0xDE, 0x7D, 0xE3, 0xDE, 0x3D, 0xE3, 0xDE, 0x3F, 0xC1, 0xDE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x9F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF0, 0x07,
  0xF1, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFC, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0x8E, 0x00, 0x0E, 0x01, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x10, 0x07, 0x80, 0xF8, 0x3F, 0x8F, 0xF8, 0x3F, 0x83, 0xF8, 0x1E, 0x00,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0E, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x1C, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8,
  0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0xBF, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0x9F, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x43, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xE3, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0xF0, 0x3F, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0x87, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFC, 0x06, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE0, 0xFD, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x21, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF4, 0x00, 0x3F, 0xBC, 0x07, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0xFE, 0xF8, 0x07, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x02, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x80, 0x7F, 0x7C, 0x3F, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0xFE,
  0x3F, 0x07, 0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F,
  0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x80,
  0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01,
  0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x02, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x81, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xBF, 0xDF, 0xFE, 0x3F, 0x0F, 0xFC,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3,
  0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0x0F, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFD, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x3F, 0xC7,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x1F, 0xF3, 0xE0, 0x3F, 0xDF,
  0x00, 0xFE, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7F,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xDF,
  0xF0, 0x3E, 0x08, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xF1, 0xFD, 0xFE, 0x07, 0xEF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x38, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x17, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xC1, 0xF1, 0xF8, 0x00, 0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF7, 0x00, 0x3F, 0x3F, 0xDF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x34, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x20, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x06, 0x00,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xF0, 0x3F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xE0, 0x02, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C,
  0x1E, 0x78, 0x7F, 0x1F, 0x3E, 0x3F, 0x8F, 0x9F, 0x1F, 0xC7, 0xCF, 0x8F,
  0xE3, 0xE7, 0xCF, 0xF9, 0xF3, 0xE7, 0xBC, 0xF9, 0xF3, 0xDE, 0x78, 0x79,
  0xEF, 0x3C, 0x3D, 0xE3, 0xDE, 0x1E, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xF0,
  0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xF8, 0x07,
  0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xF3, 0xF0, 0x03,
  0xF3, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x41, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xC0,
  0x08, 0x07, 0xF8, 0x07, 0xC7, 0xFF, 0x03, 0xE7, 0xFF, 0xE3, 0xE3, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xF0, 0xFF, 0xF9, 0xF0, 0x1F, 0xF8, 0x38,
  0x03, 0xF8, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 34, 27, 9, -33 },
  { 40, 17, 14, 27, 5, -36 },
  { 70, 25, 33, 27, 1, -33 },
  { 174, 23, 42, 27, 2, -37 },
  { 295, 26, 35, 27, 0, -34 },
  { 409, 25, 34, 27, 1, -34 },
  { 516, 7, 15, 27, 10, -36 },
  { 530, 17, 47, 27, 5, -38 },
  { 630, 17, 47, 27, 5, -38 },
  { 730, 21, 20, 27, 3, -33 },
  { 783, 23, 24, 27, 2, -26 },
  { 852, 12, 17, 27, 7, -9 },
  { 878, 13, 6, 27, 7, -17 },
  { 888, 9, 10, 27, 9, -9 },
  { 900, 21, 47, 27, 3, -38 },
  { 1024, 23, 35, 27, 2, -34 },
  { 1125, 21, 33, 27, 3, -33 },
  { 1212, 22, 34, 27, 3, -34 },
  { 1306, 22, 35, 27, 2, -34 },
  { 1403, 23, 33, 27, 2, -33 },
  { 1498, 22, 34, 27, 2, -33 },
  { 1592, 21, 35, 27, 3, -34 },
  { 1684, 21, 33, 27, 3, -33 },
  { 1771, 23, 35, 27, 2, -34 },
  { 1872, 22, 34, 27, 2, -34 },
  { 1966, 9, 27, 27, 9, -26 },
  { 1997, 12, 34, 27, 6, -26 },
  { 2048, 23, 23, 27, 2, -25 },
  { 2115, 23, 16, 27, 2, -22 },
  { 2161, 23, 23, 27, 2, -25 },
  { 2228, 19, 35, 27, 4, -34 },
  { 2312, 24, 41, 27, 1, -34 },
  { 2435, 26, 33, 27, 0, -33 },
  { 2543, 22, 34, 27, 3, -34 },
  { 2637, 23, 35, 27, 2, -34 },
  { 2738, 22, 34, 27, 3, -34 },
  { 2832, 21, 33, 27, 4, -33 },
  { 2919, 20, 33, 27, 4, -33 },
  { 3002, 23, 35, 27, 2, -34 },
  { 3103, 22, 33, 27, 2, -33 },
  { 3194, 20, 33, 27, 3, -33 },
  { 3277, 21, 34, 27, 2, -33 },
  { 3367, 23, 33, 27, 3, -33 },
  { 3462, 21, 33, 27, 4, -33 },
  { 3549, 24, 33, 27, 1, -33 },
  { 3648, 21, 33, 27, 3, -33 },
  { 3735, 24, 35, 27, 1, -34 },
  { 3840, 22, 34, 27, 3, -34 },
  { 3934, 24, 43, 27, 1, -34 },
  { 4063, 23, 34, 27, 3, -34 },
  { 4161, 22, 35, 27, 2, -34 },
  { 4258, 23, 33, 27, 2, -33 },
  { 4353, 23, 34, 27, 2, -33 },
  { 4451, 25, 33, 27, 1, -33 },
  { 4555, 24, 33, 27, 1, -33 },
  { 4654, 25, 33, 27, 1, -33 },
  { 4758, 25, 33, 27, 1, -33 },
  { 4862, 21, 33, 27, 3, -33 },
  { 4949, 14, 47, 27, 7, -38 },
  { 5032, 21, 47, 27, 3, -38 },
  { 5156, 14, 47, 27, 6, -38 },
  { 5239, 25, 19, 27, 1, -33 },
  { 5299, 26, 5, 27, 0, 4 },
  { 5316, 11, 9, 27, 8, -37 },
  { 5329, 21, 27, 27, 3, -26 },
  { 5400, 22, 38, 27, 3, -37 },
  { 5505, 23, 27, 27, 2, -26 },
  { 5583, 21, 38, 27, 2, -37 },
  { 5683, 23, 27, 27, 2, -26 },
  { 5761, 24, 37, 27, 2, -37 },
  { 5872, 21, 35, 27, 2, -26 },
  { 5964, 20, 37, 27, 4, -37 },
  { 6057, 23, 38, 27, 2, -37 },
  { 6167, 18, 46, 27, 3, -37 },
  { 6271, 22, 37, 27, 4, -37 },
  { 6373, 23, 38, 27, 2, -37 },
  { 6483, 23, 26, 27, 2, -26 },
  { 6558, 20, 26, 27, 4, -26 },
  { 6623, 23, 27, 27, 2, -26 },
  { 6701, 21, 35, 27, 4, -26 },
  { 6793, 21, 35, 27, 2, -26 },
  { 6885, 19, 26, 27, 5, -26 },
  { 6947, 21, 27, 27, 3, -26 },
  { 7018, 23, 34, 27, 2, -33 },
  { 7116, 20, 26, 27, 3, -25 },
  { 7181, 25, 25, 27, 1, -25 },
  { 7260, 25, 25, 27, 1, -25 },
  { 7339, 25, 25, 27, 1, -25 },
  { 7418, 24, 34, 27, 1, -25 },
  { 7520, 19, 25, 27, 4, -25 },
  { 7580, 19, 47, 27, 4, -38 },
  { 7692, 5, 47, 27, 11, -38 },
  { 7722, 19, 47, 27, 4, -38 },
  { 7834, 25, 10, 27, 1, -19 },
};

const GFXfont UbuntuSansMono_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_SEMIBOLD48PT7B_H_
