#ifndef _UBUNTUSANSMONO_SEMIBOLD14PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xB9, 0x99, 0x90, 0x16, 0x36, 0x36, 0xFF, 0x24,
  0x24, 0xFF, 0xFF, 0x68, 0x48, 0x30, 0xC7, 0xF1, 0xC3, 0xC3, 0xC3, 0x0F,
  0xFF, 0x8C, 0x30, 0x63, 0xF2, 0xB4, 0xFC, 0x68, 0x16, 0x3E, 0x2B, 0x4B,
  0xC6, 0x38, 0x6C, 0x6C, 0x68, 0x38, 0x72, 0x5E, 0xCE, 0x4E, 0x7B, 0xFF,
  0xC0, 0x13, 0x6C, 0xC8, 0x88, 0x8C, 0xC6, 0x31, 0x47, 0x0C, 0x31, 0x84,
  0x21, 0x18, 0xC4, 0x66, 0x20, 0x30, 0xCE, 0xDE, 0x7B, 0x20, 0x30, 0xC3,
  0x3F, 0xFC, 0xC3, 0x00, 0x6C, 0xE0, 0xFF, 0xF0, 0x0C, 0x31, 0x86, 0x18,
  0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC3, 0x00, 0x7B, 0xEC, 0xE3, 0xB6, 0xD8,
  0x73, 0xCD, 0xE0, 0x11, 0xCF, 0x2C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x73,
  0xE8, 0xC3, 0x18, 0xC6, 0x30, 0xC3, 0xF0, 0x73, 0xE0, 0xC3, 0x79, 0xE0,
  0xC3, 0x9F, 0xE0, 0x04, 0x18, 0x71, 0xA2, 0x4C, 0xBF, 0xFF, 0x04, 0x08,
  0x7D, 0xF4, 0x10, 0xF8, 0x70, 0xC3, 0x9F, 0xE0, 0x0C, 0xF6, 0x30, 0xFB,
  0x38, 0xF3, 0xCD, 0xE0, 0xFF, 0xF0, 0x86, 0x10, 0xC3, 0x08, 0x61, 0x80,
  0x7B, 0xFC, 0xF3, 0xF9, 0xEC, 0xE1, 0xCD, 0xE0, 0x7B, 0xFC, 0xE3, 0xCF,
  0xF0, 0xC6, 0x7B, 0x80, 0xF0, 0x3C, 0x6C, 0x00, 0xD9, 0xC0, 0x0D, 0xEE,
  0x38, 0x3C, 0x30, 0xFC, 0x00, 0x3F, 0xC3, 0xC1, 0xC7, 0xF3, 0x00, 0x7B,
  0xE0, 0xC6, 0x38, 0xC2, 0x00, 0x71, 0xC0, 0x1C, 0x4D, 0x0A, 0x7D, 0xFA,
  0x74, 0xE9, 0x5E, 0x80, 0xC0, 0xF0, 0x18, 0x18, 0x3C, 0x2C, 0x24, 0x66,
  0x7E, 0x7E, 0x42, 0xC3, 0xF3, 0xFC, 0xF3, 0xFB, 0xFC, 0xF1, 0xDF, 0xE0,
  0x3D, 0xFC, 0x20, 0x82, 0x08, 0x30, 0xE5, 0xF0, 0xF3, 0xEC, 0xF3, 0xC7,
  0x1C, 0xF3, 0xDB, 0xC0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0xF0,
  0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xC3, 0x00, 0x3D, 0xFC, 0x20, 0x82,
  0x38, 0xF3, 0xED, 0xF0, 0x8E, 0x38, 0xE3, 0xFF, 0xF8, 0xE3, 0x8E, 0x30,
  0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x7D, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x9B, 0xE0, 0xCD, 0x9B, 0x67, 0x8E, 0x1E, 0x36, 0x6C, 0xCD,
  0x9C, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0x66, 0xCD, 0x9B,
  0xD5, 0xAB, 0x56, 0xA1, 0xC3, 0x84, 0x8F, 0x3C, 0xEB, 0xAE, 0x79, 0xE3,
  0x8E, 0x30, 0x3C, 0xFD, 0x9A, 0x1C, 0x38, 0x50, 0xA3, 0x66, 0x78, 0xFB,
  0xFC, 0xF1, 0xCF, 0xFF, 0x30, 0xC3, 0x00, 0x3C, 0xFD, 0x9A, 0x1C, 0x38,
  0x50, 0xA3, 0x66, 0x78, 0x60, 0x70, 0x20, 0xF1, 0xF3, 0x36, 0x6C, 0xDF,
  0x36, 0x6C, 0xCD, 0x8C, 0x7F, 0xEC, 0x30, 0xF0, 0xE0, 0xC3, 0x8F, 0xE0,
  0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xCD, 0xE0, 0xC3, 0xC2, 0x46, 0x66, 0x66, 0x24, 0x2C,
  0x3C, 0x38, 0x18, 0xC3, 0x87, 0x0A, 0x15, 0xAB, 0x5E, 0xB3, 0x66, 0xCC,
  0xC2, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x3C, 0x64, 0x66, 0xC3, 0xC3, 0x66,
  0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xF1, 0x86, 0x30,
  0x86, 0x10, 0xC3, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC3,
  0x04, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x30, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x38, 0x3C, 0x66, 0x66, 0xC3, 0xFF,
  0xFF, 0x4E, 0x30, 0xA1, 0xE0, 0xCB, 0xFF, 0x3C, 0xFF, 0xC3, 0x0C, 0x34,
  0xFF, 0x3C, 0xF1, 0xCF, 0x3F, 0x80, 0x19, 0xFC, 0x30, 0x83, 0x0E, 0x5F,
  0x06, 0x0C, 0x18, 0xB7, 0xEC, 0xD1, 0xE3, 0x46, 0xCC, 0xF8, 0x11, 0xEC,
  0xE1, 0xFE, 0x0E, 0x5F, 0x1E, 0x79, 0x83, 0x0F, 0xCC, 0x18, 0x30, 0x60,
  0xC1, 0x80, 0x13, 0xFC, 0xE3, 0x8F, 0x3F, 0xCB, 0x0F, 0xE7, 0x00, 0xC3,
  0x0C, 0x38, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x21, 0x82, 0x00, 0xE0,
  0x82, 0x08, 0x20, 0xD3, 0xC0, 0x18, 0xC4, 0x0F, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0xDB, 0x3C, 0x78, 0xD9, 0x9B, 0x38,
  0xE3, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xD3, 0xC0, 0xFF, 0xB7, 0x6E,
  0xDC, 0x38, 0x70, 0x80, 0x23, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0x10, 0x79,
  0x9A, 0x3C, 0x28, 0xD9, 0x9E, 0x23, 0xEC, 0xF3, 0xC7, 0x3C, 0xFE, 0xC3,
  0x0C, 0x00, 0x11, 0xFC, 0xE3, 0x8E, 0x3C, 0xDF, 0x0C, 0x30, 0xC0, 0xFF,
  0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x17, 0xEC, 0x38, 0x78, 0x38, 0xFE, 0x21,
  0x86, 0x3F, 0x61, 0x86, 0x18, 0x74, 0xF0, 0xCF, 0x3C, 0xF3, 0xCF, 0x37,
  0xC0, 0xC3, 0x66, 0x66, 0x2C, 0x3C, 0x38, 0x18, 0xC3, 0xDA, 0x5A, 0x5A,
  0x7A, 0x66, 0x66, 0xE6, 0x3C, 0x38, 0x18, 0x3C, 0x66, 0xC7, 0x66, 0xCC,
  0x99, 0xA3, 0xC3, 0x86, 0x0C, 0x71, 0xC0, 0xFC, 0x63, 0x0C, 0x63, 0x0F,
  0xC0, 0x3C, 0xC2, 0x08, 0x20, 0x8E, 0x38, 0x20, 0x82, 0x08, 0x3C, 0x70,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xC3, 0x0C, 0x30, 0x41, 0xC7, 0x30, 0xC3,
  0x0C, 0xF3, 0x80, 0x7B, 0xCE,
};

const GFXglyph UbuntuSansMono_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 5, 8, 2, -11 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 6, 13, 8, 1, -11 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 8, 10, 8, 0, -10 },
  { 47, 2, 5, 8, 3, -11 },
  { 49, 4, 14, 8, 2, -11 },
  { 56, 5, 14, 8, 1, -11 },
  { 65, 6, 6, 8, 1, -10 },
  { 70, 6, 7, 8, 1, -8 },
  { 76, 3, 4, 8, 2, -2 },
  { 78, 4, 2, 8, 2, -5 },
  { 79, 2, 2, 8, 3, -2 },
  { 80, 6, 14, 8, 1, -11 },
  { 91, 6, 10, 8, 1, -10 },
  { 99, 6, 10, 8, 1, -10 },
  { 107, 6, 10, 8, 1, -10 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 7, 10, 8, 0, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 6, 10, 8, 1, -10 },
  { 172, 2, 7, 8, 3, -7 },
  { 174, 3, 9, 8, 2, -7 },
  { 178, 6, 6, 8, 1, -7 },
  { 183, 6, 4, 8, 1, -6 },
  { 186, 6, 6, 8, 1, -7 },
  { 191, 6, 10, 8, 1, -10 },
  { 199, 7, 12, 8, 0, -10 },
  { 210, 8, 10, 8, 0, -10 },
  { 220, 6, 10, 8, 1, -10 },
  { 228, 6, 10, 8, 1, -10 },
  { 236, 6, 10, 8, 1, -10 },
  { 244, 6, 10, 8, 1, -10 },
  { 252, 6, 10, 8, 1, -10 },
  { 260, 6, 10, 8, 1, -10 },
  { 268, 6, 10, 8, 1, -10 },
  { 276, 6, 10, 8, 1, -10 },
  { 284, 6, 10, 8, 1, -10 },
  { 292, 7, 10, 8, 1, -10 },
  { 301, 6, 10, 8, 1, -10 },
  { 309, 7, 10, 8, 0, -10 },
  { 318, 6, 10, 8, 1, -10 },
  { 326, 7, 10, 8, 0, -10 },
  { 335, 6, 10, 8, 1, -10 },
  { 343, 7, 13, 8, 0, -10 },
  { 355, 7, 10, 8, 1, -10 },
  { 364, 6, 10, 8, 1, -10 },
  { 372, 7, 10, 8, 0, -10 },
  { 381, 6, 10, 8, 1, -10 },
  { 389, 8, 10, 8, 0, -10 },
  { 399, 7, 10, 8, 0, -10 },
  { 408, 8, 10, 8, 0, -10 },
  { 418, 8, 10, 8, 0, -10 },
  { 428, 6, 10, 8, 1, -10 },
  { 436, 4, 14, 8, 2, -11 },
  { 443, 6, 14, 8, 1, -11 },
  { 454, 4, 14, 8, 2, -11 },
  { 461, 8, 6, 8, 0, -10 },
  { 467, 8, 2, 8, 0, 1 },
  { 469, 4, 3, 8, 2, -11 },
  { 471, 6, 8, 8, 1, -8 },
  { 477, 6, 11, 8, 1, -11 },
  { 486, 6, 8, 8, 1, -8 },
  { 492, 7, 11, 8, 0, -11 },
  { 502, 6, 8, 8, 1, -8 },
  { 508, 7, 11, 8, 1, -11 },
  { 518, 6, 11, 8, 1, -8 },
  { 527, 6, 11, 8, 1, -11 },
  { 536, 6, 11, 8, 1, -11 },
  { 545, 5, 14, 8, 1, -11 },
  { 554, 7, 11, 8, 1, -11 },
  { 564, 6, 11, 8, 1, -11 },
  { 573, 7, 7, 8, 0, -7 },
  { 580, 6, 8, 8, 1, -8 },
  { 586, 7, 8, 8, 0, -8 },
  { 593, 6, 11, 8, 1, -8 },
  { 602, 6, 11, 8, 1, -8 },
  { 611, 6, 7, 8, 1, -7 },
  { 617, 6, 8, 8, 1, -8 },
  { 623, 6, 10, 8, 1, -10 },
  { 631, 6, 7, 8, 1, -7 },
  { 637, 8, 7, 8, 0, -7 },
  { 644, 8, 7, 8, 0, -7 },
  { 651, 8, 7, 8, 0, -7 },
  { 658, 7, 10, 8, 0, -7 },
  { 667, 6, 7, 8, 1, -7 },
  { 673, 6, 14, 8, 1, -11 },
  { 684, 2, 14, 8, 3, -11 },
  { 688, 6, 14, 8, 1, -11 },
  { 699, 8, 2, 8, 0, -5 },
};

const GFXfont UbuntuSansMono_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_SEMIBOLD14PT7B_H_
