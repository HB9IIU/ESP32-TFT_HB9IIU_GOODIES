#ifndef _UBUNTUSANSMONO_SEMIBOLD25PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x60, 0x06, 0xFF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xC3, 0x43, 0x0C, 0x71, 0xC6, 0x1C, 0xE1, 0xCE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x9C, 0x39, 0xC3, 0x9C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0x38, 0x73, 0x86, 0x30, 0xE3, 0x00, 0x06, 0x00, 0x60, 0x0F,
  0x83, 0xFE, 0x7F, 0xE7, 0x02, 0x70, 0x07, 0x00, 0x7C, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x74, 0x0F, 0xFF, 0xEF, 0xFC, 0x1F,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x38, 0x05, 0xF0, 0x66, 0xC3, 0xBB, 0x0C,
  0xCE, 0x63, 0x3B, 0x86, 0xCC, 0x1F, 0x60, 0x3B, 0x80, 0x0C, 0x00, 0x67,
  0x83, 0xBE, 0x0C, 0xDC, 0x67, 0x33, 0x9C, 0xCC, 0x37, 0x70, 0xFB, 0x83,
  0xE0, 0x0C, 0x03, 0xF0, 0x7F, 0x87, 0x18, 0x71, 0x87, 0x38, 0x73, 0x83,
  0xF0, 0x3E, 0x43, 0xC7, 0x7E, 0x6E, 0x76, 0xE3, 0xEC, 0x3E, 0xE1, 0xEE,
  0x3E, 0x7F, 0xF3, 0xE7, 0xFF, 0xFF, 0x66, 0x66, 0x02, 0x07, 0x0F, 0x1E,
  0x3C, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x02, 0x40, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x78, 0xF0, 0xE0, 0x40, 0x07, 0x00,
  0x60, 0x66, 0x27, 0x6E, 0xFF, 0xF0, 0xF8, 0x0F, 0x01, 0xFC, 0x39, 0xC1,
  0x98, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x79, 0xF7, 0xCF,
  0x18, 0xEF, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x01,
  0xF8, 0x3F, 0xC7, 0x9E, 0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x67, 0xEF, 0x7E,
  0xF7, 0xE6, 0x7E, 0x07, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x9E, 0x3F, 0xC1,
  0xF8, 0x0E, 0x03, 0xC1, 0xF8, 0x7F, 0x0E, 0xE1, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x03, 0xF8, 0xFF, 0xC6, 0x1E, 0x40, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0xFF, 0x7F, 0xF7, 0xFF, 0x1E, 0x07, 0xF8, 0x7F, 0xC6, 0x1E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x7C, 0x1F, 0x81, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xE6, 0x3E, 0x7F, 0xC7, 0xF8, 0x01, 0xC0, 0x3C, 0x07, 0xC0,
  0xFC, 0x1D, 0xC1, 0xDC, 0x39, 0xC3, 0x1C, 0x71, 0xCE, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xE7, 0xFC,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x81, 0xFC, 0x7F, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xD8, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0xE0, 0xFE,
  0x1F, 0x83, 0xC0, 0x78, 0x07, 0x00, 0x7F, 0x87, 0xFC, 0xFF, 0xEE, 0x0E,
  0xE0, 0xFE, 0x07, 0x70, 0xF7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7,
  0x9E, 0x3F, 0xC3, 0xFC, 0x7B, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x77,
  0x9E, 0x7F, 0xE3, 0xFC, 0x0E, 0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE,
  0x0F, 0xE0, 0x7F, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xE0, 0x4E, 0x01, 0xE0,
  0x1C, 0x07, 0xC7, 0xF8, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3C,
  0x33, 0xBE, 0x60, 0x00, 0x20, 0x1F, 0x07, 0xF3, 0xFC, 0xFE, 0x0F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0xE0, 0x02, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x07, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x3F, 0x8F, 0xC0,
  0x70, 0x04, 0x00, 0x1C, 0x3F, 0xEF, 0xF9, 0x0F, 0x01, 0xC0, 0x70, 0x38,
  0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E,
  0x07, 0x00, 0x07, 0x01, 0xFC, 0x3F, 0xE7, 0x07, 0x60, 0x7E, 0x07, 0xE3,
  0xFC, 0x7F, 0xCF, 0x7C, 0xE7, 0xCE, 0x7C, 0xE7, 0xCE, 0x7C, 0xE7, 0xCF,
  0xFE, 0x7F, 0xE3, 0xF7, 0x00, 0x78, 0x03, 0xFE, 0x1F, 0xE0, 0x3E, 0x07,
  0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x18, 0x70, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xF9, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0xF0, 0x3C, 0x08, 0x0F, 0xF8, 0xFF, 0xCF, 0x1E, 0xF0,
  0xEF, 0x0E, 0xF0, 0xEF, 0x3C, 0xFF, 0x8F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0xBE, 0xFF, 0xEF, 0xF8, 0x03, 0xC1, 0xFF, 0x3F,
  0xF7, 0xC2, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC7, 0x3F, 0xF0, 0xFE, 0x08,
  0x0F, 0xF8, 0xFF, 0xCF, 0x3E, 0xF0, 0xEF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF1, 0xEF, 0xFC, 0xFF,
  0xCF, 0xF0, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE,
  0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0x81, 0xFF, 0x3F, 0xF7, 0xC2, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x78, 0x77, 0xC7,
  0x3F, 0xF0, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xF1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x83, 0xDC, 0xF7,
  0xFE, 0x7F, 0x80, 0xF0, 0xF7, 0x87, 0x3C, 0x71, 0xE7, 0x8F, 0x78, 0x7B,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xE1, 0xE7, 0x8F, 0x1C,
  0x78, 0xF3, 0xC3, 0xDE, 0x0E, 0xF0, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0xE7, 0x0E, 0xF0, 0xEF,
  0x9F, 0xF9, 0xFF, 0x9F, 0xEF, 0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xE6, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xE0, 0x7F, 0x07,
  0xF8, 0x7F, 0x87, 0xFC, 0x7E, 0xC7, 0xEE, 0x7E, 0x67, 0xE7, 0x7E, 0x37,
  0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x70, 0x07,
  0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x9E, 0x3F,
  0xC1, 0xF8, 0x18, 0x1F, 0xF3, 0xFF, 0x71, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xFF, 0xFB, 0xFE, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x03, 0xFC, 0x3F, 0xE7, 0x9E, 0xF0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x06, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0x00, 0x20, 0x10, 0x1F, 0xE3, 0xFE, 0x71, 0xEE, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0xE3, 0xDF, 0xF3, 0xFC, 0x7B, 0x8E, 0x79, 0xC7, 0x38, 0x77, 0x0E,
  0xE0, 0xFC, 0x1C, 0x07, 0x03, 0xFE, 0x7F, 0xE7, 0x04, 0x70, 0x07, 0x00,
  0x70, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0xF7, 0x1E, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x3D,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x38, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE6, 0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xFF, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0x70, 0xE7, 0x0E, 0x70, 0xE0, 0x78, 0x38, 0xE1, 0xC3, 0xC7, 0x07,
  0x38, 0x1E, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0x38, 0x1C, 0xF0, 0xE1, 0xC3, 0x87, 0x9C, 0x0E, 0xF0, 0x3C,
  0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0x73, 0x81, 0xCE,
  0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x78,
  0x07, 0xE0, 0x7F, 0x83, 0x9C, 0x3C, 0xF1, 0xC3, 0x9E, 0x0E, 0xE0, 0x79,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x63, 0xC7, 0x87, 0x08,
  0x3F, 0xC7, 0xFC, 0x87, 0x80, 0x70, 0x0E, 0x3F, 0xDF, 0xFB, 0xC7, 0xE0,
  0xFC, 0x1D, 0xE3, 0xBF, 0xF3, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xE7, 0xFE, 0xF3, 0xDC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE7, 0xDF, 0xF3, 0xFC, 0x00, 0x0F, 0xF3, 0xFE,
  0x7C, 0x27, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x7F, 0x73, 0xFF, 0x0F, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xCF, 0xFB, 0xFF, 0x79, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0x7C, 0xE7, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFE, 0x79,
  0xEF, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x7E,
  0xE3, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x87, 0x84, 0x38, 0x01, 0xC0,
  0x0E, 0x03, 0xFF, 0xDF, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F,
  0xEF, 0xFD, 0xE3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xEF,
  0x3D, 0xFF, 0x9F, 0xF0, 0x0E, 0x01, 0xD0, 0x7B, 0xFE, 0xFF, 0x87, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF3, 0xFE, 0xF7, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xB0, 0x7F, 0x07, 0xF0, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x01,
  0xFE, 0xFF, 0x7F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x7C, 0x7F, 0xFB, 0xFC, 0x78, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEE,
  0x0F, 0xC0, 0xFC, 0x0E, 0xE0, 0xE7, 0x0E, 0x38, 0xE3, 0xCE, 0x1E, 0xE0,
  0xF0, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xEF, 0xFF, 0xEE, 0x7E, 0x67,
  0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x30, 0xFF, 0x3F, 0xEE, 0x7F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x83, 0xFC, 0x79, 0xEF,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x79, 0xE3,
  0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xEF, 0x7F, 0xEF, 0xF9, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xE7, 0xFD, 0xE3, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1D, 0xEF, 0xBF, 0xF3, 0xFE, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0xFF, 0xFF, 0xEF, 0xFB, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xDF,
  0xEF, 0x0B, 0x80, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xC0, 0x7E, 0x3F,
  0xFF, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1F, 0x70, 0xFF, 0x07, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xBD, 0xFF, 0x3F, 0xC0, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x9E, 0x39, 0xC3, 0x9C, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1D, 0x80, 0x66, 0x01, 0x98,
  0xC6, 0x67, 0x99, 0x9E, 0x67, 0x7B, 0x9D, 0xEE, 0x7C, 0xF8, 0xF3, 0xC3,
  0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x77, 0x0E, 0x39, 0xC3, 0xDC, 0x1F,
  0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0xC3, 0x9C, 0x70, 0xEF, 0x0F, 0xE0,
  0x70, 0xF0, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x38, 0xE3, 0x8E, 0x39, 0xC1,
  0xDC, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x0E, 0x0F,
  0xE0, 0xFC, 0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC3, 0xF1,
  0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC3, 0xE0,
  0xE0, 0x3E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xFC, 0x3F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0x0F, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0x01, 0xC1, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xE3, 0xF0,
  0xE0, 0x00, 0x38, 0x27, 0xE3, 0xFF, 0xFE, 0x7E, 0xC1, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 8, 14, 3, -19 },
  { 18, 12, 17, 14, 1, -17 },
  { 44, 12, 22, 14, 1, -19 },
  { 77, 14, 18, 14, 0, -18 },
  { 109, 12, 18, 14, 1, -18 },
  { 136, 4, 8, 14, 5, -19 },
  { 140, 8, 25, 14, 3, -20 },
  { 165, 8, 25, 14, 3, -20 },
  { 190, 12, 10, 14, 1, -17 },
  { 205, 12, 13, 14, 1, -14 },
  { 225, 6, 8, 14, 4, -4 },
  { 231, 8, 3, 14, 3, -9 },
  { 234, 4, 4, 14, 5, -4 },
  { 236, 12, 25, 14, 1, -20 },
  { 274, 12, 18, 14, 1, -18 },
  { 301, 11, 17, 14, 2, -17 },
  { 325, 12, 18, 14, 1, -18 },
  { 352, 12, 18, 14, 1, -18 },
  { 379, 12, 17, 14, 1, -17 },
  { 405, 11, 17, 14, 1, -17 },
  { 429, 12, 17, 14, 1, -17 },
  { 455, 12, 17, 14, 1, -17 },
  { 481, 12, 18, 14, 1, -18 },
  { 508, 12, 18, 14, 1, -18 },
  { 535, 4, 13, 14, 5, -13 },
  { 542, 6, 17, 14, 3, -13 },
  { 555, 12, 12, 14, 1, -13 },
  { 573, 12, 8, 14, 1, -11 },
  { 585, 12, 12, 14, 1, -13 },
  { 603, 10, 18, 14, 2, -18 },
  { 626, 12, 22, 14, 1, -18 },
  { 659, 14, 17, 14, 0, -17 },
  { 689, 12, 18, 14, 1, -18 },
  { 716, 12, 18, 14, 1, -18 },
  { 743, 12, 18, 14, 1, -18 },
  { 770, 11, 17, 14, 2, -17 },
  { 794, 10, 17, 14, 2, -17 },
  { 816, 12, 18, 14, 1, -18 },
  { 843, 12, 17, 14, 1, -17 },
  { 869, 10, 17, 14, 2, -17 },
  { 891, 11, 17, 14, 1, -17 },
  { 915, 13, 17, 14, 1, -17 },
  { 943, 11, 17, 14, 2, -17 },
  { 967, 12, 17, 14, 1, -17 },
  { 993, 12, 17, 14, 1, -17 },
  { 1019, 12, 18, 14, 1, -18 },
  { 1046, 11, 18, 14, 2, -18 },
  { 1071, 12, 23, 14, 1, -18 },
  { 1106, 11, 18, 14, 2, -18 },
  { 1131, 12, 18, 14, 1, -18 },
  { 1158, 12, 17, 14, 1, -17 },
  { 1184, 12, 17, 14, 1, -17 },
  { 1210, 14, 17, 14, 0, -17 },
  { 1240, 12, 17, 14, 1, -17 },
  { 1266, 14, 17, 14, 0, -17 },
  { 1296, 14, 17, 14, 0, -17 },
  { 1326, 12, 17, 14, 1, -17 },
  { 1352, 8, 25, 14, 3, -20 },
  { 1377, 11, 25, 14, 2, -20 },
  { 1412, 8, 25, 14, 3, -20 },
  { 1437, 13, 10, 14, 1, -17 },
  { 1454, 14, 3, 14, 0, 2 },
  { 1460, 6, 5, 14, 4, -19 },
  { 1464, 11, 13, 14, 1, -13 },
  { 1482, 11, 19, 14, 2, -19 },
  { 1509, 12, 13, 14, 1, -13 },
  { 1529, 11, 19, 14, 1, -19 },
  { 1556, 12, 13, 14, 1, -13 },
  { 1576, 13, 19, 14, 1, -19 },
  { 1607, 11, 18, 14, 1, -13 },
  { 1632, 10, 19, 14, 2, -19 },
  { 1656, 12, 19, 14, 1, -19 },
  { 1685, 9, 24, 14, 2, -19 },
  { 1712, 12, 19, 14, 2, -19 },
  { 1741, 12, 19, 14, 1, -19 },
  { 1770, 12, 13, 14, 1, -13 },
  { 1790, 10, 13, 14, 2, -13 },
  { 1807, 12, 13, 14, 1, -13 },
  { 1827, 11, 18, 14, 2, -13 },
  { 1852, 11, 18, 14, 1, -13 },
  { 1877, 10, 13, 14, 3, -13 },
  { 1894, 10, 13, 14, 2, -13 },
  { 1911, 12, 17, 14, 1, -17 },
  { 1937, 10, 13, 14, 2, -13 },
  { 1954, 12, 13, 14, 1, -13 },
  { 1974, 14, 13, 14, 0, -13 },
  { 1997, 12, 13, 14, 1, -13 },
  { 2017, 12, 18, 14, 1, -13 },
  { 2044, 10, 13, 14, 2, -13 },
  { 2061, 10, 25, 14, 2, -20 },
  { 2093, 4, 25, 14, 5, -20 },
  { 2106, 10, 25, 14, 2, -20 },
  { 2138, 12, 5, 14, 1, -10 },
};

const GFXfont UbuntuSansMono_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_SEMIBOLD25PT7B_H_
