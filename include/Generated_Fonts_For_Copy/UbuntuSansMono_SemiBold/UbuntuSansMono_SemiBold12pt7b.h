#ifndef _UBUNTUSANSMONO_SEMIBOLD12PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x4F, 0xDD, 0x55, 0x34, 0xBF, 0xCA, 0x6B, 0xF5, 0x96, 0x23,
  0xF3, 0x0F, 0x1C, 0x33, 0xF1, 0x00, 0x43, 0x4A, 0xA5, 0x45, 0x05, 0x8A,
  0xA5, 0xCC, 0x11, 0xE4, 0x96, 0x35, 0xDD, 0xF3, 0x74, 0xF0, 0x13, 0x24,
  0x4C, 0xCC, 0x46, 0x21, 0x8C, 0x23, 0x11, 0x11, 0x13, 0x6C, 0x27, 0xC9,
  0xA5, 0x80, 0x21, 0x09, 0xF2, 0x10, 0x7D, 0x40, 0xE0, 0xDC, 0x18, 0x84,
  0x62, 0x11, 0x88, 0x46, 0x20, 0x27, 0xA7, 0x1A, 0xD6, 0x3B, 0x70, 0x67,
  0x28, 0x42, 0x10, 0x9F, 0x27, 0xA6, 0x33, 0x33, 0x18, 0xF8, 0x27, 0x86,
  0x37, 0x0C, 0x33, 0xF0, 0x18, 0x62, 0x9A, 0x4B, 0xF0, 0x82, 0xFE, 0x31,
  0xE1, 0x8E, 0x7E, 0x7A, 0x31, 0xE9, 0xC7, 0x6E, 0xF8, 0xCC, 0x62, 0x31,
  0x88, 0x27, 0xE7, 0x3F, 0x6E, 0x33, 0xF0, 0x27, 0xA7, 0x1D, 0xBC, 0x66,
  0xE0, 0xDC, 0x0D, 0xC0, 0xDC, 0x0D, 0xD4, 0x1B, 0xA1, 0xE1, 0x80, 0xF8,
  0x3E, 0xC3, 0x86, 0xFC, 0x00, 0x27, 0x86, 0x23, 0x30, 0x0C, 0x60, 0x11,
  0xF4, 0x57, 0xF7, 0xDF, 0x77, 0x49, 0x81, 0xC0, 0x30, 0x70, 0xA3, 0x44,
  0xCF, 0xB1, 0x63, 0xF4, 0xE7, 0xE9, 0xC6, 0x7E, 0x08, 0xF6, 0x10, 0xC3,
  0x04, 0x19, 0x3C, 0xF4, 0xE3, 0x18, 0xC6, 0x7E, 0xFC, 0x21, 0xE8, 0x42,
  0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10, 0x08, 0xF6, 0x10, 0xC3, 0x14, 0x59,
  0x3C, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x78,
  0xC6, 0x31, 0x8E, 0x7E, 0x9A, 0xCA, 0x38, 0xA2, 0xC9, 0xA3, 0xC6, 0x31,
  0x8C, 0x63, 0x1F, 0x4D, 0xB6, 0xDD, 0xD7, 0x1C, 0x71, 0x8E, 0x73, 0x5A,
  0xCE, 0x71, 0x11, 0xF4, 0xF1, 0xC7, 0x14, 0x53, 0x38, 0xFC, 0x63, 0x3F,
  0x42, 0x10, 0x79, 0x3C, 0x71, 0xC5, 0x14, 0xCE, 0x10, 0x30, 0xF4, 0xE7,
  0x3F, 0x4A, 0x71, 0x27, 0xE1, 0x8F, 0x1C, 0x33, 0xF0, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x8C, 0x63, 0x18, 0xC6, 0x7E, 0xC6, 0x89, 0x33, 0x66,
  0x85, 0x0E, 0x18, 0xC7, 0x1C, 0x75, 0x75, 0xB6, 0xD3, 0xCC, 0xD0, 0xE1,
  0x83, 0x8D, 0x13, 0x63, 0xC6, 0x99, 0xA1, 0xC3, 0x02, 0x04, 0x08, 0xF8,
  0x8C, 0x46, 0x63, 0x1F, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC6, 0x10, 0xC6,
  0x10, 0xC6, 0x10, 0x86, 0xF1, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x38, 0xE6,
  0xF1, 0xFE, 0xCC, 0xF8, 0xDF, 0x39, 0xFC, 0x84, 0x21, 0xF9, 0xC6, 0x33,
  0xF0, 0xFE, 0x21, 0x0C, 0x3C, 0x0C, 0x30, 0xDF, 0x4F, 0x3C, 0xD3, 0x7C,
  0x7D, 0x1F, 0xF0, 0x60, 0xF0, 0x7D, 0x84, 0x3E, 0x41, 0x04, 0x10, 0x40,
  0x7D, 0x3C, 0xD3, 0x7C, 0xF0, 0xDE, 0x84, 0x21, 0xE9, 0xCE, 0x73, 0x98,
  0x63, 0x01, 0xC6, 0x31, 0x8C, 0x38, 0x33, 0x0F, 0x11, 0x11, 0x19, 0xF0,
  0x82, 0x08, 0x26, 0xB3, 0x8B, 0x26, 0x9C, 0xE3, 0x18, 0xC6, 0x31, 0x8C,
  0x38, 0xFF, 0x5D, 0x75, 0xC7, 0x10, 0xF4, 0xE7, 0x39, 0xCC, 0x7D, 0x3C,
  0x71, 0x4C, 0xE0, 0xFC, 0xE3, 0x19, 0xFA, 0x10, 0x7D, 0x3C, 0xF3, 0x4D,
  0xF0, 0xC3, 0xFE, 0x31, 0x8C, 0x60, 0xFC, 0x38, 0x79, 0xF8, 0x42, 0x3E,
  0x84, 0x21, 0x8F, 0x9C, 0xE7, 0x3D, 0xFC, 0xC5, 0x36, 0xCA, 0x38, 0xC0,
  0xC7, 0xAB, 0xD3, 0x66, 0xC9, 0x80, 0xEC, 0xA3, 0x0E, 0x6F, 0x10, 0x45,
  0xB6, 0xCA, 0x38, 0x41, 0x38, 0xF9, 0x88, 0xCC, 0x7C, 0x3B, 0x18, 0xC6,
  0x61, 0x8C, 0x63, 0x0E, 0xFF, 0xE0, 0xE1, 0x08, 0x43, 0x0C, 0x84, 0x21,
  0x38, 0x65, 0xFC, 0x80,
};

const GFXglyph UbuntuSansMono_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 4, 4, 7, 1, -9 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 10, 7, 1, -9 },
  { 18, 7, 9, 7, 0, -9 },
  { 26, 6, 9, 7, 0, -9 },
  { 33, 1, 4, 7, 3, -9 },
  { 34, 4, 12, 7, 1, -10 },
  { 40, 4, 12, 7, 1, -10 },
  { 46, 5, 5, 7, 1, -8 },
  { 50, 5, 6, 7, 1, -7 },
  { 54, 3, 4, 7, 2, -2 },
  { 56, 3, 1, 7, 2, -4 },
  { 57, 3, 2, 7, 2, -2 },
  { 58, 5, 11, 7, 1, -9 },
  { 65, 5, 9, 7, 1, -9 },
  { 71, 5, 8, 7, 1, -8 },
  { 76, 5, 9, 7, 1, -9 },
  { 82, 5, 9, 7, 1, -9 },
  { 88, 6, 8, 7, 0, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 5, 8, 7, 1, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 5, 9, 7, 1, -9 },
  { 115, 5, 9, 7, 1, -9 },
  { 121, 3, 6, 7, 2, -6 },
  { 124, 3, 8, 7, 2, -6 },
  { 127, 5, 5, 7, 1, -6 },
  { 131, 5, 3, 7, 1, -5 },
  { 133, 5, 5, 7, 1, -6 },
  { 137, 5, 9, 7, 1, -9 },
  { 143, 6, 11, 7, 0, -9 },
  { 152, 7, 8, 7, 0, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 6, 9, 7, 0, -9 },
  { 171, 5, 8, 7, 1, -8 },
  { 176, 5, 8, 7, 1, -8 },
  { 181, 5, 8, 7, 1, -8 },
  { 186, 6, 9, 7, 0, -9 },
  { 193, 5, 8, 7, 1, -8 },
  { 198, 5, 8, 7, 1, -8 },
  { 203, 5, 8, 7, 1, -8 },
  { 208, 6, 8, 7, 1, -8 },
  { 214, 5, 8, 7, 1, -8 },
  { 219, 6, 8, 7, 0, -8 },
  { 225, 5, 8, 7, 1, -8 },
  { 230, 6, 9, 7, 0, -9 },
  { 237, 5, 8, 7, 1, -8 },
  { 242, 6, 10, 7, 0, -8 },
  { 250, 5, 8, 7, 1, -8 },
  { 255, 5, 9, 7, 1, -9 },
  { 261, 6, 8, 7, 0, -8 },
  { 267, 5, 8, 7, 1, -8 },
  { 272, 7, 8, 7, 0, -8 },
  { 279, 6, 8, 7, 0, -8 },
  { 285, 7, 8, 7, 0, -8 },
  { 292, 7, 8, 7, 0, -8 },
  { 299, 5, 8, 7, 1, -8 },
  { 304, 3, 11, 7, 2, -9 },
  { 309, 5, 11, 7, 1, -9 },
  { 316, 4, 11, 7, 1, -9 },
  { 322, 6, 4, 7, 0, -8 },
  { 325, 7, 1, 7, 0, 1 },
  { 326, 3, 2, 7, 2, -9 },
  { 327, 5, 6, 7, 1, -6 },
  { 331, 5, 9, 7, 1, -9 },
  { 337, 5, 6, 7, 1, -6 },
  { 341, 6, 9, 7, 0, -9 },
  { 348, 6, 6, 7, 0, -6 },
  { 353, 6, 9, 7, 1, -9 },
  { 360, 6, 8, 7, 0, -6 },
  { 366, 5, 9, 7, 1, -9 },
  { 372, 5, 9, 7, 1, -9 },
  { 378, 4, 11, 7, 1, -9 },
  { 384, 6, 9, 7, 1, -9 },
  { 391, 5, 9, 7, 1, -9 },
  { 397, 6, 6, 7, 0, -6 },
  { 402, 5, 6, 7, 1, -6 },
  { 406, 6, 6, 7, 0, -6 },
  { 411, 5, 8, 7, 1, -6 },
  { 416, 6, 8, 7, 0, -6 },
  { 422, 5, 6, 7, 1, -6 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 5, 8, 7, 1, -8 },
  { 435, 5, 6, 7, 1, -6 },
  { 439, 6, 6, 7, 0, -6 },
  { 444, 7, 6, 7, 0, -6 },
  { 450, 6, 6, 7, 0, -6 },
  { 455, 6, 8, 7, 0, -6 },
  { 461, 5, 6, 7, 1, -6 },
  { 465, 5, 11, 7, 1, -9 },
  { 472, 1, 11, 7, 3, -9 },
  { 474, 5, 11, 7, 1, -9 },
  { 481, 6, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_SEMIBOLD12PT7B_H_
