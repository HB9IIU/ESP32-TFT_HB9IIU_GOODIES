#ifndef _UBUNTUSANSMONO_SEMIBOLD37PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3C, 0x78, 0x00, 0x00, 0x03, 0x8F, 0xBF, 0xFF, 0xFC, 0xF8,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B, 0xE3, 0xCE,
  0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF1,
  0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7E, 0x06, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x80, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x73, 0xF8, 0x0F,
  0x7F, 0x81, 0xE7, 0x38, 0x1C, 0x73, 0xC3, 0xC7, 0x1C, 0x38, 0x71, 0xC7,
  0x07, 0x1C, 0xF0, 0x73, 0xCE, 0x07, 0xB9, 0xC0, 0x7F, 0xBC, 0x03, 0xF3,
  0x80, 0x0C, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0xC0, 0x1E, 0xFE, 0x03,
  0xCF, 0xF0, 0x39, 0xC7, 0x07, 0x9C, 0x70, 0x71, 0xC7, 0x0E, 0x1C, 0x71,
  0xE1, 0xC7, 0x1C, 0x1C, 0x73, 0x81, 0xEF, 0x78, 0x0F, 0xEF, 0x00, 0x7C,
  0x00, 0x01, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x3E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C,
  0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x3C, 0x3F, 0x87,
  0x8F, 0xF8, 0xF3, 0xEF, 0x9C, 0x78, 0xFF, 0x9E, 0x1F, 0xF3, 0xC1, 0xFE,
  0x78, 0x1F, 0x8F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x1F, 0xE3, 0xFF, 0xFE,
  0x3F, 0xF3, 0xC3, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x73, 0x9C,
  0xE0, 0x00, 0x60, 0x07, 0x80, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x40,
  0x60, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x1C, 0x00, 0x40, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x06, 0x1C, 0x33, 0xCE, 0x79,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFE, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEF,
  0x01, 0xF7, 0xC1, 0xF1, 0xF0, 0x78, 0xF0, 0x18, 0x20, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x08, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3F, 0x0F, 0x0E, 0x3E, 0xFC, 0xF8,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xF3, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x71, 0xFE, 0x7C, 0xFF, 0x3E, 0x7F,
  0x9F, 0x3F, 0xC7, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xE7, 0x81, 0xF3, 0xE0, 0xF9, 0xFD, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0x71,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x83,
  0xE1, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF2, 0x00, 0xF9, 0xF3, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1E, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F,
  0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x10, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0x7D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80,
  0xF3, 0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7B, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x3E, 0x0F, 0x9F, 0x8F, 0x87, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xF8, 0x7E, 0xF8, 0x1F, 0x78, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF9, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xF3, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x1F, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x1F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE0, 0x04, 0x0F,
  0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x7C, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3, 0xF0, 0x70, 0x78, 0x79,
  0xFC, 0xF8, 0x78, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFF, 0xE6, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0xCF, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0F, 0x70, 0x7F, 0xDC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xE3, 0xFC, 0xF8, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xFC,
  0xF0, 0xFF, 0x3C, 0x3F, 0xCF, 0x8F, 0xF1, 0xF3, 0xDC, 0x7F, 0xF7, 0x8F,
  0xFD, 0xE1, 0xFF, 0x78, 0x0C, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3D, 0xE0,
  0x03, 0xDE, 0x00, 0x39, 0xE0, 0x07, 0x9F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0,
  0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x1F, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E,
  0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x81, 0x8F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x21,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xE7, 0xC1, 0xFB,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC3, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x81, 0x8F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x3E, 0x07, 0xCF,
  0xC1, 0xF1, 0xFE, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x06,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x60, 0x3E, 0x7D, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x3F, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0,
  0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF0,
  0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xEF, 0xC0, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x9D, 0xC7, 0xF3,
  0xB8, 0xFE, 0x77, 0x3F, 0xCE, 0xE7, 0x79, 0xCE, 0xEF, 0x39, 0xDD, 0xE7,
  0x3F, 0x3C, 0xE3, 0xE7, 0x9C, 0x7C, 0xF7, 0x8F, 0x1E, 0xF1, 0xE3, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFB, 0xC3, 0xFC, 0xE1, 0xFE, 0x78, 0xFF, 0x1C,
  0x7F, 0x8F, 0x3F, 0xC3, 0x9F, 0xE1, 0xEF, 0xF0, 0x77, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0x1F, 0x01, 0xF3, 0xC0, 0x3E,
  0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x79,
  0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0xEF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x3F, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xE1, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xC0,
  0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00,
  0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0x80, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF,
  0x81, 0xF3, 0xE0, 0xFC, 0xFB, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xF0,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC0, 0x67, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFA, 0x00, 0xFD, 0xF1,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xFC, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF9, 0xFD,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3C, 0xF0, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E,
  0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF8, 0xF0,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC7, 0x8F, 0x38, 0xF9, 0xE7, 0x1F, 0x3C, 0xE7, 0xE7, 0x9C, 0xFE, 0xF3,
  0x9D, 0xDE, 0x73, 0xBB, 0xCE, 0xE7, 0x79, 0xDC, 0x7F, 0x3B, 0x8F, 0xE7,
  0xE1, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0x87,
  0x80, 0xF0, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3,
  0xE0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0x7D, 0xF0, 0x07, 0xBC, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8,
  0x07, 0xFF, 0x00, 0x7C, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x1F,
  0x1F, 0x03, 0xE3, 0xC0, 0x3E, 0xF8, 0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8,
  0x3E, 0x3E, 0x03, 0xEF, 0xC0, 0x7E, 0xF0, 0x07, 0x84, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x18, 0x1F,
  0x1F, 0xC3, 0xF0, 0xFC, 0x1C, 0x04, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x20, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x10, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFC, 0x7E, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xF0, 0x13, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xF7,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x02, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07,
  0xE1, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xFF,
  0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFB,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0xC0, 0x7C, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0x10, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xEF,
  0x83, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xE0, 0x02, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x20, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xDC, 0x1F, 0x7F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x07, 0xF0, 0x10, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x0F, 0xDE, 0x0F, 0xCF, 0x07, 0xC7, 0x87, 0xC3,
  0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0x7E, 0x07, 0x9F, 0x83, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0, 0x7C, 0x78,
  0x3F, 0x3C, 0x0F, 0xDE, 0x03, 0xEF, 0x01, 0xF8, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0E, 0x0E,
  0x3F, 0xEF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF,
  0x1E, 0x1F, 0xC7, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xC7,
  0x87, 0xF1, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0x1F, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF0, 0x01, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x03, 0xF7, 0xC0,
  0x7D, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3E, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3,
  0xF0, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xF0, 0x3E, 0xFC,
  0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C,
  0x06, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x40, 0x0F, 0x7E,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x08, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x78, 0x78, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xE3,
  0xC0, 0x7C, 0x78, 0x07, 0x9F, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x0E, 0x1F, 0xE3,
  0xE3, 0xFC, 0x7C, 0x77, 0x8F, 0x8E, 0x71, 0xF1, 0xCE, 0x7F, 0x79, 0xCE,
  0xEF, 0x39, 0xDD, 0xE7, 0xF3, 0xFC, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0xCF,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0x80, 0xFB, 0xE0, 0x1F, 0x78, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFB, 0xE0, 0x3E, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x7C, 0x7C,
  0x07, 0x8F, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x7C,
  0x3C, 0x1F, 0x0F, 0x03, 0xC7, 0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x20, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x03,
  0xF0, 0x3C, 0xFF, 0x87, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xE1, 0xFF, 0x3C,
  0x0F, 0xC0, 0x80, 0x70,
};

const GFXglyph UbuntuSansMono_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 13, 11, 21, 4, -28 },
  { 42, 19, 26, 21, 1, -26 },
  { 104, 17, 33, 21, 2, -29 },
  { 175, 20, 27, 21, 0, -26 },
  { 243, 19, 26, 21, 1, -26 },
  { 305, 5, 12, 21, 8, -28 },
  { 313, 13, 36, 21, 4, -29 },
  { 372, 13, 36, 21, 4, -29 },
  { 431, 17, 16, 21, 2, -26 },
  { 465, 17, 18, 21, 2, -20 },
  { 504, 8, 13, 21, 6, -7 },
  { 517, 11, 5, 21, 5, -13 },
  { 524, 7, 7, 21, 7, -7 },
  { 531, 17, 36, 21, 2, -29 },
  { 608, 17, 27, 21, 2, -26 },
  { 666, 17, 26, 21, 2, -26 },
  { 722, 17, 26, 21, 2, -26 },
  { 778, 17, 27, 21, 2, -26 },
  { 836, 19, 26, 21, 1, -26 },
  { 898, 16, 27, 21, 2, -26 },
  { 952, 17, 27, 21, 2, -26 },
  { 1010, 17, 26, 21, 2, -26 },
  { 1066, 17, 27, 21, 2, -26 },
  { 1124, 17, 26, 21, 2, -26 },
  { 1180, 7, 20, 21, 7, -20 },
  { 1198, 9, 26, 21, 5, -20 },
  { 1228, 17, 17, 21, 2, -19 },
  { 1265, 17, 12, 21, 2, -17 },
  { 1291, 17, 17, 21, 2, -19 },
  { 1328, 15, 26, 21, 3, -26 },
  { 1377, 18, 32, 21, 1, -26 },
  { 1449, 20, 26, 21, 0, -26 },
  { 1514, 17, 26, 21, 2, -26 },
  { 1570, 18, 27, 21, 1, -26 },
  { 1631, 17, 26, 21, 2, -26 },
  { 1687, 16, 26, 21, 3, -26 },
  { 1739, 15, 26, 21, 3, -26 },
  { 1788, 18, 27, 21, 1, -26 },
  { 1849, 17, 26, 21, 2, -26 },
  { 1905, 15, 26, 21, 3, -26 },
  { 1954, 16, 27, 21, 2, -26 },
  { 2008, 18, 26, 21, 2, -26 },
  { 2067, 16, 26, 21, 3, -26 },
  { 2119, 19, 26, 21, 1, -26 },
  { 2181, 17, 26, 21, 2, -26 },
  { 2237, 19, 27, 21, 1, -26 },
  { 2302, 17, 26, 21, 2, -26 },
  { 2358, 19, 33, 21, 1, -26 },
  { 2437, 18, 26, 21, 2, -26 },
  { 2496, 17, 27, 21, 2, -26 },
  { 2554, 19, 26, 21, 1, -26 },
  { 2616, 17, 27, 21, 2, -26 },
  { 2674, 19, 26, 21, 1, -26 },
  { 2736, 19, 26, 21, 1, -26 },
  { 2798, 19, 26, 21, 1, -26 },
  { 2860, 19, 26, 21, 1, -26 },
  { 2922, 17, 26, 21, 2, -26 },
  { 2978, 11, 36, 21, 5, -29 },
  { 3028, 17, 36, 21, 2, -29 },
  { 3105, 11, 36, 21, 5, -29 },
  { 3155, 19, 15, 21, 1, -26 },
  { 3191, 20, 4, 21, 0, 3 },
  { 3201, 9, 8, 21, 6, -29 },
  { 3210, 16, 20, 21, 2, -20 },
  { 3250, 16, 29, 21, 3, -29 },
  { 3308, 17, 20, 21, 2, -20 },
  { 3351, 17, 29, 21, 1, -29 },
  { 3413, 18, 20, 21, 1, -20 },
  { 3458, 18, 29, 21, 2, -29 },
  { 3524, 17, 27, 21, 1, -20 },
  { 3582, 15, 29, 21, 3, -29 },
  { 3637, 17, 29, 21, 2, -29 },
  { 3699, 14, 36, 21, 2, -29 },
  { 3762, 17, 29, 21, 3, -29 },
  { 3824, 17, 29, 21, 2, -29 },
  { 3886, 18, 20, 21, 1, -20 },
  { 3931, 15, 20, 21, 3, -20 },
  { 3969, 18, 21, 21, 1, -20 },
  { 4017, 16, 27, 21, 3, -20 },
  { 4071, 17, 27, 21, 1, -20 },
  { 4129, 15, 20, 21, 4, -20 },
  { 4167, 16, 20, 21, 2, -20 },
  { 4207, 17, 25, 21, 2, -25 },
  { 4261, 15, 19, 21, 3, -19 },
  { 4297, 19, 19, 21, 1, -19 },
  { 4343, 19, 19, 21, 1, -19 },
  { 4389, 19, 19, 21, 1, -19 },
  { 4435, 18, 26, 21, 1, -19 },
  { 4494, 15, 19, 21, 3, -19 },
  { 4530, 15, 36, 21, 3, -29 },
  { 4598, 5, 36, 21, 8, -29 },
  { 4621, 15, 36, 21, 3, -29 },
  { 4689, 19, 8, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_SEMIBOLD37PT7B_H_
