#ifndef _UBUNTUSANSMONO_SEMIBOLD39PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xCF, 0x8F, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xBF, 0xFE, 0xFD,
  0xF0, 0x80, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x0E, 0x03,
  0xE3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x7C, 0x7C, 0x07, 0x87, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1E, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFC, 0x7E, 0x03, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x60, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x3F, 0xFC,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x04, 0x00, 0x01, 0xF8, 0x03, 0xCF, 0xE0, 0x1C, 0xF7, 0x81, 0xE7, 0x1C,
  0x0E, 0x38, 0xE0, 0xF1, 0xC7, 0x0F, 0x0E, 0x38, 0x70, 0x71, 0xC7, 0x83,
  0x8E, 0x78, 0x1E, 0xF3, 0x80, 0xFF, 0x3C, 0x03, 0xFB, 0xC0, 0x0F, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0xE7, 0xF0, 0x0F, 0x7F, 0x80,
  0xF3, 0xDE, 0x07, 0x9C, 0x70, 0x78, 0xE3, 0x83, 0x87, 0x1C, 0x3C, 0x38,
  0xE3, 0xC1, 0xC7, 0x1C, 0x0E, 0x39, 0xE0, 0x7F, 0xDE, 0x01, 0xFD, 0xE0,
  0x0F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1,
  0xE0, 0x3C, 0x3E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x18, 0x1F, 0xC1, 0xE3, 0xFE, 0x1E, 0x7D, 0xF3, 0xC7,
  0x8F, 0xBC, 0xF8, 0xFF, 0xCF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F, 0x01, 0xF8,
  0xF8, 0x0F, 0x8F, 0x81, 0xFC, 0x7E, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xF9,
  0xE0, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x78, 0x00, 0x10, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0xC0, 0x20, 0x01, 0xC0, 0x07,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x71, 0xE3, 0x9F, 0x7B, 0xE7, 0xED, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0x80,
  0x78, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3E, 0x0F, 0xCF, 0xC1, 0xE1,
  0xE0, 0x38, 0x70, 0x04, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0x7E, 0x0F, 0x0F, 0x0F,
  0xBF, 0x9F, 0x8F, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7C, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7,
  0xC0, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC3,
  0x1F, 0xF1, 0xE3, 0xFC, 0xF8, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0xC7,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xE7,
  0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xF3, 0xC0, 0x38, 0xF0,
  0x08, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1E, 0x07, 0xC2, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0C, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF9,
  0x00, 0x7E, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF,
  0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0x00, 0x7E, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xE7,
  0xE0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0x3F, 0x9F, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0x9E, 0x03,
  0xE7, 0xC0, 0xF9, 0xFC, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x7C, 0x7F, 0x9F, 0x07, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x7F, 0x1F, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xDF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x81, 0xFB,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3C,
  0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7C, 0x0F, 0x07, 0xE3, 0xF8,
  0xFF, 0x3F, 0xC7, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x7E, 0x3F, 0x8F, 0xF3, 0xFC, 0x7F, 0x1F, 0x81, 0xE0,
  0x78, 0x7C, 0xFE, 0x1F, 0x07, 0x81, 0x00, 0x00, 0x01, 0x80, 0x03, 0xE0,
  0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x1F, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x60, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xCF,
  0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x07, 0xFD, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xE3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF3,
  0xE1, 0xFE, 0x7C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3,
  0xE3, 0xFC, 0x7F, 0xFB, 0xC7, 0xFF, 0x78, 0x7F, 0xEF, 0x07, 0xFC, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x7C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x7C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xFE, 0x00, 0x3E, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xFB, 0xE0, 0x7E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x00, 0x8F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x02, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3D, 0xF0, 0x07,
  0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0x01, 0x8F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xC0, 0xF9, 0xFC, 0x1F, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x01, 0x00, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFA, 0x00, 0xF9, 0xC0, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F,
  0xFE, 0x00, 0x20, 0x00, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C,
  0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xE0, 0xF9,
  0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0xC3, 0xC0, 0x7C,
  0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF1, 0xFE, 0x7F, 0x9D, 0xE7, 0xB9, 0xDE, 0x7B, 0xBD, 0xE7, 0xBF,
  0x9E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0x8F, 0x1E, 0x78,
  0xF1, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xBC, 0x7F, 0xEF, 0x1F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8F,
  0x7F, 0xE3, 0xDF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7C, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E,
  0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF,
  0x87, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xBF, 0x1F,
  0x00, 0x87, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7D, 0x80, 0x3E, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xF7, 0xC0, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E,
  0x79, 0xF9, 0xE7, 0xBF, 0x9E, 0x7B, 0x9D, 0xE7, 0xB9, 0xDE, 0x7F, 0x9D,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x3C, 0x03, 0xC0, 0xFC, 0x03, 0xF7,
  0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x3E,
  0x07, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xFF, 0x80, 0x1F, 0x38, 0x01, 0xC0,
  0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x20, 0x38, 0x3F, 0x1F, 0xC3, 0xF0, 0xFC, 0x1C, 0x04, 0x0F, 0xF0,
  0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x01, 0xCF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBF, 0xDF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7D, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF3,
  0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x80, 0x00,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xC1, 0x9F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x4F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF9, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xC7, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC1, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C, 0x0F, 0x9F, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0x06, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xFC, 0x3F, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE0, 0xF9, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0xC0, 0x7E,
  0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFB, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0x7E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x10, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x30, 0x7E, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF,
  0xC3, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F,
  0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0x9F, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x10, 0x3F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0x07, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF1, 0xF3, 0xEF, 0x0F, 0x1E, 0xF0, 0xF1,
  0xEF, 0x0F, 0x1F, 0xF0, 0xF1, 0xFF, 0x0F, 0x1F, 0xF0, 0xF1, 0xFF, 0x0F,
  0x1F, 0xF0, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xF0,
  0x1F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xFC, 0xFC, 0x0F, 0x9F, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0x3E, 0x0F, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x1F,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x87, 0xDF, 0x81,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E,
  0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x73, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x60, 0x0F, 0xBF, 0xFF, 0xDF, 0xFF,
  0xDF, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x40, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x04, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0xF8, 0x01,
  0xFF, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x1F, 0x8E, 0x71, 0xF9, 0xE7, 0x9F,
  0x9E, 0x7B, 0xFD, 0xE7, 0xBB, 0xDE, 0x7B, 0x9D, 0xE7, 0xB9, 0xDC, 0x3F,
  0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0xFC, 0x03, 0xF3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8,
  0x0F, 0x9F, 0x00, 0xFD, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xF9,
  0xF0, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x7E, 0x7C,
  0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x0F,
  0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x07,
  0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0x80, 0xE3, 0xFE, 0x0F, 0x7F, 0xF9, 0xF7,
  0xFF, 0xFE, 0x79, 0xFF, 0xEF, 0x07, 0xFC, 0x70, 0x1F, 0x80,
};

const GFXglyph UbuntuSansMono_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 7, 28, 22, 7, -27 },
  { 26, 14, 12, 22, 4, -30 },
  { 47, 20, 27, 22, 1, -27 },
  { 115, 18, 34, 22, 2, -30 },
  { 192, 21, 29, 22, 0, -28 },
  { 269, 20, 28, 22, 1, -28 },
  { 339, 6, 13, 22, 8, -30 },
  { 349, 14, 38, 22, 4, -31 },
  { 416, 14, 38, 22, 4, -31 },
  { 483, 18, 17, 22, 2, -27 },
  { 522, 18, 19, 22, 2, -21 },
  { 565, 9, 14, 22, 6, -7 },
  { 581, 12, 5, 22, 5, -14 },
  { 589, 8, 7, 22, 7, -7 },
  { 596, 18, 38, 22, 2, -31 },
  { 682, 18, 29, 22, 2, -28 },
  { 748, 18, 27, 22, 2, -27 },
  { 809, 18, 28, 22, 2, -28 },
  { 872, 18, 29, 22, 2, -28 },
  { 938, 20, 27, 22, 1, -27 },
  { 1006, 17, 28, 22, 2, -27 },
  { 1066, 18, 28, 22, 2, -27 },
  { 1129, 18, 27, 22, 2, -27 },
  { 1190, 18, 29, 22, 2, -28 },
  { 1256, 18, 28, 22, 2, -28 },
  { 1319, 8, 21, 22, 7, -21 },
  { 1340, 10, 28, 22, 5, -21 },
  { 1375, 18, 18, 22, 2, -20 },
  { 1416, 18, 13, 22, 2, -18 },
  { 1446, 18, 18, 22, 2, -20 },
  { 1487, 16, 29, 22, 3, -28 },
  { 1545, 19, 34, 22, 1, -28 },
  { 1626, 21, 27, 22, 0, -27 },
  { 1697, 18, 27, 22, 2, -27 },
  { 1758, 19, 29, 22, 1, -28 },
  { 1827, 19, 27, 22, 2, -27 },
  { 1892, 17, 27, 22, 3, -27 },
  { 1950, 16, 27, 22, 3, -27 },
  { 2004, 19, 29, 22, 1, -28 },
  { 2073, 18, 27, 22, 2, -27 },
  { 2134, 16, 27, 22, 3, -27 },
  { 2188, 17, 28, 22, 2, -27 },
  { 2248, 19, 27, 22, 2, -27 },
  { 2313, 17, 27, 22, 3, -27 },
  { 2371, 20, 27, 22, 1, -27 },
  { 2439, 18, 27, 22, 2, -27 },
  { 2500, 20, 29, 22, 1, -28 },
  { 2573, 17, 27, 22, 3, -27 },
  { 2631, 20, 35, 22, 1, -28 },
  { 2719, 19, 27, 22, 2, -27 },
  { 2784, 18, 29, 22, 2, -28 },
  { 2850, 20, 27, 22, 1, -27 },
  { 2918, 18, 28, 22, 2, -27 },
  { 2981, 20, 27, 22, 1, -27 },
  { 3049, 20, 27, 22, 1, -27 },
  { 3117, 20, 27, 22, 1, -27 },
  { 3185, 20, 27, 22, 1, -27 },
  { 3253, 18, 27, 22, 2, -27 },
  { 3314, 12, 38, 22, 5, -31 },
  { 3371, 18, 38, 22, 2, -31 },
  { 3457, 12, 38, 22, 5, -31 },
  { 3514, 20, 16, 22, 1, -27 },
  { 3554, 21, 4, 22, 0, 3 },
  { 3565, 9, 8, 22, 7, -30 },
  { 3574, 17, 21, 22, 2, -21 },
  { 3619, 17, 30, 22, 3, -30 },
  { 3683, 18, 21, 22, 2, -21 },
  { 3731, 18, 30, 22, 1, -30 },
  { 3799, 19, 21, 22, 1, -21 },
  { 3849, 19, 30, 22, 2, -30 },
  { 3921, 17, 28, 22, 2, -21 },
  { 3981, 16, 30, 22, 3, -30 },
  { 4041, 18, 30, 22, 2, -30 },
  { 4109, 15, 37, 22, 2, -30 },
  { 4179, 18, 30, 22, 3, -30 },
  { 4247, 18, 30, 22, 2, -30 },
  { 4315, 20, 21, 22, 1, -21 },
  { 4368, 16, 21, 22, 3, -21 },
  { 4410, 19, 22, 22, 1, -21 },
  { 4463, 17, 28, 22, 3, -21 },
  { 4523, 18, 28, 22, 1, -21 },
  { 4586, 16, 21, 22, 4, -21 },
  { 4628, 17, 21, 22, 2, -21 },
  { 4673, 18, 27, 22, 2, -27 },
  { 4734, 16, 20, 22, 3, -20 },
  { 4774, 20, 20, 22, 1, -20 },
  { 4824, 20, 20, 22, 1, -20 },
  { 4874, 20, 20, 22, 1, -20 },
  { 4924, 19, 27, 22, 1, -20 },
  { 4989, 16, 20, 22, 3, -20 },
  { 5029, 16, 38, 22, 3, -31 },
  { 5105, 4, 38, 22, 9, -31 },
  { 5124, 16, 38, 22, 3, -31 },
  { 5200, 20, 7, 22, 1, -15 },
};

const GFXfont UbuntuSansMono_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_SEMIBOLD39PT7B_H_
