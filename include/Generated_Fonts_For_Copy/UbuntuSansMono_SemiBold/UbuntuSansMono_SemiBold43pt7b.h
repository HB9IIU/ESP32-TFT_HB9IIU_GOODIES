#ifndef _UBUNTUSANSMONO_SEMIBOLD43PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xF7, 0x83, 0xDC, 0x0E, 0x70, 0x38, 0x01, 0xF0, 0xF8, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1E, 0x00, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80,
  0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF0, 0x0C, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x40,
  0x03, 0xF7, 0x80, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0x83,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x3F, 0xC0, 0x1E, 0x7F,
  0xC0, 0x3C, 0x79, 0xE0, 0x7C, 0x71, 0xE0, 0x78, 0x70, 0xE0, 0xF0, 0x70,
  0xE0, 0xF0, 0x70, 0xE1, 0xE0, 0x70, 0xE3, 0xC0, 0x71, 0xE3, 0xC0, 0x79,
  0xE7, 0x80, 0x7F, 0xCF, 0x00, 0x3F, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xF8, 0x00, 0xFB, 0xFC, 0x00,
  0xF3, 0xFE, 0x01, 0xE7, 0x9E, 0x01, 0xE7, 0x8E, 0x03, 0xC7, 0x0E, 0x07,
  0x87, 0x0E, 0x07, 0x87, 0x0E, 0x0F, 0x07, 0x0E, 0x1E, 0x07, 0x8E, 0x1E,
  0x07, 0x9E, 0x3C, 0x07, 0xFE, 0x78, 0x03, 0xFC, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x60, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x0F, 0x87, 0xFC, 0x3E, 0x3F, 0xF8,
  0xF8, 0xFB, 0xF3, 0xC7, 0xC7, 0xEF, 0x1E, 0x1F, 0xBC, 0xF8, 0x3F, 0xF3,
  0xE0, 0x7F, 0x8F, 0x80, 0xFE, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF0,
  0x3F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xBE, 0x1F, 0xFC, 0xFC, 0x3F, 0xC1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x10, 0x00, 0x70, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x20, 0x20, 0x01, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x20, 0xF0, 0x43, 0x8F, 0x1E,
  0x7E, 0xF7, 0xE7, 0xF7, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF8,
  0xFC, 0x0F, 0x0F, 0x80, 0x70, 0x60, 0x02, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7E, 0x03, 0xC0, 0x78, 0x3E, 0x7F, 0xC7, 0xF0, 0xF8, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x86, 0x1F, 0xF8, 0xF1, 0xFF, 0x9F, 0x9F, 0xF9, 0xF9, 0xFF, 0x9F, 0x9F,
  0xF8, 0xF1, 0xFF, 0x86, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7C, 0xF8, 0x0E,
  0x1F, 0x01, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7E, 0x1F, 0xC3, 0x80, 0xFC, 0x30, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3C, 0x1F, 0xC3, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x40, 0x07, 0xE7, 0x01, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xEE, 0x03, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0x7E, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E,
  0x7F, 0x07, 0xC3, 0xFC, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xFC, 0x3E, 0x1F, 0xE7, 0xC0, 0x7E, 0x7C, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7E,
  0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x7E, 0x01, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3F, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x06, 0x07, 0xE3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x1F, 0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1,
  0xFC, 0x0F, 0x07, 0x83, 0xEF, 0xF3, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xE7, 0x07, 0xF2, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF9, 0xFC, 0x1F, 0x81, 0xF0,
  0x78, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xE0,
  0x7F, 0xF7, 0x83, 0xFF, 0xDE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF1,
  0xFF, 0x8F, 0x87, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xC7, 0xC1, 0xFF,
  0x1F, 0x07, 0xFC, 0x7C, 0x1F, 0xF1, 0xF0, 0x7F, 0xE7, 0xC1, 0xFF, 0x8F,
  0x87, 0xDE, 0x3F, 0x1F, 0x78, 0x7F, 0xFD, 0xE1, 0xFF, 0xF7, 0xC3, 0xFF,
  0xCF, 0x03, 0xFE, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFC, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF0, 0x1F,
  0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3E,
  0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0xFF, 0xFF, 0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xE1, 0xE3, 0xF8,
  0x02, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x23, 0xFC, 0x0E, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x1F, 0xCF, 0x8F, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x3F, 0xC1, 0xE3, 0xF8, 0x02, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xE0, 0x1F, 0x7F, 0x01, 0xF3, 0xFC, 0x1F, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x20, 0x0F, 0xCF, 0x03, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x03,
  0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xF0, 0x0F,
  0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xF8, 0x7F,
  0x9E, 0xE1, 0xFE, 0x7B, 0x87, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E,
  0x73, 0x9E, 0x79, 0xFE, 0x79, 0xE7, 0xF9, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F,
  0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x87, 0x87, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFB, 0xE1, 0xFF, 0x9E, 0x1F, 0xF9, 0xE1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x87, 0x9F, 0xF8, 0x79, 0xFF, 0x83,
  0xDF, 0xF8, 0x3D, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xF0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0xCF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x03, 0xC7, 0xE0, 0x08,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x20, 0x03, 0xF7,
  0x80, 0x7E, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00,
  0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x1E, 0x1E, 0x78, 0x7C, 0x79, 0xE3,
  0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x79, 0xFE, 0x79, 0xE7, 0xF9,
  0xE7, 0x9C, 0xE7, 0x9E, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xEE, 0x1D, 0xE7,
  0xB8, 0x77, 0x9F, 0xE1, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x03, 0xF0,
  0x7E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F, 0x01, 0xF8,
  0x7E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F,
  0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x87,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x18, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x10, 0x0F, 0x07, 0xE3, 0xFC, 0x3F, 0x83, 0xF0, 0x78,
  0x06, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xE3,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x0F, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x06, 0x80, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7E,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x71, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFB, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xF0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xF0, 0x3F, 0x3F, 0x83, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x9F, 0xE7, 0xE0, 0x7E, 0x7C,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC1, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x78, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFC, 0xFE, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7E, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE8, 0x01, 0xF9, 0xF9, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xBF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xE0, 0x7E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x70, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x60, 0x3F, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0,
  0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x70, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x1F, 0x87, 0x87, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x78, 0xF8, 0x7B, 0xC3,
  0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F,
  0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0x1F,
  0xC3, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x7F,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3E, 0xFF, 0x87, 0xC3, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0, 0x7D,
  0xFC, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFE, 0xF8,
  0x04, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0x0B, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0x1F, 0xBF, 0x00, 0x2F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xD0, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC3, 0xFF, 0xC0,
  0x02, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x70, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0xE0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xF0, 0x7D,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x00,
  0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0x7C, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3F,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xE0, 0xFF, 0x87, 0x87, 0xFE, 0x1F,
  0x1F, 0xF8, 0xFC, 0x7D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x9E,
  0x79, 0xFE, 0x79, 0xE7, 0xF9, 0xE7, 0x9C, 0xF7, 0x8F, 0xF3, 0xDE, 0x3F,
  0xCF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x00,
  0x7C, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F,
  0xC0, 0xFC, 0x3E, 0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01,
  0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0x7F,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07,
  0x80, 0x20, 0x7F, 0x80, 0xF3, 0xFF, 0x87, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF9, 0xF1, 0xFF, 0xEF, 0x83, 0xFF, 0x1C, 0x03, 0xF8,
};

const GFXglyph UbuntuSansMono_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 31, 24, 8, -30 },
  { 32, 14, 13, 24, 5, -33 },
  { 55, 22, 30, 24, 1, -30 },
  { 138, 20, 38, 24, 2, -33 },
  { 233, 24, 31, 24, 0, -30 },
  { 326, 22, 30, 24, 1, -30 },
  { 409, 6, 14, 24, 9, -33 },
  { 420, 15, 42, 24, 5, -34 },
  { 499, 14, 42, 24, 5, -34 },
  { 573, 20, 19, 24, 2, -30 },
  { 621, 20, 21, 24, 2, -23 },
  { 674, 11, 15, 24, 6, -8 },
  { 695, 12, 5, 24, 6, -15 },
  { 703, 8, 9, 24, 8, -8 },
  { 712, 19, 42, 24, 3, -34 },
  { 812, 20, 31, 24, 2, -30 },
  { 890, 19, 30, 24, 3, -30 },
  { 962, 20, 30, 24, 2, -30 },
  { 1037, 20, 31, 24, 2, -30 },
  { 1115, 22, 30, 24, 1, -30 },
  { 1198, 19, 31, 24, 2, -30 },
  { 1272, 20, 31, 24, 2, -30 },
  { 1350, 19, 30, 24, 3, -30 },
  { 1422, 20, 32, 24, 2, -31 },
  { 1502, 20, 31, 24, 2, -31 },
  { 1580, 8, 24, 24, 8, -23 },
  { 1604, 10, 30, 24, 6, -23 },
  { 1642, 20, 21, 24, 2, -23 },
  { 1695, 20, 14, 24, 2, -20 },
  { 1730, 20, 20, 24, 2, -22 },
  { 1780, 17, 31, 24, 4, -30 },
  { 1846, 22, 37, 24, 1, -30 },
  { 1948, 24, 30, 24, 0, -30 },
  { 2038, 19, 30, 24, 3, -30 },
  { 2110, 20, 31, 24, 2, -30 },
  { 2188, 20, 30, 24, 3, -30 },
  { 2263, 19, 30, 24, 3, -30 },
  { 2335, 18, 30, 24, 3, -30 },
  { 2403, 20, 31, 24, 2, -30 },
  { 2481, 20, 30, 24, 2, -30 },
  { 2556, 18, 30, 24, 3, -30 },
  { 2624, 19, 31, 24, 2, -30 },
  { 2698, 22, 30, 24, 2, -30 },
  { 2781, 18, 30, 24, 4, -30 },
  { 2849, 22, 30, 24, 1, -30 },
  { 2932, 20, 30, 24, 2, -30 },
  { 3007, 22, 31, 24, 1, -30 },
  { 3093, 19, 30, 24, 3, -30 },
  { 3165, 22, 38, 24, 1, -30 },
  { 3270, 20, 30, 24, 3, -30 },
  { 3345, 20, 31, 24, 2, -30 },
  { 3423, 22, 30, 24, 1, -30 },
  { 3506, 20, 31, 24, 2, -30 },
  { 3584, 23, 30, 24, 1, -30 },
  { 3671, 22, 30, 24, 1, -30 },
  { 3754, 22, 30, 24, 1, -30 },
  { 3837, 23, 30, 24, 1, -30 },
  { 3924, 20, 30, 24, 2, -30 },
  { 3999, 13, 42, 24, 6, -34 },
  { 4068, 19, 42, 24, 3, -34 },
  { 4168, 13, 42, 24, 5, -34 },
  { 4237, 22, 17, 24, 1, -30 },
  { 4284, 24, 5, 24, 0, 3 },
  { 4299, 10, 8, 24, 7, -33 },
  { 4309, 19, 24, 24, 2, -23 },
  { 4366, 19, 34, 24, 3, -33 },
  { 4447, 20, 24, 24, 2, -23 },
  { 4507, 20, 34, 24, 1, -33 },
  { 4592, 20, 24, 24, 2, -23 },
  { 4652, 22, 33, 24, 2, -33 },
  { 4743, 19, 31, 24, 2, -23 },
  { 4817, 18, 33, 24, 3, -33 },
  { 4892, 20, 34, 24, 2, -33 },
  { 4977, 16, 41, 24, 3, -33 },
  { 5059, 20, 33, 24, 3, -33 },
  { 5142, 20, 34, 24, 2, -33 },
  { 5227, 21, 23, 24, 2, -23 },
  { 5288, 18, 23, 24, 3, -23 },
  { 5340, 21, 24, 24, 2, -23 },
  { 5403, 19, 31, 24, 3, -23 },
  { 5477, 19, 31, 24, 2, -23 },
  { 5551, 17, 23, 24, 5, -23 },
  { 5600, 18, 24, 24, 3, -23 },
  { 5654, 20, 30, 24, 2, -29 },
  { 5729, 18, 24, 24, 3, -23 },
  { 5783, 22, 23, 24, 1, -23 },
  { 5847, 22, 23, 24, 1, -23 },
  { 5911, 22, 23, 24, 1, -23 },
  { 5975, 22, 31, 24, 1, -23 },
  { 6061, 18, 23, 24, 3, -23 },
  { 6113, 18, 42, 24, 3, -34 },
  { 6208, 6, 42, 24, 9, -34 },
  { 6240, 18, 42, 24, 3, -34 },
  { 6335, 22, 8, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_SEMIBOLD43PT7B_H_
