#ifndef _UBUNTUSANSMONO_SEMIBOLD28PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE0, 0x00, 0x8F, 0xFF,
  0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCE, 0xF3, 0xB8, 0xE6, 0x19, 0x86, 0x0E,
  0x38, 0x38, 0xE0, 0xE3, 0x03, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0x1C, 0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x81, 0xFF, 0x9F, 0xF9, 0xF0, 0xCF, 0x00, 0x70, 0x03,
  0xC0, 0x1F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xDE, 0x3E, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xF8, 0x1D, 0xB8, 0x37, 0x30, 0xEE, 0x63, 0x9C,
  0xC6, 0x39, 0x9C, 0x37, 0x70, 0x7E, 0xC0, 0x73, 0x80, 0x0E, 0x00, 0x19,
  0xE0, 0x77, 0xE1, 0xCC, 0xC3, 0x39, 0x8E, 0x73, 0x18, 0xE6, 0x71, 0xCD,
  0xC1, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xFC, 0x1E, 0x78, 0x70,
  0xE1, 0xC7, 0x87, 0x1C, 0x0E, 0xF0, 0x3F, 0x80, 0x7C, 0x83, 0xE3, 0x9F,
  0xCE, 0xF7, 0xBB, 0x8F, 0xEE, 0x1F, 0x38, 0x3C, 0xE0, 0xF3, 0xEF, 0xE7,
  0xFB, 0x8F, 0xCF, 0xFF, 0xFF, 0xFE, 0xE6, 0x60, 0x01, 0x80, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x18, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x06, 0x00, 0x0F, 0x00, 0xE0, 0xCE, 0x2F, 0x6F, 0xFF, 0xFF,
  0xFF, 0x0F, 0x01, 0xF8, 0x3B, 0xC7, 0x9E, 0x31, 0xC1, 0x08, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C, 0xF9,
  0xF3, 0xE1, 0x87, 0x7C, 0xF0, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xEF,
  0xFE, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0x0F, 0xFC,
  0xF9, 0xE7, 0x87, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF3, 0x3F, 0x3D, 0xF9,
  0xEF, 0xC6, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x78, 0x71, 0xFF,
  0x8F, 0xF8, 0x1F, 0x80, 0x07, 0x00, 0xF0, 0x3F, 0x0F, 0xF0, 0xFF, 0x06,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x81, 0xFF,
  0x3F, 0xFC, 0xF3, 0xE2, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x83, 0xFF, 0x1F, 0xF8, 0x61,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x40, 0x7B, 0xFF, 0x9F,
  0xFD, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3B, 0xC1, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xC3, 0xC7, 0x0F, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1F, 0xF1, 0xFF, 0x8F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE8, 0x0F, 0x7F, 0xF3, 0xFF, 0x3F, 0xF0, 0x00, 0x20, 0x3E, 0x0F,
  0xE1, 0xFE, 0x3E, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xCF, 0xFE, 0xFF,
  0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xF7, 0xFE, 0x7F,
  0xE3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0x0F, 0xFC,
  0xF0, 0xF7, 0x07, 0xB8, 0x1D, 0xC1, 0xEF, 0x0E, 0x3E, 0xF1, 0xFF, 0x07,
  0xF8, 0x77, 0xE7, 0x07, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7B, 0xFF,
  0xCF, 0xFC, 0x3F, 0xC0, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07,
  0xB8, 0x3F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0xC3, 0xCF, 0xFE, 0x7F, 0xF0,
  0xF7, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0xE1, 0xFE, 0x0F, 0xC0, 0x78,
  0x00, 0x73, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xE7,
  0x80, 0x38, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7,
  0xCF, 0xCF, 0x0E, 0x1D, 0xF3, 0xC4, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E,
  0x0F, 0xF1, 0xFE, 0x7F, 0x83, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x03, 0x80,
  0x1F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x03, 0xF8,
  0xFF, 0x3F, 0xE0, 0xF8, 0x07, 0x00, 0x20, 0x00, 0x1F, 0x1F, 0xF9, 0xFF,
  0xB0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x0E, 0x0E, 0x70, 0x39, 0xC0, 0x7E, 0x1F,
  0xF8, 0xFF, 0xE7, 0xFF, 0x9E, 0x7E, 0x71, 0xFB, 0xC7, 0xEE, 0x1F, 0xBC,
  0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0xFF, 0x8F, 0xF7, 0x0F, 0x9C, 0x00, 0x38,
  0x00, 0xFC, 0x20, 0xFF, 0x81, 0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0xEE, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x78, 0x38,
  0x70, 0x70, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9E, 0x07, 0x3C, 0x0F,
  0x70, 0x1E, 0xE0, 0x3F, 0xC0, 0x38, 0x3C, 0x07, 0xFE, 0x3F, 0xF9, 0xC7,
  0xCE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1C, 0xFF, 0xE7, 0xFC, 0x3F, 0xF9,
  0xC3, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0xFF, 0xBF,
  0xF9, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x08, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFE, 0x38, 0x07, 0xFC, 0x3F, 0xF1, 0xCF, 0xCE, 0x1F, 0x70, 0x7B,
  0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3B, 0x83, 0xDC, 0x1E, 0xE1, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x7F,
  0xC7, 0xFE, 0x7C, 0x37, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEF, 0x07, 0x7C,
  0x39, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0E, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xCC, 0x1E, 0x7F, 0xF7, 0xFF, 0x0F,
  0xF0, 0xE0, 0xFF, 0x07, 0xB8, 0x79, 0xC7, 0x8E, 0x3C, 0x73, 0xC3, 0xBC,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3B, 0xC1, 0xCF, 0x0E, 0x7C, 0x71, 0xE3,
  0x87, 0x9C, 0x1E, 0xE0, 0xF7, 0x03, 0xF8, 0x1E, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0x7C, 0xDB, 0xB3, 0x6E,
  0xDD, 0xBB, 0x76, 0xEF, 0x9B, 0x9E, 0x6E, 0x79, 0xF9, 0xC7, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE,
  0x7E, 0x77, 0xE7, 0x7E, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x70, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x70,
  0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0x9C, 0x0E, 0x78, 0x79, 0xFF, 0xC3,
  0xFF, 0x07, 0xF0, 0x3E, 0x07, 0xFE, 0x3F, 0xF9, 0xC7, 0xEE, 0x0F, 0x70,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0x3C, 0x78, 0x7B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0x9C, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFF, 0x07, 0xF0, 0x07,
  0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x3C, 0x07, 0xFC, 0x3F,
  0xF9, 0xCF, 0xCE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0, 0xF7, 0x1F,
  0x3F, 0xF9, 0xFF, 0x0F, 0xF8, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7,
  0x07, 0xB8, 0x1D, 0xC0, 0xF0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0xF0, 0x67,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x40, 0x7B, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0,
  0xEF, 0x0F, 0x7F, 0xF9, 0xFF, 0x87, 0xF8, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0F, 0x1E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x71, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF9, 0xC7, 0xE7, 0x9B, 0x9E,
  0x6E, 0xF9, 0xBB, 0x76, 0xEC, 0xDB, 0xF3, 0x67, 0x8D, 0x9E, 0x1E, 0x78,
  0x79, 0xC1, 0xE7, 0x03, 0x80, 0x78, 0x1E, 0x78, 0x78, 0xF0, 0xE0, 0xF3,
  0xC0, 0xE7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x7F, 0x80, 0xE7, 0x03, 0xCF, 0x07, 0x1E, 0x1E, 0x1E, 0x38,
  0x3C, 0xF0, 0x3F, 0xC0, 0x78, 0xF0, 0x1E, 0xF0, 0x3C, 0xE0, 0x71, 0xE1,
  0xE3, 0xC3, 0x83, 0x8F, 0x07, 0x9C, 0x07, 0x38, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1D, 0xE0, 0xF3, 0xC7,
  0x87, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xF2, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x41, 0x8F, 0x1F, 0x1C, 0x20, 0x7F, 0x87, 0xFC, 0x7F,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x3F, 0xF7, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x30, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0x3C,
  0x3D, 0xE1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x77, 0x83,
  0xBC, 0x3D, 0xFF, 0xCF, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0xCF, 0xFE,
  0xF8, 0x17, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x00, 0x10, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xFF, 0x3F, 0xF7, 0xFF, 0x78,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x78,
  0x77, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x70, 0x3B, 0xC0, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xF0, 0x1F, 0xF0,
  0x7F, 0xC3, 0xC3, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F,
  0xF1, 0xFF, 0xDF, 0xFE, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x01, 0xE0,
  0x0E, 0x40, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x30, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF1,
  0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x04, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0x7F, 0xDF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1D, 0x0F, 0xFF,
  0xFF, 0xE7, 0xF0, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x1F, 0xF0, 0xF7, 0x8F, 0x3C, 0xF1, 0xEF, 0x0F, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xF7, 0x87, 0x9E, 0x3C, 0x79, 0xE1, 0xEF,
  0x0F, 0x78, 0x3C, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x7C, 0xF3, 0xFF, 0xEF, 0xFF, 0xB9, 0xCF, 0xE7, 0x1F,
  0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x7F, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x1E, 0x1E,
  0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xFE, 0x3F,
  0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xBC, 0x1D, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xCF, 0xFE, 0xF0, 0xF7,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF0,
  0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F,
  0xC7, 0xFE, 0x7F, 0xEF, 0x02, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x83, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0x7F, 0xF7, 0xFF, 0x3F, 0xF0, 0xE0, 0x3F, 0xC0, 0xFF, 0x03,
  0x9C, 0x0E, 0x70, 0x79, 0xE1, 0xC3, 0x8F, 0x0E, 0x3C, 0x3C, 0xE0, 0x77,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0xE0, 0x1D, 0xC0, 0x3B, 0x8C, 0x77, 0x38, 0xEE, 0x79, 0xDC, 0xF3, 0xB9,
  0xE6, 0x77, 0xEC, 0x6D, 0xD8, 0xD9, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x87,
  0x07, 0x0E, 0x00, 0xF0, 0x3D, 0xC1, 0xE7, 0x87, 0x0F, 0x3C, 0x1F, 0xE0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xDE, 0x0E, 0x3C,
  0x78, 0x79, 0xC1, 0xEF, 0x03, 0xC0, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E,
  0x1E, 0x78, 0x78, 0xE1, 0xC3, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x7B, 0x80,
  0xEE, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0x0F, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0xFC, 0x0F,
  0x00, 0xFC, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFF, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF,
  0x0F, 0xE0, 0xFC, 0x00, 0x3C, 0x19, 0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0xE1,
  0xF0,
};

const GFXglyph UbuntuSansMono_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 5, -19 },
  { 13, 10, 8, 16, 3, -21 },
  { 23, 14, 19, 16, 1, -19 },
  { 57, 13, 25, 16, 1, -22 },
  { 98, 15, 20, 16, 0, -20 },
  { 136, 14, 20, 16, 1, -20 },
  { 171, 4, 9, 16, 6, -21 },
  { 176, 10, 27, 16, 3, -22 },
  { 210, 10, 27, 16, 3, -22 },
  { 244, 12, 12, 16, 2, -19 },
  { 262, 13, 14, 16, 1, -15 },
  { 285, 7, 10, 16, 4, -5 },
  { 294, 8, 4, 16, 4, -10 },
  { 298, 6, 5, 16, 5, -5 },
  { 302, 12, 27, 16, 2, -22 },
  { 343, 13, 20, 16, 1, -20 },
  { 376, 12, 19, 16, 2, -19 },
  { 405, 13, 20, 16, 1, -20 },
  { 438, 13, 20, 16, 1, -20 },
  { 471, 14, 19, 16, 1, -19 },
  { 505, 13, 19, 16, 1, -19 },
  { 536, 12, 20, 16, 2, -20 },
  { 566, 12, 19, 16, 2, -19 },
  { 595, 13, 20, 16, 1, -20 },
  { 628, 13, 20, 16, 1, -20 },
  { 661, 6, 15, 16, 5, -15 },
  { 673, 7, 20, 16, 4, -15 },
  { 691, 13, 14, 16, 1, -15 },
  { 714, 13, 9, 16, 1, -13 },
  { 729, 13, 14, 16, 1, -15 },
  { 752, 11, 20, 16, 2, -20 },
  { 780, 14, 24, 16, 1, -20 },
  { 822, 15, 19, 16, 0, -19 },
  { 858, 13, 20, 16, 2, -20 },
  { 891, 14, 20, 16, 1, -20 },
  { 926, 13, 20, 16, 2, -20 },
  { 959, 12, 19, 16, 2, -19 },
  { 988, 12, 19, 16, 2, -19 },
  { 1017, 13, 20, 16, 1, -20 },
  { 1050, 13, 19, 16, 1, -19 },
  { 1081, 12, 19, 16, 2, -19 },
  { 1110, 13, 19, 16, 1, -19 },
  { 1141, 13, 19, 16, 2, -19 },
  { 1172, 12, 19, 16, 2, -19 },
  { 1201, 14, 19, 16, 1, -19 },
  { 1235, 12, 19, 16, 2, -19 },
  { 1264, 14, 20, 16, 1, -20 },
  { 1299, 13, 20, 16, 2, -20 },
  { 1332, 14, 25, 16, 1, -20 },
  { 1376, 13, 20, 16, 2, -20 },
  { 1409, 13, 20, 16, 1, -20 },
  { 1442, 14, 19, 16, 1, -19 },
  { 1476, 13, 19, 16, 1, -19 },
  { 1507, 15, 19, 16, 0, -19 },
  { 1543, 14, 19, 16, 1, -19 },
  { 1577, 15, 19, 16, 0, -19 },
  { 1613, 15, 19, 16, 0, -19 },
  { 1649, 12, 19, 16, 2, -19 },
  { 1678, 8, 27, 16, 4, -22 },
  { 1705, 12, 27, 16, 2, -22 },
  { 1746, 9, 27, 16, 3, -22 },
  { 1777, 14, 11, 16, 1, -19 },
  { 1797, 15, 3, 16, 0, 2 },
  { 1803, 6, 6, 16, 5, -22 },
  { 1808, 12, 15, 16, 2, -15 },
  { 1831, 13, 22, 16, 2, -22 },
  { 1867, 13, 15, 16, 1, -15 },
  { 1892, 12, 22, 16, 1, -22 },
  { 1925, 14, 15, 16, 1, -15 },
  { 1952, 14, 22, 16, 1, -22 },
  { 1991, 13, 20, 16, 1, -15 },
  { 2024, 12, 22, 16, 2, -22 },
  { 2057, 13, 22, 16, 1, -22 },
  { 2093, 10, 27, 16, 2, -22 },
  { 2127, 13, 22, 16, 2, -22 },
  { 2163, 13, 22, 16, 1, -22 },
  { 2199, 14, 15, 16, 1, -15 },
  { 2226, 12, 15, 16, 2, -15 },
  { 2249, 14, 15, 16, 1, -15 },
  { 2276, 13, 20, 16, 2, -15 },
  { 2309, 13, 20, 16, 1, -15 },
  { 2342, 11, 15, 16, 3, -15 },
  { 2363, 12, 15, 16, 2, -15 },
  { 2386, 14, 19, 16, 1, -19 },
  { 2420, 12, 15, 16, 2, -15 },
  { 2443, 14, 15, 16, 1, -15 },
  { 2470, 15, 15, 16, 0, -15 },
  { 2499, 14, 15, 16, 1, -15 },
  { 2526, 14, 20, 16, 1, -15 },
  { 2561, 12, 15, 16, 2, -15 },
  { 2584, 12, 27, 16, 2, -22 },
  { 2625, 4, 27, 16, 6, -22 },
  { 2639, 12, 27, 16, 2, -22 },
  { 2680, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_SEMIBOLD28PT7B_H_
