#ifndef _UBUNTUSANSMONO_SEMIBOLD52PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC7, 0xE3,
  0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xCF, 0xE0, 0x80, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xC0, 0xFB, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x30,
  0x00, 0x7F, 0x1F, 0x00, 0x7F, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x7F, 0xE0, 0x03, 0xE7, 0xFF, 0x00, 0x7C, 0xF9, 0xF0, 0x0F,
  0x8F, 0x8F, 0x00, 0xF8, 0xF0, 0xF0, 0x1F, 0x0F, 0x0F, 0x81, 0xE0, 0xF0,
  0xF8, 0x3E, 0x0F, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x78, 0x0F, 0x0F, 0x8F,
  0x80, 0xF0, 0xF1, 0xF0, 0x0F, 0x9F, 0x1F, 0x00, 0x7F, 0xF3, 0xE0, 0x07,
  0xFE, 0x7C, 0x00, 0x3F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xF8,
  0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0x9F, 0xFC, 0x00, 0xF1, 0xF3, 0xE0, 0x1F,
  0x1E, 0x1E, 0x03, 0xE1, 0xE1, 0xE0, 0x3C, 0x3E, 0x1E, 0x07, 0xC3, 0xE1,
  0xE0, 0xF8, 0x3E, 0x1E, 0x0F, 0x83, 0xE1, 0xE1, 0xF0, 0x1E, 0x1E, 0x3E,
  0x01, 0xE3, 0xE3, 0xE0, 0x1F, 0xFE, 0x7C, 0x00, 0xFF, 0xCF, 0x80, 0x0F,
  0xFC, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0x80, 0x1F, 0xF0, 0x3E,
  0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xCF,
  0xE7, 0xE3, 0xF0, 0xFE, 0xFC, 0x7E, 0x0F, 0xFF, 0x0F, 0x80, 0xFF, 0xE3,
  0xF0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0xC3, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0x07, 0xFF, 0xC7, 0xE0, 0x3F, 0xE0,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x3C, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x20, 0x18,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x06, 0x0F, 0x81, 0x9F,
  0x1F, 0x0F, 0x3F, 0x9E, 0x7E, 0x7F, 0xBB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFB,
  0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F,
  0xE0, 0x7C, 0x1F, 0x80, 0x78, 0x3C, 0x00, 0x60, 0x30, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xFE, 0x1F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x1F, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x7F, 0x02, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x07,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xF0,
  0x20, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x3F, 0x1F, 0xFE, 0x3F, 0x8F, 0xFF,
  0x1F, 0xC7, 0xFF, 0x8F, 0xE3, 0xFF, 0xC3, 0xE1, 0xFF, 0xE0, 0xE0, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xC1, 0xF8,
  0x02, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x07, 0xF8, 0x38, 0x03, 0xFC, 0x30, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x01, 0xFE, 0x10, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xD0, 0x00, 0x7F, 0x38, 0x03, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x9C, 0x01, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE7, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0,
  0x3F, 0x9F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF,
  0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE1, 0xFC,
  0x03, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0xE3, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xFC, 0x3F, 0xF0, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0,
  0xFF, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x08, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFB, 0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE1, 0xFC, 0xFF, 0xBF, 0xEF, 0xFF, 0xFE, 0xFF, 0xBF,
  0xE7, 0xF0, 0x20, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0x1F, 0xF8, 0xFF, 0x87, 0xF0, 0x1F, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xE0, 0x1F, 0xC4, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x01, 0xDF, 0x7E, 0x07, 0xFF, 0xDF, 0x03, 0xFF,
  0xF7, 0xC1, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0x7C, 0x3F, 0xFF, 0xDF, 0x0F,
  0xE1, 0xF7, 0xC7, 0xF0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0x7E, 0x07, 0xFF,
  0x1F, 0x81, 0xFF, 0xC7, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0x7E, 0x07,
  0xFF, 0x1F, 0x81, 0xF7, 0xC7, 0xE0, 0x7D, 0xF1, 0xFC, 0x1F, 0x7C, 0x3F,
  0x07, 0xDF, 0x0F, 0xF3, 0xF7, 0xC1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0x3E,
  0x0F, 0xFF, 0xCF, 0x81, 0xFF, 0xF3, 0xF0, 0x0F, 0xF0, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x04, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFC,
  0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0x3C, 0x3F, 0xC0,
  0x02, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x04, 0x3F, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFE, 0x1F, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0x3C, 0x3F, 0xC0, 0x04, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x3F,
  0xE0, 0x7F, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x20, 0x01, 0xFC, 0xC0, 0x0F, 0xE7, 0xC0, 0xFF, 0x9F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xE3,
  0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3,
  0xF8, 0x03, 0xF1, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xDF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xF7, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x1F,
  0xE0, 0x0F, 0xC3, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0xFC, 0x1F, 0xE0, 0x3F,
  0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xE3, 0xF0, 0x03, 0xFC, 0xFC, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF1, 0xEF, 0x07, 0xFC, 0x7B, 0xC1, 0xEF, 0x1E, 0xF0, 0x7B, 0xC7, 0xFE,
  0x3E, 0xF1, 0xF7, 0x8F, 0x3C, 0x7D, 0xE3, 0xCF, 0x1F, 0x7D, 0xF3, 0xEF,
  0xCF, 0x7C, 0xFB, 0xF3, 0xDE, 0x3E, 0xFC, 0xFF, 0x8F, 0xBF, 0x3F, 0xE3,
  0xEF, 0xC7, 0xF0, 0xFB, 0xF1, 0xFC, 0x3E, 0xF8, 0x7F, 0x0F, 0xBE, 0x0F,
  0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x07,
  0xFF, 0xBF, 0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0x7C, 0x7F,
  0xF8, 0xFC, 0xFF, 0xF0, 0xF9, 0xFF, 0xE1, 0xFB, 0xFF, 0xC1, 0xF7, 0xFF,
  0x83, 0xEF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xF8,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFE, 0x07, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFE, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xF0, 0x7F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x07,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x80, 0x38, 0x7E, 0x00,
  0x08, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x60, 0x00, 0xFE, 0x78, 0x01,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE1,
  0xFC, 0x3E, 0xF8, 0x7F, 0x0F, 0xBE, 0x1F, 0xC3, 0xEF, 0x8F, 0xF8, 0xFB,
  0xE3, 0xFE, 0x3E, 0xF8, 0xF7, 0x8F, 0xBE, 0x3D, 0xF3, 0xE7, 0x9F, 0x3C,
  0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0xF8, 0x7B, 0xC7, 0xBC,
  0x1E, 0xF1, 0xEF, 0x07, 0xBC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x0F, 0xEF, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFC, 0xF8,
  0x00, 0x3F, 0x07, 0x00, 0x03, 0x80, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x03, 0xC0, 0x7E, 0x07,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7E, 0x01, 0xC0, 0x04, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x84, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xF8, 0x0F, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xFB,
  0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xE0, 0x04, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x06, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC7,
  0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFD, 0xFE, 0x07, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0xFF, 0x00,
  0xFC, 0xFF, 0x01, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x2F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x78, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x00, 0x74, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xE0,
  0x3F, 0x80, 0x08, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0xBF, 0x80,
  0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7,
  0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x07, 0xFE, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x9C, 0x01, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC,
  0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x20, 0x07, 0xF3, 0xC0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xFE, 0xFC, 0x03, 0xFC, 0xFC, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC,
  0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x3F, 0xF9, 0xFE, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF8, 0x7F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07,
  0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0x01, 0xFE, 0x7E, 0x01, 0xFE, 0xFC, 0x01, 0xFD, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xEF, 0xFC, 0x0F, 0xC1, 0x80, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0xBF, 0xC0, 0x3F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xEF,
  0xF0, 0x0F, 0xDF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFB, 0xF0, 0x03, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFE, 0xFF, 0x1F, 0xC0, 0x04, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xEC,
  0x00, 0x1F, 0xDF, 0x00, 0x7F, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x17, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x06, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xA0, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07, 0xC1, 0xFB, 0xE0, 0xFC, 0x3F,
  0x7C, 0x1F, 0x87, 0xCF, 0x87, 0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F,
  0xE3, 0xE7, 0xC7, 0xFC, 0x7C, 0xF8, 0xFF, 0x8F, 0x9F, 0x1E, 0xF1, 0xF1,
  0xF3, 0xDF, 0x3C, 0x3E, 0xFB, 0xEF, 0x87, 0xDE, 0x3D, 0xF0, 0xFB, 0xC7,
  0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x07,
  0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x04, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x07, 0x07, 0xFE, 0x01, 0xF3, 0xFF, 0xE0, 0xFD,
  0xFF, 0xFE, 0x7E, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xC3, 0xFF,
  0xF3, 0xE0, 0x3F, 0xF8, 0x70, 0x03, 0xFC, 0x02, 0x00, 0x3C, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 37, 29, 10, -36 },
  { 43, 17, 16, 29, 6, -40 },
  { 77, 27, 36, 29, 1, -36 },
  { 199, 25, 46, 29, 2, -40 },
  { 343, 28, 38, 29, 1, -37 },
  { 476, 27, 37, 29, 1, -37 },
  { 601, 7, 17, 29, 11, -40 },
  { 616, 18, 51, 29, 6, -41 },
  { 731, 18, 51, 29, 5, -41 },
  { 846, 23, 22, 29, 3, -36 },
  { 910, 25, 26, 29, 2, -28 },
  { 992, 12, 18, 29, 8, -9 },
  { 1019, 15, 6, 29, 7, -18 },
  { 1031, 10, 10, 29, 10, -9 },
  { 1044, 23, 51, 29, 3, -41 },
  { 1191, 25, 38, 29, 2, -37 },
  { 1310, 23, 36, 29, 3, -36 },
  { 1414, 24, 37, 29, 3, -37 },
  { 1525, 23, 38, 29, 3, -37 },
  { 1635, 26, 36, 29, 2, -36 },
  { 1752, 23, 37, 29, 3, -36 },
  { 1859, 23, 37, 29, 3, -36 },
  { 1966, 23, 36, 29, 3, -36 },
  { 2070, 25, 38, 29, 2, -37 },
  { 2189, 23, 37, 29, 3, -37 },
  { 2296, 10, 28, 29, 10, -27 },
  { 2331, 13, 36, 29, 7, -27 },
  { 2390, 24, 24, 29, 3, -27 },
  { 2462, 25, 17, 29, 2, -24 },
  { 2516, 25, 24, 29, 2, -27 },
  { 2591, 21, 38, 29, 4, -37 },
  { 2691, 26, 45, 29, 1, -37 },
  { 2838, 28, 36, 29, 1, -36 },
  { 2964, 24, 36, 29, 3, -36 },
  { 3072, 25, 38, 29, 2, -37 },
  { 3191, 24, 36, 29, 3, -36 },
  { 3299, 23, 36, 29, 4, -36 },
  { 3403, 22, 36, 29, 4, -36 },
  { 3502, 25, 38, 29, 2, -37 },
  { 3621, 24, 36, 29, 3, -36 },
  { 3729, 21, 36, 29, 4, -36 },
  { 3824, 22, 37, 29, 3, -36 },
  { 3926, 26, 36, 29, 3, -36 },
  { 4043, 22, 36, 29, 5, -36 },
  { 4142, 26, 36, 29, 2, -36 },
  { 4259, 23, 36, 29, 3, -36 },
  { 4363, 26, 38, 29, 2, -37 },
  { 4487, 24, 36, 29, 3, -36 },
  { 4595, 26, 47, 29, 2, -37 },
  { 4748, 25, 36, 29, 3, -36 },
  { 4861, 24, 38, 29, 3, -37 },
  { 4975, 25, 36, 29, 2, -36 },
  { 5088, 25, 37, 29, 2, -36 },
  { 5204, 27, 36, 29, 1, -36 },
  { 5326, 26, 36, 29, 2, -36 },
  { 5443, 27, 36, 29, 1, -36 },
  { 5565, 27, 36, 29, 1, -36 },
  { 5687, 23, 36, 29, 3, -36 },
  { 5791, 16, 51, 29, 7, -41 },
  { 5893, 23, 51, 29, 3, -41 },
  { 6040, 16, 51, 29, 6, -41 },
  { 6142, 27, 21, 29, 1, -36 },
  { 6213, 29, 6, 29, 0, 4 },
  { 6235, 12, 10, 29, 9, -40 },
  { 6250, 23, 29, 29, 3, -28 },
  { 6334, 23, 41, 29, 4, -40 },
  { 6452, 24, 29, 29, 3, -28 },
  { 6539, 23, 41, 29, 2, -40 },
  { 6657, 25, 29, 29, 2, -28 },
  { 6748, 26, 40, 29, 3, -40 },
  { 6878, 23, 38, 29, 2, -28 },
  { 6988, 22, 40, 29, 4, -40 },
  { 7098, 25, 41, 29, 2, -40 },
  { 7227, 20, 50, 29, 3, -40 },
  { 7352, 24, 40, 29, 4, -40 },
  { 7472, 25, 41, 29, 2, -40 },
  { 7601, 25, 28, 29, 2, -28 },
  { 7689, 22, 28, 29, 4, -28 },
  { 7766, 25, 29, 29, 2, -28 },
  { 7857, 23, 38, 29, 4, -28 },
  { 7967, 23, 38, 29, 2, -28 },
  { 8077, 20, 28, 29, 6, -28 },
  { 8147, 23, 29, 29, 3, -28 },
  { 8231, 24, 36, 29, 3, -35 },
  { 8339, 21, 28, 29, 4, -27 },
  { 8413, 27, 27, 29, 1, -27 },
  { 8505, 27, 27, 29, 1, -27 },
  { 8597, 27, 27, 29, 1, -27 },
  { 8689, 26, 37, 29, 1, -27 },
  { 8810, 21, 27, 29, 4, -27 },
  { 8881, 21, 51, 29, 4, -41 },
  { 9015, 7, 51, 29, 11, -41 },
  { 9060, 21, 51, 29, 4, -41 },
  { 9194, 26, 10, 29, 2, -20 },
};

const GFXfont UbuntuSansMono_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold52pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUSANSMONO_SEMIBOLD52PT7B_H_
