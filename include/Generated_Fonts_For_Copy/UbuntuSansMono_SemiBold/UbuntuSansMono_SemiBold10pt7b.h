#ifndef _UBUNTUSANSMONO_SEMIBOLD10PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xAC, 0xBA, 0xA0, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x21, 0xD2,
  0x87, 0x06, 0x2E, 0x20, 0xCE, 0xAF, 0x08, 0x39, 0x59, 0x80, 0x72, 0x94,
  0xDF, 0xCD, 0xE0, 0xF0, 0x36, 0x4C, 0x88, 0x84, 0x63, 0x84, 0x22, 0x23,
  0x22, 0x48, 0x4D, 0x6F, 0x21, 0x3E, 0x42, 0x00, 0x6E, 0xA0, 0xE0, 0xF0,
  0x13, 0x22, 0x64, 0x4C, 0x88, 0x72, 0x73, 0xDC, 0xA5, 0xC0, 0x6E, 0xE6,
  0x66, 0xF0, 0xEB, 0x32, 0x48, 0xF0, 0xE3, 0x36, 0x11, 0xE0, 0x19, 0xDE,
  0xBF, 0x8C, 0x60, 0x7A, 0x10, 0xE0, 0x87, 0xC0, 0x7C, 0x8F, 0x99, 0xE0,
  0xF3, 0x26, 0x44, 0x40, 0x72, 0x52, 0xE4, 0xE5, 0xE0, 0xE9, 0x9F, 0x12,
  0xC0, 0xF3, 0xC0, 0x6C, 0x26, 0xA0, 0x3C, 0xC7, 0x10, 0xF8, 0x01, 0xF0,
  0xE1, 0xC7, 0xC8, 0x00, 0xE3, 0x36, 0x44, 0x40, 0x7A, 0x67, 0x5A, 0xD5,
  0x6D, 0x10, 0x30, 0xC5, 0x16, 0x7B, 0x28, 0xC0, 0xE9, 0xBE, 0x99, 0xF0,
  0x3A, 0x31, 0x8C, 0x21, 0xE0, 0xEB, 0x99, 0x9B, 0xE0, 0xF8, 0x8F, 0x88,
  0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x3A, 0x31, 0x9C, 0xA5, 0xE0, 0xCE, 0x73,
  0xFC, 0xE7, 0x20, 0xF4, 0x44, 0x44, 0xF0, 0xF1, 0x11, 0x13, 0xE0, 0x9A,
  0xEC, 0xAB, 0x90, 0x88, 0x88, 0x88, 0xF0, 0x4A, 0xEF, 0x7A, 0xC6, 0x20,
  0x99, 0xDD, 0xBB, 0x90, 0x72, 0x73, 0x9C, 0xA5, 0xC0, 0xE9, 0x9B, 0xC8,
  0x80, 0x72, 0x73, 0x9C, 0xA5, 0xC6, 0x18, 0xEB, 0x9F, 0xAB, 0x90, 0x7A,
  0x10, 0x60, 0x87, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0xCE, 0x73, 0x9C,
  0xA5, 0xE0, 0xCE, 0x52, 0xB5, 0x18, 0xC0, 0x8C, 0x63, 0x7B, 0xAD, 0x20,
  0xCA, 0xCC, 0x67, 0x2F, 0x20, 0xCA, 0x54, 0x62, 0x10, 0x80, 0xF3, 0x24,
  0xC8, 0xF0, 0xFB, 0x6D, 0xB6, 0xDC, 0x88, 0xC4, 0x46, 0x22, 0x31, 0xE4,
  0x92, 0x49, 0x3C, 0x33, 0x97, 0x90, 0xFC, 0xB0, 0xF1, 0xF9, 0xF0, 0x88,
  0x8F, 0x99, 0x9E, 0xF8, 0x88, 0xF0, 0x08, 0x42, 0xFC, 0xE5, 0x2F, 0x7E,
  0x7E, 0x87, 0x80, 0x19, 0x49, 0xF2, 0x10, 0x84, 0x7E, 0x72, 0xB2, 0xCD,
  0xC0, 0x88, 0x8F, 0x99, 0x99, 0x21, 0x01, 0xC2, 0x10, 0x87, 0x24, 0x72,
  0x49, 0xBC, 0x88, 0x8B, 0xEC, 0xA9, 0xE1, 0x08, 0x42, 0x10, 0x87, 0xFD,
  0x6B, 0x18, 0x80, 0xF9, 0x99, 0x90, 0x7E, 0x72, 0x97, 0x00, 0xF9, 0x99,
  0xF8, 0x80, 0x7E, 0x72, 0x97, 0x84, 0x20, 0xF8, 0x88, 0x80, 0xF8, 0x61,
  0xF0, 0x21, 0x3E, 0x42, 0x10, 0xE0, 0x99, 0x99, 0xF0, 0xCA, 0x54, 0x63,
  0x00, 0x8D, 0x6E, 0xB5, 0x80, 0xD9, 0x8C, 0xAC, 0x80, 0xCA, 0x5C, 0x63,
  0x13, 0x80, 0xF2, 0x4C, 0xF0, 0x74, 0x44, 0xCC, 0x44, 0x47, 0xFF, 0xC0,
  0xC6, 0x66, 0x23, 0x66, 0x6C, 0x6C, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 5, 7, 6, 0, -7 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 6, 7, 6, 0, -7 },
  { 22, 5, 7, 6, 0, -7 },
  { 27, 1, 4, 6, 2, -8 },
  { 28, 4, 10, 6, 1, -8 },
  { 33, 4, 10, 6, 1, -8 },
  { 38, 4, 4, 6, 1, -7 },
  { 40, 5, 5, 6, 0, -5 },
  { 44, 3, 4, 6, 1, -2 },
  { 46, 3, 1, 6, 1, -3 },
  { 47, 2, 2, 6, 2, -2 },
  { 48, 4, 10, 6, 1, -8 },
  { 53, 5, 7, 6, 0, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 4, 7, 6, 1, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 5, 7, 6, 0, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 4, 7, 6, 1, -7 },
  { 88, 5, 7, 6, 0, -7 },
  { 93, 4, 7, 6, 1, -7 },
  { 97, 2, 5, 6, 2, -5 },
  { 99, 3, 7, 6, 1, -5 },
  { 102, 4, 5, 6, 1, -5 },
  { 105, 5, 4, 6, 0, -5 },
  { 108, 5, 5, 6, 0, -5 },
  { 112, 4, 7, 6, 1, -7 },
  { 116, 5, 9, 6, 0, -7 },
  { 122, 6, 7, 6, 0, -7 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 5, 7, 6, 0, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 4, 7, 6, 1, -7 },
  { 149, 5, 7, 6, 0, -7 },
  { 154, 5, 7, 6, 0, -7 },
  { 159, 4, 7, 6, 1, -7 },
  { 163, 4, 7, 6, 1, -7 },
  { 167, 4, 7, 6, 1, -7 },
  { 171, 4, 7, 6, 1, -7 },
  { 175, 5, 7, 6, 0, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 5, 7, 6, 0, -7 },
  { 189, 4, 7, 6, 1, -7 },
  { 193, 5, 9, 6, 0, -7 },
  { 199, 4, 7, 6, 1, -7 },
  { 203, 5, 7, 6, 0, -7 },
  { 208, 5, 7, 6, 0, -7 },
  { 213, 5, 7, 6, 0, -7 },
  { 218, 5, 7, 6, 0, -7 },
  { 223, 5, 7, 6, 0, -7 },
  { 228, 5, 7, 6, 0, -7 },
  { 233, 5, 7, 6, 0, -7 },
  { 238, 4, 7, 6, 1, -7 },
  { 242, 3, 10, 6, 1, -8 },
  { 246, 4, 10, 6, 1, -8 },
  { 251, 3, 10, 6, 1, -8 },
  { 255, 5, 4, 6, 0, -7 },
  { 258, 6, 1, 6, 0, 1 },
  { 259, 2, 2, 6, 2, -8 },
  { 260, 4, 5, 6, 1, -5 },
  { 263, 4, 8, 6, 1, -8 },
  { 267, 4, 5, 6, 1, -5 },
  { 270, 5, 8, 6, 0, -8 },
  { 275, 5, 5, 6, 0, -5 },
  { 279, 5, 8, 6, 0, -8 },
  { 284, 5, 7, 6, 0, -5 },
  { 289, 4, 8, 6, 1, -8 },
  { 293, 5, 8, 6, 0, -8 },
  { 298, 3, 10, 6, 1, -8 },
  { 302, 4, 8, 6, 1, -8 },
  { 306, 5, 8, 6, 0, -8 },
  { 311, 5, 5, 6, 0, -5 },
  { 315, 4, 5, 6, 1, -5 },
  { 318, 5, 5, 6, 0, -5 },
  { 322, 4, 7, 6, 1, -5 },
  { 326, 5, 7, 6, 0, -5 },
  { 331, 4, 5, 6, 1, -5 },
  { 334, 4, 5, 6, 1, -5 },
  { 337, 5, 7, 6, 0, -7 },
  { 342, 4, 5, 6, 1, -5 },
  { 345, 5, 5, 6, 0, -5 },
  { 349, 5, 5, 6, 0, -5 },
  { 353, 5, 5, 6, 0, -5 },
  { 357, 5, 7, 6, 0, -5 },
  { 362, 4, 5, 6, 1, -5 },
  { 365, 4, 10, 6, 1, -8 },
  { 370, 1, 10, 6, 2, -8 },
  { 372, 4, 10, 6, 1, -8 },
  { 377, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_SEMIBOLD10PT7B_H_
