#ifndef _UBUNTUSANSMONO_SEMIBOLD19PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0x03, 0xFE, 0xEF, 0xDF, 0x36, 0x64, 0x40, 0x1D,
  0xC6, 0x61, 0x9B, 0xFF, 0xFF, 0xC6, 0xC3, 0x30, 0xCC, 0xFF, 0xFF, 0xF3,
  0x61, 0x98, 0x66, 0x00, 0x18, 0x0C, 0x07, 0x8F, 0xEE, 0x17, 0x03, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xE0, 0x7C, 0x3F, 0xF8, 0xF0, 0x30, 0x18, 0x00,
  0x70, 0xF6, 0x2D, 0x9B, 0x6C, 0xDA, 0x1D, 0x80, 0xC0, 0x3F, 0x1A, 0xCC,
  0x93, 0x25, 0x8F, 0xC3, 0xC0, 0x7C, 0x37, 0x39, 0x9C, 0xC6, 0xC3, 0xC1,
  0xE7, 0xF2, 0xCF, 0x63, 0xB1, 0xDF, 0xF7, 0x98, 0xFF, 0x6C, 0x80, 0x04,
  0x3C, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x10, 0x41, 0xC1, 0xC1, 0xC1, 0x81, 0x83, 0x06, 0x0E,
  0x1C, 0x30, 0x60, 0xC3, 0x86, 0x1C, 0x71, 0xC1, 0x00, 0x1C, 0x0C, 0x3A,
  0xDF, 0xF1, 0xC1, 0xB1, 0xDC, 0x4C, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8,
  0xC0, 0x60, 0x30, 0x18, 0x00, 0x77, 0x73, 0xEC, 0xFF, 0xFE, 0xFF, 0x80,
  0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x00, 0x3E, 0x3F,
  0xB8, 0xD8, 0x7C, 0x1E, 0xCF, 0x77, 0x93, 0xC3, 0xE1, 0xF8, 0xCF, 0xE3,
  0xE0, 0x0C, 0x1E, 0x3F, 0x0D, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x0F, 0xF7, 0xF8, 0x7E, 0x7F, 0x90, 0xC0, 0x60, 0x70, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0xFE, 0x3F, 0x81, 0xC0, 0x60,
  0x71, 0xF0, 0xF8, 0x0E, 0x03, 0x01, 0xC0, 0xDF, 0xEF, 0xE0, 0x07, 0x07,
  0x87, 0xC7, 0xE3, 0x73, 0x3B, 0x9D, 0x8E, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0,
  0x70, 0x7F, 0x7F, 0x60, 0x60, 0x60, 0x7C, 0x7F, 0x07, 0x03, 0x03, 0x03,
  0xFF, 0xFE, 0x0F, 0x1F, 0x8E, 0x0E, 0x0E, 0x07, 0xF3, 0xFD, 0x86, 0xC3,
  0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x7E, 0x3B, 0xB8, 0xD8,
  0x6E, 0x33, 0xF0, 0xF8, 0xCE, 0xC3, 0xE0, 0xF0, 0xFF, 0xE7, 0xE0, 0x7E,
  0x3F, 0xB8, 0xD8, 0x7C, 0x3F, 0x1D, 0xFE, 0x7E, 0x03, 0x03, 0x87, 0x8F,
  0x87, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x77, 0x70, 0x00, 0x07, 0x77, 0x3E,
  0xC0, 0x01, 0x03, 0xCF, 0xDF, 0x0E, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x78, 0x1F, 0x03, 0xF0,
  0x38, 0x7D, 0xF9, 0xE0, 0xC0, 0x00, 0xFD, 0xFC, 0x18, 0x30, 0xE3, 0x8E,
  0x18, 0x00, 0x00, 0xC3, 0xC7, 0x00, 0x3F, 0x39, 0xB0, 0x78, 0x3C, 0xFE,
  0xFE, 0x67, 0x33, 0x99, 0xCC, 0xF7, 0xF9, 0xFC, 0x03, 0x00, 0xFC, 0x1E,
  0x0E, 0x07, 0x81, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x18, 0xC6, 0x7F, 0x9F,
  0xF6, 0x1D, 0x83, 0xE0, 0xC0, 0xFE, 0x7F, 0xB8, 0xDC, 0x6E, 0x37, 0xF3,
  0xFD, 0xC6, 0xE3, 0xF0, 0xF8, 0xFF, 0xEF, 0xE0, 0x3F, 0xBF, 0xD8, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0F, 0xF3, 0xF8, 0xFC,
  0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF9, 0xDF,
  0xCF, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x00, 0x3F, 0xBF, 0x98, 0x1C, 0x0C, 0x06, 0x03, 0x0F, 0x87,
  0xC3, 0xF1, 0xD8, 0xEF, 0xF3, 0xF8, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x38, 0xFF, 0xFF, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x7F, 0x7F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x47, 0xFF, 0xFE, 0xC3,
  0xE3, 0xB1, 0x99, 0xCD, 0xC7, 0xC3, 0xE1, 0xB8, 0xCE, 0x63, 0xB1, 0xD8,
  0x7C, 0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xE3, 0x71, 0xB9, 0xFE, 0xFF, 0x5E, 0xEF, 0x77, 0xB3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xC3, 0xF1, 0xFC, 0xFE, 0x7D, 0xBE,
  0xDF, 0x3F, 0x9F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x38, 0x3E, 0x3F, 0xB8,
  0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0,
  0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x1F, 0x1F, 0xFD, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xC0, 0x38, 0x0F, 0x00, 0x80, 0xFE,
  0x7F, 0xB8, 0xDC, 0x6E, 0x37, 0x3B, 0xFD, 0xF8, 0xEE, 0x73, 0xB8, 0xDC,
  0x7E, 0x18, 0x7F, 0x3F, 0xB8, 0x1C, 0x0E, 0x03, 0xE0, 0xF8, 0x0E, 0x03,
  0x81, 0xE0, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xCF, 0xE7, 0xE0, 0xE0,
  0xD8, 0x36, 0x1D, 0x87, 0x71, 0x8C, 0x63, 0x38, 0xCC, 0x1B, 0x06, 0xC1,
  0xE0, 0x38, 0x0E, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0xCF, 0x77,
  0xAB, 0xF5, 0xFB, 0xF9, 0xFC, 0x6E, 0x30, 0x61, 0xDC, 0x63, 0x38, 0x6C,
  0x1F, 0x03, 0x80, 0xE0, 0x7C, 0x1B, 0x0C, 0xE3, 0x19, 0xC7, 0xE0, 0xC0,
  0xE0, 0xD8, 0x77, 0x18, 0xC6, 0x3B, 0x06, 0xC1, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0x7F, 0x81, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70,
  0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x0E, 0x07, 0x81,
  0xF0, 0xEE, 0x31, 0x9C, 0x7E, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0x47, 0x1E,
  0x20, 0x7E, 0x7F, 0x03, 0x03, 0x7F, 0xFF, 0xC3, 0xC3, 0xFF, 0x7F, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3, 0xFD, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C,
  0x7E, 0x37, 0xFB, 0xF8, 0x3F, 0xBF, 0xB8, 0x1C, 0x0C, 0x06, 0x03, 0x81,
  0xC0, 0x7F, 0x9F, 0xC0, 0x01, 0x03, 0x03, 0x03, 0x03, 0x7F, 0x7F, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0x3E, 0x3F, 0xB8, 0xD8, 0x7F,
  0xFF, 0xFF, 0x01, 0xC0, 0x7F, 0x1F, 0x80, 0x07, 0x0F, 0xCE, 0x27, 0x03,
  0x07, 0xFF, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0x7F, 0x03, 0x03, 0xCF,
  0xFE, 0x38, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x10, 0x1C, 0x0E, 0x02, 0x00, 0x07, 0xC3,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFC, 0x3E, 0x04, 0x1C,
  0x38, 0x20, 0x0F, 0xDF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x6F, 0xFC, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x9D, 0xDC,
  0xFC, 0x7C, 0x3F, 0x1D, 0xCE, 0x77, 0x1B, 0x8E, 0xF8, 0x7C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFC,
  0x3E, 0xFF, 0x7F, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x07, 0x83, 0xC1, 0xE0,
  0xC0, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3E,
  0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x0F, 0xC6, 0x7F, 0x1F, 0x00, 0xFE,
  0x7F, 0xB8, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0x7F, 0x38, 0x1C,
  0x0E, 0x07, 0x00, 0x3F, 0x7F, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F,
  0x7F, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3F, 0x7F, 0xE0, 0x60, 0x7C, 0x1F, 0x07, 0x83, 0xFF,
  0xFE, 0x38, 0x1C, 0x0E, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xF1, 0xF8, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x63,
  0x7F, 0x3F, 0xE0, 0xD8, 0x77, 0x18, 0xC6, 0x33, 0x8E, 0xC1, 0xB0, 0x78,
  0x0E, 0x03, 0x00, 0xC0, 0xF0, 0x36, 0xCD, 0xBB, 0x6E, 0xDB, 0xB7, 0xAD,
  0xEE, 0x73, 0x8C, 0x60, 0x61, 0xCC, 0x63, 0xB0, 0x7C, 0x0E, 0x03, 0x81,
  0xF0, 0xCE, 0x71, 0xB8, 0x70, 0xC3, 0xF1, 0xD8, 0xCC, 0x67, 0x71, 0xB0,
  0xD8, 0x7C, 0x1C, 0x0E, 0x07, 0x17, 0x0F, 0x02, 0x00, 0x7F, 0x7F, 0x06,
  0x0E, 0x1C, 0x38, 0x30, 0x70, 0xFF, 0xFF, 0x0F, 0x1F, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xF0, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF8,
  0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x07, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x1C, 0xF8, 0xE0, 0xF9, 0xFF, 0xE3, 0xC0,
};

const GFXglyph UbuntuSansMono_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 7, 5, 11, 2, -14 },
  { 11, 10, 13, 11, 0, -13 },
  { 28, 9, 17, 11, 1, -15 },
  { 48, 10, 13, 11, 0, -13 },
  { 65, 9, 13, 11, 1, -13 },
  { 80, 3, 6, 11, 4, -14 },
  { 83, 7, 19, 11, 2, -15 },
  { 100, 7, 19, 11, 2, -15 },
  { 117, 9, 8, 11, 1, -13 },
  { 126, 9, 9, 11, 1, -10 },
  { 137, 4, 6, 11, 3, -3 },
  { 140, 5, 3, 11, 3, -7 },
  { 142, 3, 3, 11, 4, -3 },
  { 144, 9, 19, 11, 1, -15 },
  { 166, 9, 13, 11, 1, -13 },
  { 181, 9, 13, 11, 1, -13 },
  { 196, 9, 13, 11, 1, -13 },
  { 211, 9, 13, 11, 1, -13 },
  { 226, 9, 13, 11, 1, -13 },
  { 241, 8, 13, 11, 1, -13 },
  { 254, 9, 13, 11, 1, -13 },
  { 269, 9, 13, 11, 1, -13 },
  { 284, 9, 13, 11, 1, -13 },
  { 299, 9, 13, 11, 1, -13 },
  { 314, 3, 10, 11, 4, -10 },
  { 318, 4, 13, 11, 3, -10 },
  { 325, 9, 9, 11, 1, -10 },
  { 336, 9, 6, 11, 1, -9 },
  { 343, 9, 9, 11, 1, -10 },
  { 354, 7, 13, 11, 2, -13 },
  { 366, 9, 16, 11, 1, -13 },
  { 384, 10, 13, 11, 0, -13 },
  { 401, 9, 13, 11, 1, -13 },
  { 416, 9, 13, 11, 1, -13 },
  { 431, 9, 13, 11, 1, -13 },
  { 446, 8, 13, 11, 2, -13 },
  { 459, 7, 13, 11, 2, -13 },
  { 471, 9, 13, 11, 1, -13 },
  { 486, 9, 13, 11, 1, -13 },
  { 501, 8, 13, 11, 1, -13 },
  { 514, 8, 13, 11, 1, -13 },
  { 527, 9, 13, 11, 1, -13 },
  { 542, 8, 13, 11, 2, -13 },
  { 555, 9, 13, 11, 1, -13 },
  { 570, 9, 13, 11, 1, -13 },
  { 585, 9, 13, 11, 1, -13 },
  { 600, 9, 13, 11, 1, -13 },
  { 615, 9, 17, 11, 1, -13 },
  { 635, 9, 13, 11, 1, -13 },
  { 650, 9, 13, 11, 1, -13 },
  { 665, 9, 13, 11, 1, -13 },
  { 680, 9, 13, 11, 1, -13 },
  { 695, 10, 13, 11, 0, -13 },
  { 712, 9, 13, 11, 1, -13 },
  { 727, 10, 13, 11, 0, -13 },
  { 744, 10, 13, 11, 0, -13 },
  { 761, 9, 13, 11, 1, -13 },
  { 776, 5, 19, 11, 3, -15 },
  { 788, 9, 19, 11, 1, -15 },
  { 810, 6, 19, 11, 2, -15 },
  { 825, 10, 7, 11, 0, -13 },
  { 834, 10, 3, 11, 0, 1 },
  { 838, 5, 4, 11, 3, -15 },
  { 841, 8, 10, 11, 1, -10 },
  { 851, 9, 15, 11, 1, -15 },
  { 868, 9, 10, 11, 1, -10 },
  { 880, 8, 15, 11, 1, -15 },
  { 895, 9, 10, 11, 1, -10 },
  { 907, 9, 15, 11, 1, -15 },
  { 924, 8, 14, 11, 1, -10 },
  { 938, 8, 15, 11, 1, -15 },
  { 953, 9, 15, 11, 1, -15 },
  { 970, 7, 19, 11, 1, -15 },
  { 987, 9, 15, 11, 1, -15 },
  { 1004, 9, 15, 11, 1, -15 },
  { 1021, 9, 10, 11, 1, -10 },
  { 1033, 8, 10, 11, 1, -10 },
  { 1043, 9, 10, 11, 1, -10 },
  { 1055, 9, 14, 11, 1, -10 },
  { 1071, 8, 14, 11, 1, -10 },
  { 1085, 8, 10, 11, 2, -10 },
  { 1095, 8, 10, 11, 1, -10 },
  { 1105, 9, 13, 11, 1, -13 },
  { 1120, 8, 10, 11, 1, -10 },
  { 1130, 10, 10, 11, 0, -10 },
  { 1143, 10, 10, 11, 0, -10 },
  { 1156, 10, 10, 11, 0, -10 },
  { 1169, 9, 14, 11, 1, -10 },
  { 1185, 8, 10, 11, 1, -10 },
  { 1195, 8, 19, 11, 1, -15 },
  { 1214, 3, 19, 11, 4, -15 },
  { 1222, 8, 19, 11, 1, -15 },
  { 1241, 9, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_SEMIBOLD19PT7B_H_
