#ifndef _UBUNTUSANSMONO_SEMIBOLD23PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0x27, 0xF7, 0xEF, 0x9F, 0x3E,
  0x3C, 0x78, 0xC0, 0x1C, 0xE3, 0x98, 0x63, 0x0C, 0xEF, 0xFF, 0xFF, 0xCE,
  0x61, 0x8C, 0x33, 0x86, 0x73, 0xFF, 0xFF, 0xF6, 0x30, 0xC6, 0x19, 0xC7,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0xE7, 0xFC, 0xE0, 0xB8, 0x03, 0x80,
  0x7C, 0x07, 0xE0, 0x7F, 0x01, 0xE0, 0x1E, 0x01, 0xD0, 0x3F, 0xFE, 0xFF,
  0xC7, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x78, 0x3B, 0xE1, 0xB3, 0x19, 0x99,
  0x8C, 0xCC, 0x36, 0xC1, 0xEE, 0x06, 0x60, 0x06, 0x60, 0x7F, 0x83, 0x6C,
  0x33, 0x33, 0x99, 0x98, 0xC9, 0x87, 0xDC, 0x1E, 0x3E, 0x0F, 0xE1, 0xCE,
  0x31, 0xC6, 0x30, 0xEE, 0x0F, 0x81, 0xE6, 0x7C, 0xFD, 0xDB, 0x1F, 0x61,
  0xEC, 0x39, 0xC7, 0xBF, 0xF9, 0xF7, 0xFF, 0xFF, 0xD0, 0x06, 0x1C, 0x71,
  0xC7, 0x0E, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x70,
  0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0x60, 0xF0, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1C,
  0x38, 0xF0, 0x60, 0x0E, 0x01, 0xC1, 0x39, 0x3A, 0xEF, 0xFE, 0x1C, 0x06,
  0xC1, 0xDC, 0x7B, 0xC2, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1,
  0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38, 0xF3,
  0xCF, 0x1C, 0xEF, 0x10, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0xEE, 0x0F,
  0xC1, 0xFB, 0x3F, 0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x76, 0x1C, 0xE3,
  0x8F, 0xE0, 0xF8, 0x07, 0x01, 0xE0, 0xFC, 0x7F, 0x87, 0x70, 0x8E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFB,
  0xFF, 0x3F, 0x1F, 0xF1, 0x8F, 0x20, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F,
  0x1F, 0xF1, 0x8F, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xE0, 0xF8, 0x1F, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x1C, 0x87, 0xBF, 0xF7, 0xF8, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xC1, 0xD8, 0x73, 0x0C, 0x63, 0x8C, 0x61, 0x9C, 0x33, 0xFF,
  0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xCF, 0xF3, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0xE1, 0xFE, 0x07, 0xC0, 0x70, 0x1C, 0x03, 0x01, 0xD0,
  0xFF, 0xFB, 0xFC, 0x03, 0xC1, 0xF8, 0x7E, 0x1E, 0x07, 0x00, 0xE0, 0x1F,
  0xC7, 0xFE, 0xF1, 0xDC, 0x1F, 0x83, 0xF0, 0x77, 0x0C, 0xE3, 0x8F, 0xF0,
  0xF8, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3F,
  0x8F, 0xF9, 0xC7, 0x30, 0x6E, 0x0C, 0xE3, 0x9E, 0x71, 0xFC, 0x3F, 0x8E,
  0x7B, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xDF, 0xF1, 0xFC, 0x3F, 0x0F, 0xF1,
  0xC7, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3B, 0x8F, 0x7F, 0xE3, 0xF8, 0x07,
  0x01, 0xE0, 0x78, 0x7E, 0x1F, 0x83, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x00,
  0x77, 0xFE, 0xE0, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x39, 0xF7, 0xCF,
  0x18, 0xEF, 0x30, 0x00, 0x40, 0x7C, 0x3F, 0x9F, 0x8F, 0xC1, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3C, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x40, 0x1F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xC1, 0xF9, 0xFC, 0xFE, 0x1E, 0x01, 0x00, 0x00, 0xFE, 0x7F, 0x91,
  0xE0, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0x81,
  0xE0, 0xF0, 0x78, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x7E, 0x07, 0x8F, 0xF3,
  0xFE, 0x73, 0xCC, 0x7B, 0x8F, 0x71, 0xE6, 0x3C, 0xE7, 0x9F, 0xF8, 0xFB,
  0x00, 0x70, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1B,
  0x01, 0xDC, 0x0E, 0xE0, 0x67, 0x03, 0x18, 0x38, 0xE1, 0xC7, 0x0F, 0xF8,
  0xFF, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x0F, 0xFF, 0x1F, 0xF3, 0x8F,
  0x70, 0xEE, 0x1D, 0xC3, 0xBF, 0xE7, 0xF8, 0xFF, 0xDC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xFF, 0xF7, 0xF8, 0x0F, 0xC7, 0xFD, 0xE1, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x8F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF3, 0x9F, 0x70, 0xEE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xCF, 0xBF,
  0xE7, 0xF0, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF3, 0xFC,
  0xFF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x1F, 0xC7, 0xFD, 0xE1, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xF1, 0xCF,
  0xF8, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xD8, 0xFF,
  0xF9, 0xFC, 0xE0, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFE, 0x0E, 0xF0, 0xE7, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE0,
  0xEE, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0x60, 0xDE,
  0x3B, 0xC7, 0x78, 0xFD, 0x37, 0xB6, 0xF6, 0xDE, 0x73, 0xCE, 0x79, 0xCF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xFE, 0x1F, 0xC3,
  0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x8F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E,
  0xE3, 0x9F, 0xE1, 0xF8, 0xFE, 0x3F, 0xEC, 0x7F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xFF, 0xBF, 0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F, 0xF1, 0xF8, 0x0E, 0x00,
  0xE0, 0x1F, 0x80, 0xF0, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3,
  0xB8, 0x77, 0x1E, 0xFF, 0x9F, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8,
  0x3F, 0x07, 0x3F, 0xCF, 0xF9, 0xC2, 0x70, 0x0E, 0x00, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0E, 0x83, 0xBF, 0xF3, 0xFC,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F, 0xF1, 0xFC, 0xE0, 0x7B, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x07, 0x18, 0x70, 0xE3, 0x87, 0x1C, 0x18, 0xC0, 0xC6,
  0x07, 0x70, 0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF3, 0x9E, 0x73, 0xCE, 0x7B, 0x6F,
  0x6D, 0xED, 0xBF, 0x17, 0xE3, 0x9C, 0x73, 0x06, 0x70, 0x77, 0x06, 0x38,
  0xE1, 0x9C, 0x1D, 0xC0, 0xF8, 0x0F, 0x80, 0x70, 0x0F, 0x80, 0xF8, 0x1D,
  0xC1, 0xDC, 0x38, 0xE3, 0x8E, 0x70, 0x7F, 0x07, 0xF0, 0x7B, 0x83, 0x9C,
  0x1C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xB0, 0x0F, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xCF,
  0xF8, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xFF,
  0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC0, 0x0E, 0x03, 0xE0, 0x7C, 0x1D,
  0xC3, 0xB8, 0xE3, 0xBC, 0x7F, 0x07, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x43, 0x3C, 0x70, 0x80, 0x7F, 0x8F, 0xF4, 0x1C, 0x07, 0x00, 0xCF, 0xF7,
  0xFF, 0x83, 0xE0, 0xFC, 0x37, 0xFC, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xF3, 0xFE, 0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x8E, 0xFF, 0xBF, 0x80, 0x1F, 0xE7, 0xF9, 0xE1, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x04, 0xFF, 0x8F, 0xF0, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x73, 0xFD, 0xFF, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xC7, 0x7F, 0xCF, 0xF0, 0x1F, 0x8F,
  0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0F, 0x09,
  0xFF, 0x0F, 0xE0, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0,
  0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xDF, 0xF7, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xDF, 0xF3, 0xFC, 0x07, 0x01, 0xD0, 0xFF,
  0xFB, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x71, 0x0F, 0xE0, 0xFC,
  0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00, 0x01, 0xFE, 0xFF, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xEC, 0x77, 0xF7,
  0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0x9E, 0xE7,
  0x3B, 0x8F, 0xC3, 0xE0, 0xFC, 0x3B, 0x8E, 0x73, 0x8E, 0xE3, 0xF8, 0x70,
  0xFC, 0x1F, 0x83, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x71, 0x0F, 0xE0,
  0xFC, 0xFF, 0xDF, 0xFF, 0x33, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFF, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3F, 0x8F, 0xF9, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x39, 0xFF, 0x1F,
  0x80, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xEF, 0xFB, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0xDF, 0xF7,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0x77, 0xFC, 0xFF,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x7F, 0xFF, 0xEF, 0x0B, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3F, 0xDF, 0xF7, 0x09,
  0xC0, 0x78, 0x0F, 0xC1, 0xF8, 0x0F, 0x01, 0xD8, 0x77, 0xFF, 0xFE, 0x04,
  0x03, 0x80, 0x70, 0x0E, 0x0F, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x47, 0xF8, 0x7F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE3, 0xF9, 0xFF, 0xEF, 0xF0, 0xF0,
  0x77, 0x07, 0x70, 0x73, 0x8E, 0x38, 0xE3, 0x8C, 0x1D, 0xC1, 0xDC, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x70, 0xE0, 0x3F, 0x01, 0x99, 0xCC, 0xCE, 0x66,
  0x73, 0x33, 0x99, 0xB6, 0xCD, 0xBE, 0x7D, 0xE1, 0xC7, 0x0E, 0x38, 0x71,
  0xC0, 0xE0, 0xEE, 0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x1C, 0x07, 0xC0, 0xFC,
  0x3B, 0x8E, 0x3B, 0x87, 0xF0, 0x70, 0xE0, 0xFC, 0x1D, 0xC3, 0x38, 0xE7,
  0x1C, 0x73, 0x8E, 0x60, 0xDC, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x38, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xC1, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x3F, 0xFF, 0xF0, 0x0F, 0x8F, 0xC7, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x3C, 0x1E, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x81, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x01, 0xE0, 0xF0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x8F, 0xC7, 0xC0, 0x78, 0x6F, 0xCF, 0xFF, 0xE3, 0xE0,
};

const GFXglyph UbuntuSansMono_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 16, 13, 4, -16 },
  { 9, 7, 6, 13, 3, -17 },
  { 15, 11, 16, 13, 1, -16 },
  { 37, 11, 21, 13, 1, -18 },
  { 66, 13, 16, 13, 0, -16 },
  { 92, 11, 16, 13, 1, -16 },
  { 114, 3, 7, 13, 5, -17 },
  { 117, 7, 22, 13, 3, -18 },
  { 137, 8, 22, 13, 2, -18 },
  { 159, 11, 10, 13, 1, -16 },
  { 173, 11, 12, 13, 1, -13 },
  { 190, 6, 8, 13, 3, -4 },
  { 196, 7, 3, 13, 3, -8 },
  { 199, 5, 4, 13, 4, -4 },
  { 202, 11, 22, 13, 1, -18 },
  { 233, 11, 16, 13, 1, -16 },
  { 255, 11, 16, 13, 1, -16 },
  { 277, 11, 16, 13, 1, -16 },
  { 299, 11, 16, 13, 1, -16 },
  { 321, 11, 16, 13, 1, -16 },
  { 343, 10, 16, 13, 1, -16 },
  { 363, 11, 16, 13, 1, -16 },
  { 385, 11, 16, 13, 1, -16 },
  { 407, 11, 16, 13, 1, -16 },
  { 429, 11, 16, 13, 1, -16 },
  { 451, 5, 12, 13, 4, -12 },
  { 459, 6, 16, 13, 3, -12 },
  { 471, 11, 11, 13, 1, -12 },
  { 487, 11, 7, 13, 1, -10 },
  { 497, 11, 11, 13, 1, -12 },
  { 513, 9, 16, 13, 2, -16 },
  { 531, 11, 19, 13, 1, -16 },
  { 558, 13, 16, 13, 0, -16 },
  { 584, 11, 16, 13, 1, -16 },
  { 606, 11, 16, 13, 1, -16 },
  { 628, 11, 16, 13, 1, -16 },
  { 650, 10, 16, 13, 2, -16 },
  { 670, 9, 16, 13, 2, -16 },
  { 688, 11, 16, 13, 1, -16 },
  { 710, 11, 16, 13, 1, -16 },
  { 732, 9, 16, 13, 2, -16 },
  { 750, 10, 16, 13, 1, -16 },
  { 770, 12, 16, 13, 1, -16 },
  { 794, 10, 16, 13, 2, -16 },
  { 814, 11, 16, 13, 1, -16 },
  { 836, 11, 16, 13, 1, -16 },
  { 858, 11, 16, 13, 1, -16 },
  { 880, 10, 16, 13, 2, -16 },
  { 900, 11, 20, 13, 1, -16 },
  { 928, 11, 16, 13, 1, -16 },
  { 950, 11, 16, 13, 1, -16 },
  { 972, 11, 16, 13, 1, -16 },
  { 994, 11, 16, 13, 1, -16 },
  { 1016, 13, 16, 13, 0, -16 },
  { 1042, 11, 16, 13, 1, -16 },
  { 1064, 12, 16, 13, 0, -16 },
  { 1088, 13, 16, 13, 0, -16 },
  { 1114, 11, 16, 13, 1, -16 },
  { 1136, 7, 22, 13, 3, -18 },
  { 1156, 11, 22, 13, 1, -18 },
  { 1187, 7, 22, 13, 3, -18 },
  { 1207, 11, 9, 13, 1, -16 },
  { 1220, 13, 2, 13, 0, 2 },
  { 1224, 5, 5, 13, 4, -18 },
  { 1228, 10, 12, 13, 1, -12 },
  { 1243, 10, 18, 13, 2, -18 },
  { 1266, 11, 12, 13, 1, -12 },
  { 1283, 10, 18, 13, 1, -18 },
  { 1306, 11, 12, 13, 1, -12 },
  { 1323, 12, 18, 13, 1, -18 },
  { 1350, 10, 16, 13, 1, -12 },
  { 1370, 9, 18, 13, 2, -18 },
  { 1391, 11, 18, 13, 1, -18 },
  { 1416, 9, 22, 13, 1, -18 },
  { 1441, 10, 18, 13, 2, -18 },
  { 1464, 11, 18, 13, 1, -18 },
  { 1489, 11, 12, 13, 1, -12 },
  { 1506, 9, 12, 13, 2, -12 },
  { 1520, 11, 12, 13, 1, -12 },
  { 1537, 10, 16, 13, 2, -12 },
  { 1557, 10, 16, 13, 1, -12 },
  { 1577, 10, 12, 13, 2, -12 },
  { 1592, 10, 12, 13, 1, -12 },
  { 1607, 11, 16, 13, 1, -16 },
  { 1629, 9, 12, 13, 2, -12 },
  { 1643, 12, 12, 13, 0, -12 },
  { 1661, 13, 12, 13, 0, -12 },
  { 1681, 11, 12, 13, 1, -12 },
  { 1698, 11, 16, 13, 1, -12 },
  { 1720, 9, 12, 13, 2, -12 },
  { 1734, 9, 22, 13, 2, -18 },
  { 1759, 3, 22, 13, 5, -18 },
  { 1768, 9, 22, 13, 2, -18 },
  { 1793, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_SEMIBOLD23PT7B_H_
