#ifndef _UBUNTUSANSMONO_SEMIBOLD71PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87,
  0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC1, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xF0, 0x3F,
  0xF0, 0x00, 0x0C, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x38, 0x00,
  0x01, 0xFF, 0x8F, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF1, 0xFF, 0xE0, 0x00, 0x3F, 0x8F, 0xFF, 0xC0,
  0x00, 0xFC, 0x7F, 0xFF, 0x00, 0x07, 0xF1, 0xFD, 0xFE, 0x00, 0x3F, 0x87,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0xFC,
  0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x07, 0xF7, 0xF8, 0xFE,
  0x00, 0x1F, 0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x00, 0x7F,
  0xF8, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF1, 0xFF,
  0xE0, 0x00, 0x1F, 0xCF, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xFF, 0x00, 0x03,
  0xF1, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0x00, 0xFE, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0x3F, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x7E,
  0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x7E, 0x00, 0x1F, 0xFF, 0xE3, 0xF8, 0x00,
  0x3F, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0xE3,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x01, 0xFF,
  0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFE, 0xFF, 0xC3,
  0xF8, 0x3F, 0xC7, 0xFE, 0x3F, 0x87, 0xF8, 0x3F, 0xF3, 0xF8, 0x7F, 0x81,
  0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x0F,
  0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0x87,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0xE3, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x20, 0x0F, 0xF0, 0x00,
  0x3C, 0x07, 0xE0, 0x1C, 0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0xC7, 0xE1, 0xFC,
  0x7F, 0xE7, 0xE7, 0xFE, 0x7F, 0xFB, 0xDF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x07, 0x01, 0xFE,
  0xFF, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0x87,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xC1, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x03,
  0xF0, 0x7F, 0xFF, 0xC0, 0x30, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFB, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1E, 0x03, 0xFC, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF9, 0xFF, 0xF8,
  0x3F, 0x80, 0x3F, 0xF8, 0x3E, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x0F, 0xFC,
  0x08, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xF8, 0x1F, 0x00, 0x3F, 0xF8,
  0x18, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x60, 0x00, 0x0F, 0xFE,
  0x7C, 0x00, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x20, 0x00, 0x07,
  0xFE, 0x3C, 0x00, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0,
  0x01, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x07,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01,
  0xFE, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x78, 0x00, 0x00,
  0x60, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xFE, 0x38, 0x00, 0x7F, 0xE2, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x7F,
  0x00, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFF,
  0xBF, 0x80, 0xFF, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF,
  0x07, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F,
  0xFF, 0x83, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFE, 0x0F, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0x07,
  0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xFF,
  0xEF, 0xE0, 0x7F, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F,
  0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xCF, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xC0,
  0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x3F,
  0xF3, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0,
  0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE7, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0x07, 0xFF, 0x80, 0x00, 0xC1, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xC0, 0xFF, 0xF8, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x1F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0x07, 0xFF,
  0x00, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC4, 0x00, 0x03, 0xFE, 0x3C,
  0x00, 0x1F, 0xF8, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xDF, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xE0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xEF, 0xC3,
  0xF7, 0xC0, 0x7E, 0xFC, 0x3F, 0x7E, 0x07, 0xEF, 0xC3, 0xF7, 0xE0, 0x7C,
  0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7F, 0x1F, 0x9F, 0x8F, 0xC7,
  0xF1, 0xF9, 0xF8, 0xFC, 0x7F, 0x1F, 0xBF, 0x0F, 0xC7, 0xF0, 0xFF, 0xF0,
  0xFC, 0x7F, 0x0F, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xF0, 0xFE, 0x7F, 0x0F,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xE0, 0xFE, 0x7F, 0x07, 0xFE, 0x0F, 0xE7,
  0xF0, 0x7F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0,
  0xFE, 0x7F, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0x3F, 0x80, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF,
  0x1F, 0xC0, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF,
  0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF,
  0x00, 0xFE, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x70, 0x7F, 0xC0,
  0x00, 0x10, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x20, 0x00, 0x03, 0xFF, 0x38, 0x00, 0x03, 0xFF, 0x7E, 0x00,
  0x0F, 0xFE, 0x7F, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x03, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xC1, 0xFE, 0x7F,
  0x03, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0xC1, 0xFE, 0x7F, 0x07, 0xFE, 0x1F,
  0xE7, 0xF0, 0x7F, 0xE1, 0xFE, 0x7F, 0x0F, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF,
  0xF1, 0xFE, 0x7F, 0x0F, 0xFF, 0x1F, 0xC7, 0xF0, 0xFF, 0xF1, 0xFC, 0x7F,
  0x1F, 0x9F, 0x1F, 0xC7, 0xF1, 0xF9, 0xF9, 0xFC, 0x7F, 0x1F, 0x9F, 0x9F,
  0xC3, 0xF3, 0xF0, 0xF9, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x7E, 0x07, 0xCF, 0xC3, 0xF7, 0xE0, 0x7E, 0xFC, 0x3F,
  0x7E, 0x07, 0xEF, 0xC3, 0xF7, 0xC0, 0x7E, 0xFC, 0x3F, 0xFC, 0x03, 0xEF,
  0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x04, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x40, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0xFE, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80,
  0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x04, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x1F,
  0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x83, 0xFF, 0xF0, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF3, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x07,
  0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFD,
  0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x38, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x08, 0x00, 0x3F, 0xF0, 0x0E, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x40, 0x00,
  0xFF, 0x8F, 0x00, 0x3F, 0xF3, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xC3, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x08, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xF9, 0xFF, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0x00, 0x02, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x40, 0x00, 0x07, 0xFD, 0xC0, 0x00,
  0x1F, 0xF7, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x02, 0x00, 0x7F, 0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x7F,
  0x9F, 0xE0, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFF, 0x07, 0xF0, 0xFE, 0x0F,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC,
  0x3F, 0x83, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xE1, 0xF8, 0x3F, 0x8F, 0xDF, 0xCF, 0xE0,
  0x7E, 0x3F, 0x3F, 0x3F, 0x81, 0xFC, 0xFC, 0xFC, 0xFE, 0x07, 0xF7, 0xE3,
  0xFB, 0xF8, 0x1F, 0xDF, 0x87, 0xEF, 0xE0, 0x7F, 0x7E, 0x1F, 0xBF, 0x01,
  0xFF, 0xF0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x04, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xC0,
  0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF,
  0xFF, 0xF3, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xCF, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0x00, 0x7F,
  0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x20,
  0x00, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 12, 50, 40, 14, -49 },
  { 76, 24, 22, 40, 8, -54 },
  { 142, 36, 49, 40, 2, -49 },
  { 363, 34, 63, 40, 3, -55 },
  { 631, 38, 51, 40, 1, -50 },
  { 874, 36, 51, 40, 2, -50 },
  { 1104, 10, 23, 40, 15, -54 },
  { 1133, 24, 69, 40, 8, -56 },
  { 1340, 25, 69, 40, 7, -56 },
  { 1556, 32, 30, 40, 4, -49 },
  { 1676, 34, 36, 40, 3, -39 },
  { 1829, 17, 25, 40, 11, -13 },
  { 1883, 20, 9, 40, 10, -25 },
  { 1906, 14, 14, 40, 13, -13 },
  { 1931, 32, 69, 40, 4, -56 },
  { 2207, 34, 51, 40, 3, -50 },
  { 2424, 32, 49, 40, 4, -49 },
  { 2620, 32, 50, 40, 4, -50 },
  { 2820, 32, 51, 40, 4, -50 },
  { 3024, 36, 49, 40, 2, -49 },
  { 3245, 32, 50, 40, 3, -49 },
  { 3445, 32, 51, 40, 4, -50 },
  { 3649, 32, 49, 40, 4, -49 },
  { 3845, 34, 51, 40, 3, -50 },
  { 4062, 32, 50, 40, 4, -50 },
  { 4262, 14, 39, 40, 13, -38 },
  { 4331, 17, 50, 40, 10, -38 },
  { 4438, 33, 33, 40, 4, -37 },
  { 4575, 34, 22, 40, 3, -32 },
  { 4669, 34, 34, 40, 3, -37 },
  { 4814, 28, 51, 40, 6, -50 },
  { 4993, 35, 61, 40, 2, -50 },
  { 5260, 38, 49, 40, 1, -49 },
  { 5493, 33, 51, 40, 4, -50 },
  { 5704, 34, 51, 40, 3, -50 },
  { 5921, 33, 51, 40, 4, -50 },
  { 6132, 31, 49, 40, 6, -49 },
  { 6322, 29, 49, 40, 6, -49 },
  { 6500, 34, 51, 40, 3, -50 },
  { 6717, 32, 49, 40, 4, -49 },
  { 6913, 30, 49, 40, 5, -49 },
  { 7097, 30, 50, 40, 4, -49 },
  { 7285, 35, 49, 40, 4, -49 },
  { 7500, 31, 49, 40, 6, -49 },
  { 7690, 36, 49, 40, 2, -49 },
  { 7911, 32, 49, 40, 4, -49 },
  { 8107, 36, 51, 40, 2, -50 },
  { 8337, 32, 50, 40, 5, -50 },
  { 8537, 36, 63, 40, 2, -50 },
  { 8821, 34, 50, 40, 4, -50 },
  { 9034, 32, 51, 40, 4, -50 },
  { 9238, 35, 49, 40, 2, -49 },
  { 9453, 33, 50, 40, 3, -49 },
  { 9660, 38, 49, 40, 1, -49 },
  { 9893, 36, 49, 40, 2, -49 },
  { 10114, 38, 49, 40, 1, -49 },
  { 10347, 38, 49, 40, 1, -49 },
  { 10580, 32, 49, 40, 4, -49 },
  { 10776, 21, 69, 40, 10, -56 },
  { 10958, 32, 69, 40, 4, -56 },
  { 11234, 21, 69, 40, 9, -56 },
  { 11416, 36, 28, 40, 2, -49 },
  { 11542, 38, 8, 40, 1, 5 },
  { 11580, 17, 14, 40, 12, -55 },
  { 11610, 31, 39, 40, 4, -38 },
  { 11762, 32, 56, 40, 5, -55 },
  { 11986, 33, 39, 40, 4, -38 },
  { 12147, 32, 56, 40, 2, -55 },
  { 12371, 34, 39, 40, 3, -38 },
  { 12537, 36, 55, 40, 3, -55 },
  { 12785, 32, 51, 40, 3, -38 },
  { 12989, 30, 55, 40, 5, -55 },
  { 13196, 34, 56, 40, 3, -55 },
  { 13434, 27, 68, 40, 4, -55 },
  { 13664, 33, 55, 40, 5, -55 },
  { 13891, 34, 56, 40, 3, -55 },
  { 14129, 34, 38, 40, 3, -38 },
  { 14291, 30, 38, 40, 5, -38 },
  { 14434, 34, 39, 40, 3, -38 },
  { 14600, 32, 51, 40, 5, -38 },
  { 14804, 32, 51, 40, 3, -38 },
  { 15008, 28, 38, 40, 8, -38 },
  { 15141, 30, 39, 40, 5, -38 },
  { 15288, 34, 49, 40, 3, -48 },
  { 15497, 30, 38, 40, 5, -37 },
  { 15640, 37, 37, 40, 1, -37 },
  { 15812, 38, 37, 40, 1, -37 },
  { 15988, 36, 37, 40, 2, -37 },
  { 16155, 35, 50, 40, 2, -37 },
  { 16374, 29, 37, 40, 5, -37 },
  { 16509, 30, 69, 40, 5, -56 },
  { 16768, 8, 69, 40, 16, -56 },
  { 16837, 29, 69, 40, 5, -56 },
  { 17088, 36, 14, 40, 2, -28 },
};

const GFXfont UbuntuSansMono_SemiBold71pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold71pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold71pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _UBUNTUSANSMONO_SEMIBOLD71PT7B_H_
