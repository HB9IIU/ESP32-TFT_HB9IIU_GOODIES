#ifndef _UBUNTUSANSMONO_SEMIBOLD44PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1E, 0xF8,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xC0, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x00, 0xF0,
  0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFC, 0x0F, 0x1F, 0x80, 0x08, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0xC0,
  0x07, 0xE7, 0xC0, 0x7F, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x1F, 0x3F, 0xE0, 0x1E, 0x79, 0xE0, 0x3C, 0x79, 0xE0, 0x7C, 0x70, 0xE0,
  0x78, 0x70, 0xF0, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xF1, 0xE0, 0x70, 0xE3,
  0xC0, 0x79, 0xE3, 0xC0, 0x7F, 0xE7, 0x80, 0x3F, 0xEF, 0x00, 0x3F, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x79,
  0xFC, 0x00, 0xFB, 0xFE, 0x00, 0xF3, 0xFE, 0x01, 0xE7, 0x8F, 0x01, 0xE7,
  0x8F, 0x03, 0xC7, 0x8F, 0x07, 0x87, 0x8F, 0x07, 0x87, 0x8F, 0x0F, 0x07,
  0x8F, 0x1E, 0x07, 0x8F, 0x1E, 0x07, 0x8F, 0x3C, 0x03, 0xFE, 0x7C, 0x03,
  0xFE, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x01, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1F, 0x00,
  0x7C, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x18, 0x07, 0xF8, 0x3C, 0x1F, 0xF0, 0x78, 0x7F, 0xF1, 0xF1, 0xFB,
  0xF3, 0xE3, 0xE3, 0xF7, 0xC7, 0x83, 0xFF, 0x1F, 0x03, 0xFE, 0x3E, 0x03,
  0xFC, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0x8F, 0x81, 0xFE, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x38, 0xE0,
  0x00, 0x08, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x60, 0x20, 0x00, 0xE0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x38, 0xF0, 0x67, 0xC7, 0x1E, 0x7F, 0x77, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xE0,
  0x07, 0xDF, 0x00, 0xFD, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0x07,
  0x80, 0x30, 0x60, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x07,
  0xC1, 0xE0, 0xFB, 0xFC, 0xFE, 0x3F, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xF9,
  0xFC, 0x7C, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x83, 0xF1,
  0xF8, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF0, 0x03, 0xFF, 0x87, 0x1F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF,
  0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC7, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7E,
  0x03, 0xF3, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xF7, 0xC0, 0x7C, 0xF8, 0x0C, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xC0, 0xFE, 0x30,
  0x07, 0xE1, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF4, 0x00, 0x7F, 0x78, 0x1F, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x0F,
  0x9F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x1F,
  0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x40, 0x07, 0xE7,
  0x01, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x87, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0xFE,
  0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x80, 0xF8, 0xFE, 0x07, 0xC3, 0xF8, 0x7C, 0x1F, 0xF7, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFB, 0xFE, 0x0F, 0x83,
  0xF8, 0xF8, 0x0F, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0xC1, 0xFC, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x9F, 0xE7,
  0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7F, 0x03,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x06,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xF9,
  0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E,
  0x7F, 0xBF, 0xDF, 0xFF, 0xF3, 0xF8, 0xF8, 0x10, 0x07, 0x03, 0xF0, 0xFF,
  0x1F, 0xE3, 0xFE, 0x7F, 0x87, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x83, 0xF8, 0xFF, 0x1F, 0xF3,
  0xFE, 0x3F, 0x87, 0xF0, 0x1E, 0x07, 0xC1, 0xF1, 0xFC, 0x7F, 0x0F, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xEF, 0xF3, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3C, 0x00, 0x7D, 0xF0, 0x0F, 0xF7, 0x81, 0xFF, 0xDE, 0x0F, 0xFF,
  0x78, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8,
  0xF8, 0x7F, 0xE7, 0xC1, 0xFF, 0x9F, 0x07, 0xFE, 0x7C, 0x1F, 0xF9, 0xF0,
  0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0x78, 0xFE, 0x7D,
  0xE1, 0xFF, 0xF7, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0x3C, 0x0F, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF1,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0,
  0x07, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x81, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0x83, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xFC,
  0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xE0, 0x18, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x8F, 0xF8, 0x3C, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0x83, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x0F, 0xCF, 0x81, 0xFC, 0xF9, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xC0, 0x38, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xF0,
  0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x03, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x30, 0x0F, 0xEF, 0x83, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x70, 0x00, 0xF8, 0x07, 0xF7, 0xC0, 0x3F,
  0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1,
  0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x01,
  0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFB, 0xF8, 0x07, 0xCF, 0xE0, 0x3E, 0x3F, 0x81, 0xF0, 0xFC, 0x0F,
  0x87, 0xF0, 0x7C, 0x1F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF8, 0xF8, 0x0F,
  0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0xFC,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFE, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xE7, 0xB8, 0x7F, 0x9E, 0xE1, 0xFE,
  0x7B, 0xC7, 0xF9, 0xEF, 0x1D, 0xE7, 0x9C, 0xF7, 0x9E, 0x7B, 0xDE, 0x79,
  0xEE, 0x7D, 0xE3, 0xF9, 0xF7, 0x8F, 0xE7, 0xDE, 0x3F, 0x1F, 0x78, 0xFC,
  0x7D, 0xE1, 0xF1, 0xF7, 0x87, 0xC7, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xBE, 0x1F, 0xFB, 0xE1, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x1F,
  0xF8, 0xF9, 0xFF, 0x87, 0x9F, 0xF8, 0x7D, 0xFF, 0x83, 0xDF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F,
  0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0x3E, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0xFE, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x83, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7C, 0x0F, 0xE3, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xF8,
  0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E,
  0x7C, 0x07, 0xE3, 0xE0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x83,
  0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xEF,
  0xC7, 0xE0, 0x0C, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF2, 0x00, 0x3F, 0x78, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x2F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0x7E, 0x03,
  0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0xDE, 0x1F, 0x1F, 0x78, 0x7C, 0x7D, 0xE3, 0xF1, 0xF7, 0x8F,
  0xE7, 0xDE, 0x3F, 0x9F, 0x79, 0xEE, 0x7D, 0xE7, 0xB9, 0xF7, 0x9E, 0xF7,
  0x9E, 0x71, 0xDE, 0x7B, 0xC7, 0x79, 0xEF, 0x1F, 0xE7, 0xB8, 0x7F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE0, 0xFE, 0x00, 0xFC, 0xFC, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7C,
  0x03, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xBE, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF,
  0x00, 0x1F, 0x9E, 0x00, 0x3C, 0x08, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20,
  0x1E, 0x07, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0xF8, 0x0C, 0x01, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7E, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x3F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x60, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xC3, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0, 0x30, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0x0F, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB,
  0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x3E, 0xFF, 0x07, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xC3, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x20, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xEF, 0xE0, 0xFD, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x78, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFD, 0x00, 0x3F, 0xBF, 0x1F, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x3C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0x00, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFC, 0x0F,
  0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x18,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x60, 0x3F, 0x7E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F,
  0xF0, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0xFE, 0x7E,
  0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0,
  0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0x80,
  0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x38, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xC0, 0xFF, 0xCF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x1F, 0x9F, 0xF8, 0x78, 0x7F, 0xC3, 0xE3, 0xFE, 0x1F, 0x0F,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F,
  0x87, 0xF8, 0x7C, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFF, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFC, 0x30, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x0F,
  0xBF, 0x87, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x43, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x70, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x07,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0xFD, 0x00, 0x1F, 0xFC, 0x07, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC3, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x81,
  0xF7, 0xF0, 0x7D, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x01, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x3F,
  0x00, 0xFC, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xF7, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0x87, 0xBE, 0x1F, 0x0F, 0x7C, 0x3E, 0x1E, 0x78, 0xFC, 0x3C, 0xF1,
  0xFC, 0x79, 0xE3, 0xF8, 0xF3, 0xC7, 0xF3, 0xE7, 0x9F, 0xE7, 0x8F, 0x3D,
  0xEF, 0x1F, 0x73, 0xDE, 0x1F, 0xE7, 0xBC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF8, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xF7, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01,
  0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x06, 0x7F,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x38, 0x3F, 0xE0, 0x7C,
  0xFF, 0xF1, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x0F, 0xFF, 0x3E,
  0x07, 0xFC, 0x18, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 8, 31, 25, 8, -30 },
  { 32, 15, 13, 25, 5, -33 },
  { 57, 23, 30, 25, 1, -30 },
  { 144, 21, 39, 25, 2, -34 },
  { 247, 24, 32, 25, 0, -31 },
  { 343, 23, 31, 25, 1, -31 },
  { 433, 6, 14, 25, 9, -33 },
  { 444, 15, 43, 25, 5, -35 },
  { 525, 15, 43, 25, 5, -35 },
  { 606, 20, 18, 25, 2, -30 },
  { 651, 21, 22, 25, 2, -24 },
  { 709, 10, 15, 25, 7, -8 },
  { 728, 13, 5, 25, 6, -15 },
  { 737, 9, 9, 25, 8, -8 },
  { 748, 19, 42, 25, 3, -34 },
  { 848, 21, 32, 25, 2, -31 },
  { 932, 19, 30, 25, 3, -30 },
  { 1004, 20, 31, 25, 2, -31 },
  { 1082, 20, 32, 25, 2, -31 },
  { 1162, 22, 30, 25, 1, -30 },
  { 1245, 20, 31, 25, 2, -30 },
  { 1323, 20, 32, 25, 2, -31 },
  { 1403, 19, 30, 25, 3, -30 },
  { 1475, 21, 32, 25, 2, -31 },
  { 1559, 20, 31, 25, 2, -31 },
  { 1637, 9, 24, 25, 8, -23 },
  { 1664, 11, 30, 25, 6, -23 },
  { 1706, 21, 21, 25, 2, -23 },
  { 1762, 21, 14, 25, 2, -20 },
  { 1799, 21, 21, 25, 2, -23 },
  { 1855, 17, 32, 25, 4, -31 },
  { 1923, 22, 38, 25, 1, -31 },
  { 2028, 24, 30, 25, 0, -30 },
  { 2118, 20, 31, 25, 3, -31 },
  { 2196, 21, 32, 25, 2, -31 },
  { 2280, 20, 31, 25, 3, -31 },
  { 2358, 19, 30, 25, 4, -30 },
  { 2430, 18, 30, 25, 4, -30 },
  { 2498, 21, 32, 25, 2, -31 },
  { 2582, 20, 30, 25, 2, -30 },
  { 2657, 19, 30, 25, 3, -30 },
  { 2729, 19, 31, 25, 2, -30 },
  { 2803, 21, 30, 25, 3, -30 },
  { 2882, 19, 30, 25, 4, -30 },
  { 2954, 22, 30, 25, 1, -30 },
  { 3037, 20, 30, 25, 2, -30 },
  { 3112, 22, 32, 25, 1, -31 },
  { 3200, 20, 31, 25, 3, -31 },
  { 3278, 22, 39, 25, 1, -31 },
  { 3386, 21, 31, 25, 3, -31 },
  { 3468, 20, 32, 25, 2, -31 },
  { 3548, 22, 30, 25, 1, -30 },
  { 3631, 21, 31, 25, 2, -30 },
  { 3713, 23, 30, 25, 1, -30 },
  { 3800, 22, 30, 25, 1, -30 },
  { 3883, 23, 30, 25, 1, -30 },
  { 3970, 23, 30, 25, 1, -30 },
  { 4057, 20, 30, 25, 2, -30 },
  { 4132, 13, 42, 25, 6, -34 },
  { 4201, 19, 42, 25, 3, -34 },
  { 4301, 14, 42, 25, 5, -34 },
  { 4375, 23, 17, 25, 1, -30 },
  { 4424, 24, 5, 25, 0, 3 },
  { 4439, 10, 9, 25, 8, -34 },
  { 4451, 20, 25, 25, 2, -24 },
  { 4514, 20, 35, 25, 3, -34 },
  { 4602, 21, 25, 25, 2, -24 },
  { 4668, 19, 35, 25, 2, -34 },
  { 4752, 21, 25, 25, 2, -24 },
  { 4818, 22, 34, 25, 2, -34 },
  { 4912, 19, 32, 25, 2, -24 },
  { 4988, 19, 34, 25, 3, -34 },
  { 5069, 21, 35, 25, 2, -34 },
  { 5161, 16, 42, 25, 3, -34 },
  { 5245, 21, 34, 25, 3, -34 },
  { 5335, 21, 35, 25, 2, -34 },
  { 5427, 21, 23, 25, 2, -23 },
  { 5488, 19, 24, 25, 3, -24 },
  { 5545, 21, 25, 25, 2, -24 },
  { 5611, 20, 32, 25, 3, -24 },
  { 5691, 19, 32, 25, 2, -24 },
  { 5767, 17, 24, 25, 5, -24 },
  { 5818, 19, 25, 25, 3, -24 },
  { 5878, 21, 31, 25, 2, -30 },
  { 5960, 18, 24, 25, 3, -23 },
  { 6014, 23, 23, 25, 1, -23 },
  { 6081, 23, 23, 25, 1, -23 },
  { 6148, 23, 23, 25, 1, -23 },
  { 6215, 22, 31, 25, 1, -23 },
  { 6301, 18, 23, 25, 3, -23 },
  { 6353, 18, 42, 25, 3, -34 },
  { 6448, 5, 42, 25, 10, -34 },
  { 6475, 18, 42, 25, 3, -34 },
  { 6570, 23, 8, 25, 1, -17 },
};

const GFXfont UbuntuSansMono_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_SEMIBOLD44PT7B_H_
