#ifndef _UBUNTUSANSMONO_SEMIBOLD16PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x90, 0x5F, 0x80, 0xDE, 0xF7, 0xB8, 0x80, 0x1B, 0x09,
  0x84, 0xDF, 0xF3, 0x61, 0xB0, 0x99, 0xFF, 0x64, 0x36, 0x1B, 0x00, 0x10,
  0x79, 0xFE, 0x0C, 0x1E, 0x1F, 0x07, 0x07, 0x0F, 0xFB, 0xC1, 0x02, 0x00,
  0x71, 0xE9, 0xB4, 0x9A, 0x87, 0xC0, 0x40, 0x7C, 0x6B, 0x25, 0xB2, 0xF1,
  0xC0, 0x3C, 0x33, 0x19, 0x8D, 0x83, 0xC1, 0xD9, 0xFD, 0x9E, 0xC6, 0x37,
  0x8F, 0xE0, 0xFD, 0x24, 0x08, 0xCC, 0xC6, 0x63, 0x18, 0xC6, 0x31, 0x86,
  0x38, 0xE1, 0x86, 0x18, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x33, 0x3B, 0x90,
  0x11, 0x27, 0xFB, 0xE2, 0x8D, 0x8A, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2,
  0x04, 0x08, 0x37, 0x73, 0xE4, 0xFF, 0xC0, 0xDF, 0x80, 0x06, 0x0C, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0x7D,
  0xDF, 0x1E, 0x3D, 0x7F, 0xF1, 0xE3, 0xC6, 0xD9, 0xF0, 0x18, 0xF3, 0xE4,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0xFD, 0xF8, 0x7D, 0x98, 0x18, 0x30, 0xC3,
  0x0E, 0x38, 0xE1, 0xFF, 0xF8, 0xFD, 0x98, 0x18, 0x63, 0xC7, 0x83, 0x83,
  0x07, 0xBF, 0xF0, 0x0C, 0x38, 0xF1, 0x66, 0xD9, 0xB3, 0x7F, 0x0C, 0x18,
  0x30, 0x7E, 0xFD, 0x83, 0x07, 0x8F, 0x81, 0x83, 0x07, 0xBF, 0xF0, 0x1C,
  0x7D, 0x86, 0x0F, 0xDF, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xFF, 0xFC, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0x30, 0x61, 0xC0, 0x7D, 0xDF, 0x1E, 0x36, 0xCF,
  0xB3, 0xE3, 0xC7, 0xDD, 0xF0, 0x7D, 0xDF, 0x1E, 0x3C, 0x7F, 0xCF, 0x87,
  0x1D, 0xF1, 0xC0, 0xDF, 0x80, 0x37, 0xE0, 0x67, 0x70, 0x00, 0x27, 0x73,
  0xE8, 0x06, 0x7F, 0xC6, 0x0F, 0x83, 0xC1, 0x80, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0xC1, 0xF0, 0x78, 0x33, 0xFE, 0x30, 0x00, 0xFC, 0x9C, 0x18, 0x61,
  0xC7, 0x0C, 0x00, 0x10, 0x70, 0xC0, 0x3E, 0x33, 0x61, 0x4F, 0x4F, 0xD9,
  0xD9, 0xD9, 0x59, 0x4F, 0x60, 0x30, 0x1F, 0x1C, 0x0E, 0x05, 0x06, 0xC3,
  0x61, 0x31, 0x8C, 0xFE, 0x63, 0x31, 0xB0, 0x60, 0xFD, 0xFF, 0x1E, 0x3F,
  0xDF, 0xB1, 0xE3, 0xC7, 0xFF, 0xF0, 0x3E, 0xEF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xFC, 0xF8, 0xF9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFB, 0xE0, 0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0xFF, 0xF8,
  0xFF, 0xFF, 0x06, 0x0F, 0xDF, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x3E, 0xEF,
  0x06, 0x0C, 0x18, 0xF1, 0xE3, 0xC6, 0xFC, 0xF8, 0xC7, 0x8F, 0x1E, 0x3F,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x39, 0xFF, 0xF8, 0x7E, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0xBB, 0xE0, 0xC6, 0xCC, 0xCC, 0xD8, 0xF0, 0xF0, 0xD8, 0xDC, 0xCE, 0xC6,
  0xC7, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0x63,
  0x31, 0x9D, 0xCA, 0xA5, 0x52, 0xE9, 0x24, 0x82, 0x41, 0x20, 0xB0, 0x60,
  0xC7, 0x8F, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x8F, 0x18, 0x3E, 0x77,
  0x63, 0x63, 0x63, 0xE3, 0x63, 0x63, 0x63, 0x77, 0x3E, 0xFD, 0xFF, 0x1E,
  0x3C, 0x7F, 0xFF, 0x60, 0xC1, 0x83, 0x00, 0x3E, 0x77, 0x63, 0x63, 0x63,
  0xE3, 0x63, 0x63, 0x63, 0x77, 0x3E, 0x08, 0x0F, 0x03, 0xFC, 0xFE, 0xC6,
  0xC6, 0xC6, 0xFC, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0x7F, 0xCB, 0x06, 0x0F,
  0x07, 0x83, 0x83, 0x07, 0x9F, 0xF0, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xDD, 0xF0, 0xC1, 0xB1, 0x98, 0xCC, 0x66, 0x31, 0xB0, 0xD8, 0x6C, 0x14,
  0x0E, 0x07, 0x00, 0xC1, 0xA0, 0x90, 0x48, 0x24, 0x92, 0xE9, 0x54, 0xAA,
  0x77, 0x31, 0x98, 0xC0, 0xE3, 0xB1, 0x8D, 0x86, 0xC1, 0xC0, 0xE0, 0x70,
  0x6C, 0x77, 0x31, 0xB8, 0xE0, 0xE3, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xFC, 0x30, 0xE1, 0x86, 0x0C,
  0x30, 0x61, 0xFF, 0xF8, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0xFF, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x60, 0xC1, 0x81, 0x83, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8F, 0xFF, 0x1C, 0x0E, 0x0D, 0x86, 0xC6, 0x37, 0x1C, 0xFF, 0xFF, 0xC0,
  0xDC, 0x80, 0x38, 0xF8, 0x38, 0x37, 0xF8, 0xF1, 0xF3, 0x7E, 0xC1, 0x83,
  0x06, 0xCF, 0xD8, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xE0, 0x1C, 0xFF, 0x86,
  0x0C, 0x18, 0x30, 0x3F, 0x3E, 0x06, 0x0C, 0x19, 0xB7, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0xFB, 0xF0, 0x18, 0xFB, 0x1E, 0x3F, 0xF8, 0x30, 0x7F, 0x7E,
  0x3F, 0x31, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x18, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xBF, 0x16, 0x0F, 0xF7, 0xC0, 0xC1,
  0x83, 0x06, 0x8F, 0xD9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0x30, 0xE0,
  0x00, 0x0F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0x1C, 0x70, 0x00,
  0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0xCE, 0xCC, 0xD8, 0xF0, 0xD8, 0xCC, 0xCE, 0xC7, 0xF0, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0x45, 0xFE, 0xCC, 0x99,
  0x32, 0x60, 0xC1, 0x82, 0x31, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0x10, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7C, 0x31, 0xFB, 0x3E, 0x3C,
  0x78, 0xF1, 0xFF, 0xFD, 0x83, 0x06, 0x00, 0x18, 0xFF, 0x9E, 0x3C, 0x78,
  0xF1, 0xFF, 0x7E, 0x0C, 0x18, 0x30, 0x3B, 0xFC, 0x70, 0xC3, 0x0C, 0x30,
  0xC0, 0x18, 0xFB, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFC, 0x30, 0x60, 0xC7,
  0xF3, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0xF8, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xFF, 0xBF, 0xE3, 0xB1, 0x98, 0xC6, 0xC3, 0x61, 0xA0, 0x70, 0x38, 0xC1,
  0xE4, 0xD3, 0x4B, 0xA5, 0x52, 0xA9, 0xDC, 0xC6, 0xE3, 0x1B, 0x07, 0x03,
  0x81, 0xC1, 0xB1, 0x8D, 0xC7, 0x63, 0x63, 0x33, 0x36, 0x36, 0x1E, 0x1C,
  0x0C, 0x18, 0x78, 0xF0, 0xFE, 0x18, 0x61, 0xC3, 0x0C, 0x3F, 0xFF, 0x0E,
  0x3C, 0xC1, 0x83, 0x06, 0x0C, 0x78, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0x0E, 0x30, 0x60, 0xC1, 0x83, 0x3E, 0x78, 0x79, 0xBF, 0xB1, 0x80,
};

const GFXglyph UbuntuSansMono_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 14, 9, 1, -12 },
  { 36, 9, 11, 9, 0, -11 },
  { 49, 9, 11, 9, 0, -11 },
  { 62, 3, 5, 9, 3, -12 },
  { 64, 5, 16, 9, 2, -13 },
  { 74, 5, 16, 9, 2, -13 },
  { 84, 7, 7, 9, 1, -11 },
  { 91, 7, 8, 9, 1, -9 },
  { 98, 4, 6, 9, 2, -3 },
  { 101, 5, 2, 9, 2, -6 },
  { 103, 3, 3, 9, 3, -3 },
  { 105, 7, 16, 9, 1, -13 },
  { 119, 7, 11, 9, 1, -11 },
  { 129, 7, 11, 9, 1, -11 },
  { 139, 7, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 7, 11, 9, 1, -11 },
  { 169, 7, 11, 9, 1, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 7, 11, 9, 1, -11 },
  { 199, 7, 11, 9, 1, -11 },
  { 209, 7, 11, 9, 1, -11 },
  { 219, 3, 9, 9, 3, -9 },
  { 223, 4, 12, 9, 2, -9 },
  { 229, 7, 7, 9, 1, -8 },
  { 236, 7, 5, 9, 1, -7 },
  { 241, 7, 7, 9, 1, -8 },
  { 248, 7, 11, 9, 1, -11 },
  { 258, 8, 13, 9, 0, -11 },
  { 271, 9, 11, 9, 0, -11 },
  { 284, 7, 11, 9, 1, -11 },
  { 294, 7, 11, 9, 1, -11 },
  { 304, 7, 11, 9, 1, -11 },
  { 314, 7, 11, 9, 1, -11 },
  { 324, 7, 11, 9, 1, -11 },
  { 334, 7, 11, 9, 1, -11 },
  { 344, 7, 11, 9, 1, -11 },
  { 354, 7, 11, 9, 1, -11 },
  { 364, 7, 11, 9, 1, -11 },
  { 374, 8, 11, 9, 1, -11 },
  { 385, 7, 11, 9, 1, -11 },
  { 395, 9, 11, 9, 0, -11 },
  { 408, 7, 11, 9, 1, -11 },
  { 418, 8, 11, 9, 0, -11 },
  { 429, 7, 11, 9, 1, -11 },
  { 439, 8, 14, 9, 0, -11 },
  { 453, 8, 11, 9, 1, -11 },
  { 464, 7, 11, 9, 1, -11 },
  { 474, 7, 11, 9, 1, -11 },
  { 484, 7, 11, 9, 1, -11 },
  { 494, 9, 11, 9, 0, -11 },
  { 507, 9, 11, 9, 0, -11 },
  { 520, 9, 11, 9, 0, -11 },
  { 533, 9, 11, 9, 0, -11 },
  { 546, 7, 11, 9, 1, -11 },
  { 556, 5, 16, 9, 2, -13 },
  { 566, 7, 16, 9, 1, -13 },
  { 580, 5, 16, 9, 2, -13 },
  { 590, 9, 6, 9, 0, -11 },
  { 597, 9, 2, 9, 0, 1 },
  { 600, 3, 3, 9, 3, -12 },
  { 602, 7, 9, 9, 1, -9 },
  { 610, 7, 12, 9, 1, -12 },
  { 621, 7, 9, 9, 1, -9 },
  { 629, 7, 12, 9, 1, -12 },
  { 640, 7, 9, 9, 1, -9 },
  { 648, 8, 12, 9, 1, -12 },
  { 660, 7, 12, 9, 1, -9 },
  { 671, 7, 12, 9, 1, -12 },
  { 682, 7, 12, 9, 1, -12 },
  { 693, 6, 15, 9, 1, -12 },
  { 705, 8, 12, 9, 1, -12 },
  { 717, 7, 12, 9, 1, -12 },
  { 728, 7, 9, 9, 1, -9 },
  { 736, 7, 9, 9, 1, -9 },
  { 744, 7, 9, 9, 1, -9 },
  { 752, 7, 12, 9, 1, -9 },
  { 763, 7, 12, 9, 1, -9 },
  { 774, 6, 9, 9, 2, -9 },
  { 781, 7, 9, 9, 1, -9 },
  { 789, 7, 11, 9, 1, -11 },
  { 799, 7, 8, 9, 1, -8 },
  { 806, 9, 8, 9, 0, -8 },
  { 815, 9, 8, 9, 0, -8 },
  { 824, 9, 8, 9, 0, -8 },
  { 833, 8, 11, 9, 0, -8 },
  { 844, 7, 8, 9, 1, -8 },
  { 851, 7, 16, 9, 1, -13 },
  { 865, 2, 16, 9, 3, -13 },
  { 869, 7, 16, 9, 1, -13 },
  { 883, 9, 3, 9, 0, -6 },
};

const GFXfont UbuntuSansMono_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_SEMIBOLD16PT7B_H_
