#ifndef _UBUNTUSANSMONO_SEMIBOLD32PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1E,
  0x0F, 0x1C, 0x0F, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0xE0, 0x78, 0xE0,
  0x71, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x0C, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x60, 0x1E, 0x7F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x08, 0x00,
  0x4F, 0x80, 0xE7, 0xF0, 0x39, 0xDC, 0x1C, 0x63, 0x0E, 0x38, 0xC3, 0x8E,
  0x31, 0xC1, 0x8C, 0xE0, 0x77, 0x38, 0x1F, 0xDC, 0x03, 0xEE, 0x00, 0x03,
  0x80, 0x01, 0xC4, 0x00, 0xE7, 0xC0, 0x3B, 0xF8, 0x1C, 0xEE, 0x0E, 0x31,
  0x83, 0x9C, 0x61, 0xC3, 0x18, 0x70, 0xC6, 0x38, 0x3B, 0x9C, 0x0F, 0xEF,
  0x01, 0xF0, 0x03, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x3C, 0xF0, 0x38, 0x70,
  0x78, 0x70, 0x78, 0x70, 0x38, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x1F, 0x80,
  0x1F, 0x0E, 0x3F, 0x8E, 0x7F, 0xCE, 0xF3, 0xFE, 0xF1, 0xFE, 0xE0, 0xFC,
  0xE0, 0x7C, 0xF0, 0x3C, 0xF0, 0x7C, 0x7F, 0xFE, 0x7F, 0xEF, 0x1F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x01, 0x80, 0x78, 0x1F, 0x87, 0xC1, 0xF0,
  0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x20,
  0x30, 0x0F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xE0,
  0x7C, 0x1F, 0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x18, 0xE6, 0xFB, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x7F,
  0x83, 0xCF, 0x1F, 0x3E, 0x18, 0x60, 0x21, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x18, 0x7D, 0xFB, 0xF3, 0xE7, 0xC3, 0x8F, 0x7D, 0xF3, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF1,
  0x8E, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0E, 0x70,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0x3C, 0x10, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x07, 0x00, 0xFF, 0x8F, 0xFF, 0x3F,
  0xFE, 0x70, 0xF9, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x01, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x60, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xF0, 0x3E, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xB8, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x3C, 0x38,
  0x38, 0x38, 0x78, 0x38, 0x70, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x7F, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xFC, 0x0F, 0xBF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x00, 0x00, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xF0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF7, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x3F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1F,
  0xE0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x7C, 0x1C, 0x7C, 0x78, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x87, 0x9F, 0x9E,
  0x0F, 0xBC, 0x0F, 0x70, 0x0F, 0xE0, 0x1D, 0xE0, 0x7B, 0xE1, 0xF7, 0xFF,
  0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0xF8, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83,
  0xDF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0xF3, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x3F, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0xC0, 0x00, 0x33, 0xEF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0xFB, 0xFF, 0xFF, 0x78, 0x0C,
  0x3E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1F, 0x07, 0x0E, 0x7C, 0xF8, 0x70, 0x00, 0x04, 0x00,
  0x78, 0x03, 0xF0, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x7C, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xD0, 0x1F, 0xC0, 0x0F, 0x80,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0xFC, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x0F, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0x41, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x3C, 0x0E, 0x78,
  0x0E, 0x70, 0x0F, 0x70, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7,
  0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE7, 0x8F, 0xE3,
  0x8F, 0xE3, 0xFF, 0xF3, 0xFF, 0x71, 0xFF, 0x70, 0x7C, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x02, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0x73,
  0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1E,
  0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xF0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0E,
  0x78, 0x3C, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0x07, 0xDE,
  0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC3, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFE, 0x3E, 0x06, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x06, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x07,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0,
  0xFB, 0xC7, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x06, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF8, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x7C, 0x0E, 0x3E,
  0x0E, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x79, 0x01, 0xE6, 0x0F, 0xBF, 0xFC,
  0xFF, 0xF1, 0xFF, 0x00, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8,
  0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xF7, 0xC0, 0xF3, 0xE0, 0xF3, 0xE0, 0xF1, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E,
  0x7E, 0x7E, 0x76, 0x6E, 0x76, 0xEE, 0xF7, 0xEE, 0xF7, 0xEE, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFB, 0x87, 0xEF, 0x1F,
  0x9C, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0xDF, 0x87, 0x7E, 0x1F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x70, 0x01,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7B, 0xC3, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x0E, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xCF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xFC, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1,
  0xF7, 0x81, 0xEF, 0x03, 0xFE, 0x03, 0xC0, 0x03, 0x80, 0x7F, 0xE3, 0xFF,
  0x9F, 0xFE, 0xF8, 0x13, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xFB, 0xFF, 0xE7, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0xC1,
  0xFE, 0x00, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1C, 0x0E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x1C, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF7, 0xEE, 0xF7, 0xEE, 0x76, 0x6E, 0x7E, 0x6E, 0x7E, 0x7E,
  0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x0F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xDE, 0x01,
  0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x0F,
  0x70, 0x0E, 0x10, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x40, 0xC3, 0xC7, 0xE3, 0xE1, 0x81, 0x00, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x88, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xDF, 0xFF,
  0x3F, 0xFC, 0x30, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x1F, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF,
  0xE0, 0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3, 0xF0, 0x6F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F,
  0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0x1F, 0x78, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x78, 0x3D, 0xF0, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E,
  0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7E, 0x04, 0x3F, 0xFC, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB, 0xF0,
  0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7B, 0xC0, 0xF7, 0xE7, 0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xEF, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF3, 0xCF, 0xE7, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0,
  0x00, 0x30, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x3E, 0xF0, 0x7B,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x03, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC2, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x40, 0xF7, 0xBF, 0xFF, 0xEF, 0xFC, 0x3F, 0x80, 0x30, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7, 0x8F, 0x8F, 0x1E, 0x1E, 0x78,
  0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xEF, 0x83, 0xCF, 0x87, 0x8F, 0x0F,
  0x0F, 0x1E, 0x1F, 0x3C, 0x1F, 0x78, 0x1E, 0xF0, 0x3E, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC2, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x7E,
  0x7C, 0xFF, 0xFE, 0xFF, 0xFE, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3,
  0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x7F, 0xC3, 0xFF,
  0xCF, 0xFF, 0xBE, 0x7E, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x78,
  0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF,
  0x03, 0xDF, 0x0F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xE1, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xFC, 0xFF, 0xFB, 0xF0, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x87, 0xCF,
  0xFF, 0x9F, 0xFF, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0xE7, 0xFF, 0x9F, 0x0C, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3D, 0x81, 0xFF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x10, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xF0, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x1E, 0x3B,
  0x8F, 0x1D, 0xC7, 0x8E, 0xE3, 0xCF, 0x7B, 0xF7, 0x1D, 0xFB, 0x8E, 0xDD,
  0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1C,
  0x0E, 0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x78,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1E, 0xF8, 0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x3E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF8, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x4F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x0F, 0xE0, 0x3E, 0x00, 0xFE, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x00, 0x08, 0x00, 0x3F, 0x07, 0x7F, 0xCF,
  0x7F, 0xFF, 0xF3, 0xFE, 0xE0, 0xFC, 0x20, 0x18,
};

const GFXglyph UbuntuSansMono_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 10, 9, 18, 4, -24 },
  { 30, 16, 22, 18, 1, -22 },
  { 74, 16, 28, 18, 1, -25 },
  { 130, 18, 23, 18, 0, -23 },
  { 182, 16, 23, 18, 1, -23 },
  { 228, 4, 10, 18, 7, -24 },
  { 233, 11, 31, 18, 4, -25 },
  { 276, 11, 31, 18, 3, -25 },
  { 319, 14, 14, 18, 2, -22 },
  { 344, 15, 16, 18, 1, -17 },
  { 374, 7, 11, 18, 5, -6 },
  { 384, 10, 4, 18, 4, -11 },
  { 389, 6, 6, 18, 6, -6 },
  { 394, 14, 31, 18, 2, -25 },
  { 449, 16, 23, 18, 1, -23 },
  { 495, 14, 22, 18, 2, -22 },
  { 534, 14, 23, 18, 2, -23 },
  { 575, 14, 23, 18, 2, -23 },
  { 616, 16, 22, 18, 1, -22 },
  { 660, 14, 22, 18, 2, -22 },
  { 699, 14, 22, 18, 2, -22 },
  { 738, 14, 22, 18, 2, -22 },
  { 777, 15, 23, 18, 1, -23 },
  { 821, 14, 23, 18, 2, -23 },
  { 862, 6, 17, 18, 6, -17 },
  { 875, 8, 22, 18, 4, -17 },
  { 897, 15, 15, 18, 2, -17 },
  { 926, 15, 11, 18, 1, -15 },
  { 947, 14, 15, 18, 2, -17 },
  { 974, 12, 23, 18, 3, -23 },
  { 1009, 16, 28, 18, 1, -23 },
  { 1065, 18, 22, 18, 0, -22 },
  { 1115, 15, 22, 18, 2, -22 },
  { 1157, 16, 23, 18, 1, -23 },
  { 1203, 15, 22, 18, 2, -22 },
  { 1245, 13, 22, 18, 3, -22 },
  { 1281, 13, 22, 18, 3, -22 },
  { 1317, 16, 23, 18, 1, -23 },
  { 1363, 14, 22, 18, 2, -22 },
  { 1402, 14, 22, 18, 2, -22 },
  { 1441, 14, 22, 18, 2, -22 },
  { 1480, 16, 22, 18, 2, -22 },
  { 1524, 13, 22, 18, 3, -22 },
  { 1560, 16, 22, 18, 1, -22 },
  { 1604, 14, 22, 18, 2, -22 },
  { 1643, 16, 23, 18, 1, -23 },
  { 1689, 15, 22, 18, 2, -22 },
  { 1731, 16, 29, 18, 1, -23 },
  { 1789, 15, 22, 18, 2, -22 },
  { 1831, 14, 23, 18, 2, -23 },
  { 1872, 16, 22, 18, 1, -22 },
  { 1916, 15, 22, 18, 1, -22 },
  { 1958, 18, 22, 18, 0, -22 },
  { 2008, 16, 22, 18, 1, -22 },
  { 2052, 16, 22, 18, 1, -22 },
  { 2096, 18, 22, 18, 0, -22 },
  { 2146, 14, 22, 18, 2, -22 },
  { 2185, 10, 31, 18, 4, -25 },
  { 2224, 14, 31, 18, 2, -25 },
  { 2279, 10, 31, 18, 4, -25 },
  { 2318, 16, 13, 18, 1, -22 },
  { 2344, 18, 4, 18, 0, 2 },
  { 2353, 7, 7, 18, 6, -25 },
  { 2360, 14, 17, 18, 2, -17 },
  { 2390, 15, 25, 18, 2, -25 },
  { 2437, 15, 17, 18, 2, -17 },
  { 2469, 14, 25, 18, 1, -25 },
  { 2513, 16, 17, 18, 1, -17 },
  { 2547, 16, 25, 18, 2, -25 },
  { 2597, 15, 23, 18, 1, -17 },
  { 2641, 14, 25, 18, 2, -25 },
  { 2685, 16, 25, 18, 1, -25 },
  { 2735, 12, 31, 18, 2, -25 },
  { 2782, 15, 25, 18, 2, -25 },
  { 2829, 16, 25, 18, 1, -25 },
  { 2879, 16, 17, 18, 1, -17 },
  { 2913, 14, 17, 18, 2, -17 },
  { 2943, 16, 17, 18, 1, -17 },
  { 2977, 15, 23, 18, 2, -17 },
  { 3021, 15, 23, 18, 1, -17 },
  { 3065, 13, 17, 18, 3, -17 },
  { 3093, 14, 17, 18, 2, -17 },
  { 3123, 15, 22, 18, 2, -22 },
  { 3165, 14, 17, 18, 2, -17 },
  { 3195, 16, 17, 18, 1, -17 },
  { 3229, 17, 17, 18, 0, -17 },
  { 3266, 16, 17, 18, 1, -17 },
  { 3300, 16, 23, 18, 1, -17 },
  { 3346, 14, 17, 18, 2, -17 },
  { 3376, 14, 31, 18, 2, -25 },
  { 3431, 4, 31, 18, 7, -25 },
  { 3447, 13, 31, 18, 2, -25 },
  { 3498, 16, 7, 18, 1, -13 },
};

const GFXfont UbuntuSansMono_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_SEMIBOLD32PT7B_H_
