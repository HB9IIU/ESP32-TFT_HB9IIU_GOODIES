#ifndef _UBUNTUSANSMONO_SEMIBOLD61PT7B_H_
#define _UBUNTUSANSMONO_SEMIBOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-SemiBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_SemiBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xE1, 0xE0, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE,
  0xFF, 0xC3, 0xFE, 0x00, 0x38, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF2, 0x00, 0x00, 0xFF, 0x38, 0x00, 0x1F, 0xF7, 0xF8, 0x07, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x1F, 0x8F, 0xFE, 0x00,
  0x0F, 0x8F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xC0, 0x0F, 0xC7, 0xE3, 0xE0,
  0x07, 0xC3, 0xE1, 0xF8, 0x07, 0xE1, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x3E,
  0x03, 0xF0, 0x7C, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x1F, 0x07,
  0xC1, 0xF8, 0x0F, 0x83, 0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0xF8, 0x03, 0xF1,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0xFC, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x3F,
  0xFE, 0x7E, 0x00, 0x0F, 0xFE, 0x7E, 0x00, 0x03, 0xFE, 0x3E, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x0F, 0xCF, 0xFE,
  0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0xC0, 0x07, 0xE3, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x7C, 0x03, 0xF0, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0x1F,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0xFC, 0x01,
  0xF0, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x7E, 0x00, 0x7F, 0xFC, 0x7E, 0x00,
  0x1F, 0xFE, 0x3E, 0x00, 0x0F, 0xFE, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x1F,
  0x00, 0xFF, 0xC0, 0x3F, 0x03, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC,
  0x3F, 0xFF, 0xC3, 0xF8, 0xFF, 0x7F, 0xC7, 0xE1, 0xFC, 0x7F, 0xCF, 0xC7,
  0xF8, 0x7F, 0xDF, 0x8F, 0xE0, 0x7F, 0xFF, 0x1F, 0xC0, 0x7F, 0xFC, 0x3F,
  0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x7F, 0xC1, 0xFC,
  0x00, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0x0F, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFD, 0xFC, 0x1F, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE,
  0x07, 0xF8, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x01,
  0xF8, 0x00, 0x3C, 0x1F, 0x81, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x8F, 0x9F,
  0xE7, 0xFE, 0xF3, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF9, 0xFE, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x0F, 0xF8, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0x60, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x7C, 0x3F,
  0xBF, 0x87, 0xE1, 0xFD, 0xFC, 0x7F, 0x8F, 0xEF, 0xE3, 0xFC, 0x7F, 0xFF,
  0x1F, 0xE3, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xC3, 0xF0, 0xFF, 0xFE, 0x0F,
  0x87, 0xF7, 0xF0, 0x10, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xCF, 0xF0, 0x07, 0xE1, 0xFE, 0x00, 0x70, 0x3F, 0xC0, 0x08, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0x83, 0xF0, 0x0F,
  0xFC, 0x1C, 0x00, 0x7F, 0xC1, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xC3, 0xFF, 0x81, 0xE0, 0x0F, 0xF8, 0x10, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE4, 0x00, 0x03, 0xFE, 0x78, 0x00,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7E, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFD, 0x00,
  0x00, 0xFF, 0xBC, 0x00, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC3, 0xFF, 0x07, 0xF8, 0x1F, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xE7, 0xFF, 0xC3, 0xFC, 0x0F, 0xFC, 0x7F, 0x80, 0x3F,
  0xE7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xF0,
  0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC7, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3, 0xFC, 0x06, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0x07, 0xFF, 0x30, 0x01, 0xFF, 0x20, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x01, 0xFF, 0xF7, 0xE0,
  0x1F, 0xFF, 0xDF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xFC, 0x3F, 0xC1,
  0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F,
  0xFC, 0x3F, 0x81, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF,
  0x0F, 0xC0, 0x7F, 0xFC, 0x3F, 0x81, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xC3,
  0xF8, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F,
  0x87, 0xFF, 0xC1, 0xFF, 0xFF, 0xDF, 0x83, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF,
  0xFD, 0xF8, 0x1F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFE,
  0x3F, 0x80, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xCF, 0xE0, 0x03, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0xFE, 0x01, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF,
  0x03, 0xFF, 0x00, 0x1C, 0x1F, 0xF8, 0x00, 0x10, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x04, 0x0F, 0xFE, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xFE,
  0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0xFF, 0xCF, 0xE0, 0x1F,
  0xF8, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xC1, 0xFF, 0x80, 0x0E,
  0x1F, 0xF8, 0x00, 0x10, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF,
  0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0xF0, 0x07, 0xF0, 0xFF, 0xC0, 0x3F, 0x87, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC2, 0x00,
  0x07, 0xF8, 0xE0, 0x01, 0xFF, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xDF, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xF0,
  0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xBE, 0x1F,
  0x7E, 0x7E, 0xF8, 0x7D, 0xF9, 0xFB, 0xE1, 0xF7, 0xE7, 0xE7, 0xCF, 0xDF,
  0x9F, 0x9F, 0x3E, 0x7E, 0x7E, 0x7C, 0xF9, 0xF9, 0xF9, 0xF3, 0xE7, 0xE7,
  0xE3, 0xFF, 0x1F, 0x9F, 0x8F, 0xFC, 0x7E, 0x7E, 0x3F, 0xF1, 0xF9, 0xF8,
  0x7F, 0xC7, 0xF7, 0xE1, 0xFE, 0x1F, 0xDF, 0x87, 0xF8, 0x7F, 0xFE, 0x1F,
  0xE1, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0xFE, 0x07, 0xFF, 0xE7,
  0xE0, 0x7F, 0xFE, 0x7F, 0x07, 0xFF, 0xE3, 0xF0, 0x7F, 0xFE, 0x1F, 0x87,
  0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xC7, 0xFF, 0xE0, 0xFC, 0x7F, 0xFE,
  0x07, 0xE7, 0xFF, 0xE0, 0x7E, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x07,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0xFE, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x3F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC0, 0x3F, 0xF0, 0xFE, 0x00, 0xFF, 0x87, 0xF0, 0x03, 0xFE,
  0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x01, 0xFF,
  0x0F, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03,
  0xFC, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F,
  0x87, 0xFC, 0x00, 0x30, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF3, 0x00, 0x01, 0xFF, 0x3E, 0x00, 0x3F, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1, 0xFF, 0xF8,
  0x7F, 0x87, 0xF7, 0xE1, 0xFE, 0x1F, 0xDF, 0x87, 0xF8, 0x7F, 0x7E, 0x1F,
  0xF1, 0xF9, 0xF8, 0xFF, 0xC7, 0xE7, 0xE3, 0xFF, 0x1F, 0x9F, 0x8F, 0xFC,
  0x7E, 0x7E, 0x7E, 0xF9, 0xF9, 0xF9, 0xF3, 0xE7, 0xE7, 0xE7, 0xCF, 0x9F,
  0x9F, 0xBF, 0x1F, 0x7E, 0x7E, 0xF8, 0x7D, 0xF9, 0xFB, 0xE1, 0xF7, 0xE7,
  0xEF, 0x83, 0xFF, 0x9F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x3F, 0x07,
  0x80, 0x00, 0x78, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xF8,
  0x07, 0xC0, 0x0F, 0x00, 0x08, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x40, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0x07,
  0xF7, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0x00, 0x3F,
  0xBF, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x07, 0x80, 0x0F, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0x80, 0x1C, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x1C, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0x83, 0xF8, 0x07, 0xFF, 0x7F, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xCF, 0xF0, 0x03, 0xFB, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xDF, 0xF0, 0x03, 0xF9, 0xFF, 0x00, 0x7F, 0x3F, 0xF0, 0x0F, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x1E, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0x80, 0x3F, 0xC0, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF7, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x10, 0x00, 0x3F,
  0xE3, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x70, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xF8, 0x1F, 0xFB, 0xF8, 0x03,
  0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x70, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x40, 0x03, 0xFC, 0xC0, 0x0F,
  0xF3, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0xFE, 0x00, 0x7F, 0xCF,
  0xE0, 0x0F, 0xF8, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xE7, 0xFC, 0x00, 0xFE,
  0x3F, 0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F,
  0x80, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00,
  0x3F, 0xEF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x70, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x3F, 0xFC, 0x7F, 0xC3, 0xFF, 0xFB, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xE1, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1,
  0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F,
  0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF,
  0x83, 0xF0, 0x3F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xE0,
  0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xFC, 0x07, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0xFC, 0xFE, 0x00,
  0xFF, 0x9F, 0xC0, 0x0F, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xDF, 0xC0, 0x0F, 0xF3, 0xFE,
  0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x1F, 0xC1,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xF0, 0x01, 0xF0, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x01, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xD8, 0x00, 0x0F, 0xF7, 0xC0, 0x07, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x04, 0x01, 0xFF, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x07, 0xE0,
  0x7F, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0,
  0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF8,
  0x7E, 0x3F, 0x1F, 0xF8, 0x7E, 0x3F, 0x1F, 0xF8, 0x7C, 0x3F, 0x1F, 0xFC,
  0xFC, 0x3F, 0x1F, 0xFC, 0xFC, 0x3F, 0x3E, 0x7C, 0xFC, 0x3F, 0x3E, 0x7C,
  0xFC, 0x3F, 0x3E, 0x7E, 0xFC, 0x1F, 0x7C, 0x3E, 0xF8, 0x1F, 0x7C, 0x3E,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x40, 0x1F, 0xF8, 0x00, 0xF8, 0x7F, 0xFC, 0x01, 0xF9,
  0xFF, 0xFC, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xF1, 0xF8,
  0x03, 0xFF, 0xC1, 0xF0, 0x01, 0xFF, 0x00, 0x40, 0x00, 0xF8, 0x00,
};

const GFXglyph UbuntuSansMono_SemiBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 43, 34, 12, -42 },
  { 55, 20, 18, 34, 7, -46 },
  { 100, 32, 42, 34, 1, -42 },
  { 268, 28, 54, 34, 3, -47 },
  { 457, 33, 44, 34, 1, -43 },
  { 639, 31, 44, 34, 2, -43 },
  { 810, 8, 19, 34, 13, -46 },
  { 829, 21, 60, 34, 7, -48 },
  { 987, 21, 60, 34, 6, -48 },
  { 1145, 28, 26, 34, 3, -42 },
  { 1236, 28, 30, 34, 3, -33 },
  { 1341, 15, 21, 34, 9, -11 },
  { 1381, 18, 7, 34, 8, -21 },
  { 1397, 12, 12, 34, 11, -11 },
  { 1415, 27, 59, 34, 4, -48 },
  { 1615, 29, 44, 34, 3, -43 },
  { 1775, 27, 42, 34, 4, -42 },
  { 1917, 28, 43, 34, 3, -43 },
  { 2068, 28, 44, 34, 3, -43 },
  { 2222, 30, 42, 34, 2, -42 },
  { 2380, 27, 43, 34, 3, -42 },
  { 2526, 28, 44, 34, 3, -43 },
  { 2680, 27, 42, 34, 4, -42 },
  { 2822, 28, 44, 34, 3, -43 },
  { 2976, 28, 43, 34, 3, -43 },
  { 3127, 12, 33, 34, 11, -32 },
  { 3177, 15, 42, 34, 8, -32 },
  { 3256, 29, 29, 34, 3, -32 },
  { 3362, 28, 20, 34, 3, -28 },
  { 3432, 28, 29, 34, 3, -32 },
  { 3534, 24, 44, 34, 5, -43 },
  { 3666, 30, 52, 34, 2, -43 },
  { 3861, 33, 42, 34, 1, -42 },
  { 4035, 28, 43, 34, 4, -43 },
  { 4186, 30, 44, 34, 2, -43 },
  { 4351, 28, 43, 34, 4, -43 },
  { 4502, 26, 42, 34, 5, -42 },
  { 4639, 25, 42, 34, 5, -42 },
  { 4771, 29, 44, 34, 2, -43 },
  { 4931, 28, 42, 34, 3, -42 },
  { 5078, 26, 42, 34, 4, -42 },
  { 5215, 27, 43, 34, 3, -42 },
  { 5361, 30, 42, 34, 3, -42 },
  { 5519, 26, 42, 34, 5, -42 },
  { 5656, 30, 42, 34, 2, -42 },
  { 5814, 28, 42, 34, 3, -42 },
  { 5961, 30, 44, 34, 2, -43 },
  { 6126, 28, 43, 34, 4, -43 },
  { 6277, 30, 54, 34, 2, -43 },
  { 6480, 29, 43, 34, 4, -43 },
  { 6636, 28, 44, 34, 3, -43 },
  { 6790, 30, 42, 34, 2, -42 },
  { 6948, 28, 43, 34, 3, -42 },
  { 7099, 32, 42, 34, 1, -42 },
  { 7267, 30, 42, 34, 2, -42 },
  { 7425, 32, 42, 34, 1, -42 },
  { 7593, 32, 42, 34, 1, -42 },
  { 7761, 28, 42, 34, 3, -42 },
  { 7908, 18, 59, 34, 8, -48 },
  { 8041, 27, 59, 34, 4, -48 },
  { 8241, 18, 59, 34, 8, -48 },
  { 8374, 31, 24, 34, 2, -42 },
  { 8467, 33, 6, 34, 1, 5 },
  { 8492, 14, 12, 34, 11, -47 },
  { 8513, 27, 34, 34, 3, -33 },
  { 8628, 28, 48, 34, 4, -47 },
  { 8796, 29, 34, 34, 3, -33 },
  { 8920, 27, 48, 34, 2, -47 },
  { 9082, 30, 34, 34, 2, -33 },
  { 9210, 30, 47, 34, 3, -47 },
  { 9387, 28, 44, 34, 2, -33 },
  { 9541, 25, 47, 34, 5, -47 },
  { 9688, 29, 48, 34, 3, -47 },
  { 9862, 23, 59, 34, 4, -47 },
  { 10032, 28, 47, 34, 5, -47 },
  { 10197, 29, 48, 34, 3, -47 },
  { 10371, 30, 32, 34, 2, -32 },
  { 10491, 25, 33, 34, 5, -33 },
  { 10595, 30, 34, 34, 2, -33 },
  { 10723, 27, 44, 34, 5, -33 },
  { 10872, 28, 44, 34, 2, -33 },
  { 11026, 25, 33, 34, 6, -33 },
  { 11130, 26, 34, 34, 4, -33 },
  { 11241, 29, 43, 34, 3, -42 },
  { 11397, 26, 33, 34, 4, -32 },
  { 11505, 32, 32, 34, 1, -32 },
  { 11633, 32, 32, 34, 1, -32 },
  { 11761, 31, 32, 34, 2, -32 },
  { 11885, 30, 43, 34, 2, -32 },
  { 12047, 25, 32, 34, 5, -32 },
  { 12147, 25, 59, 34, 5, -48 },
  { 12332, 8, 59, 34, 13, -48 },
  { 12391, 25, 59, 34, 5, -48 },
  { 12576, 31, 12, 34, 2, -24 },
};

const GFXfont UbuntuSansMono_SemiBold61pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_SemiBold61pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_SemiBold61pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _UBUNTUSANSMONO_SEMIBOLD61PT7B_H_
